.meas tran vdout0_0ck40 FIND v(dout0_0) AT=25.025n

.meas tran vdout0_1ck40 FIND v(dout0_1) AT=25.025n

.meas tran vdout0_2ck40 FIND v(dout0_2) AT=25.025n

.meas tran vdout0_3ck40 FIND v(dout0_3) AT=25.025n

.meas tran vdout0_4ck40 FIND v(dout0_4) AT=25.025n

.meas tran vdout0_5ck40 FIND v(dout0_5) AT=25.025n

.meas tran vdout0_6ck40 FIND v(dout0_6) AT=25.025n

.meas tran vdout0_7ck40 FIND v(dout0_7) AT=25.025n

.meas tran vdout0_8ck40 FIND v(dout0_8) AT=25.025n

.meas tran vdout0_9ck40 FIND v(dout0_9) AT=25.025n

.meas tran vdout0_10ck40 FIND v(dout0_10) AT=25.025n

.meas tran vdout0_11ck40 FIND v(dout0_11) AT=25.025n

.meas tran vdout0_12ck40 FIND v(dout0_12) AT=25.025n

.meas tran vdout0_13ck40 FIND v(dout0_13) AT=25.025n

.meas tran vdout0_14ck40 FIND v(dout0_14) AT=25.025n

.meas tran vdout0_15ck40 FIND v(dout0_15) AT=25.025n

.meas tran vdout0_16ck40 FIND v(dout0_16) AT=25.025n

.meas tran vdout0_17ck40 FIND v(dout0_17) AT=25.025n

.meas tran vdout0_18ck40 FIND v(dout0_18) AT=25.025n

.meas tran vdout0_19ck40 FIND v(dout0_19) AT=25.025n

.meas tran vdout0_20ck40 FIND v(dout0_20) AT=25.025n

.meas tran vdout0_21ck40 FIND v(dout0_21) AT=25.025n

.meas tran vdout0_22ck40 FIND v(dout0_22) AT=25.025n

.meas tran vdout0_23ck40 FIND v(dout0_23) AT=25.025n

.meas tran vdout0_24ck40 FIND v(dout0_24) AT=25.025n

.meas tran vdout0_25ck40 FIND v(dout0_25) AT=25.025n

.meas tran vdout0_26ck40 FIND v(dout0_26) AT=25.025n

.meas tran vdout0_27ck40 FIND v(dout0_27) AT=25.025n

.meas tran vdout0_28ck40 FIND v(dout0_28) AT=25.025n

.meas tran vdout0_29ck40 FIND v(dout0_29) AT=25.025n

.meas tran vdout0_30ck40 FIND v(dout0_30) AT=25.025n

.meas tran vdout0_31ck40 FIND v(dout0_31) AT=25.025n

.meas tran vdout0_32ck40 FIND v(dout0_32) AT=25.025n

.meas tran vdout0_33ck40 FIND v(dout0_33) AT=25.025n

.meas tran vdout0_34ck40 FIND v(dout0_34) AT=25.025n

.meas tran vdout0_35ck40 FIND v(dout0_35) AT=25.025n

.meas tran vdout0_36ck40 FIND v(dout0_36) AT=25.025n

.meas tran vdout0_37ck40 FIND v(dout0_37) AT=25.025n

.meas tran vdout0_38ck40 FIND v(dout0_38) AT=25.025n

.meas tran vdout0_39ck40 FIND v(dout0_39) AT=25.025n

.meas tran vdout0_40ck40 FIND v(dout0_40) AT=25.025n

.meas tran vdout0_41ck40 FIND v(dout0_41) AT=25.025n

.meas tran vdout0_42ck40 FIND v(dout0_42) AT=25.025n

.meas tran vdout0_43ck40 FIND v(dout0_43) AT=25.025n

.meas tran vdout0_44ck40 FIND v(dout0_44) AT=25.025n

.meas tran vdout0_45ck40 FIND v(dout0_45) AT=25.025n

.meas tran vdout0_46ck40 FIND v(dout0_46) AT=25.025n

.meas tran vdout0_47ck40 FIND v(dout0_47) AT=25.025n

.meas tran vdout0_48ck40 FIND v(dout0_48) AT=25.025n

.meas tran vdout0_49ck40 FIND v(dout0_49) AT=25.025n

.meas tran vdout0_50ck40 FIND v(dout0_50) AT=25.025n

.meas tran vdout0_51ck40 FIND v(dout0_51) AT=25.025n

.meas tran vdout0_52ck40 FIND v(dout0_52) AT=25.025n

.meas tran vdout0_53ck40 FIND v(dout0_53) AT=25.025n

.meas tran vdout0_54ck40 FIND v(dout0_54) AT=25.025n

.meas tran vdout0_55ck40 FIND v(dout0_55) AT=25.025n

.meas tran vdout0_56ck40 FIND v(dout0_56) AT=25.025n

.meas tran vdout0_57ck40 FIND v(dout0_57) AT=25.025n

.meas tran vdout0_58ck40 FIND v(dout0_58) AT=25.025n

.meas tran vdout0_59ck40 FIND v(dout0_59) AT=25.025n

.meas tran vdout0_60ck40 FIND v(dout0_60) AT=25.025n

.meas tran vdout0_61ck40 FIND v(dout0_61) AT=25.025n

.meas tran vdout0_62ck40 FIND v(dout0_62) AT=25.025n

.meas tran vdout0_63ck40 FIND v(dout0_63) AT=25.025n

.meas tran vdout0_64ck40 FIND v(dout0_64) AT=25.025n

.meas tran vdout0_65ck40 FIND v(dout0_65) AT=25.025n

.meas tran vdout0_66ck40 FIND v(dout0_66) AT=25.025n

.meas tran vdout0_67ck40 FIND v(dout0_67) AT=25.025n

.meas tran vdout0_68ck40 FIND v(dout0_68) AT=25.025n

.meas tran vdout0_69ck40 FIND v(dout0_69) AT=25.025n

.meas tran vdout0_70ck40 FIND v(dout0_70) AT=25.025n

.meas tran vdout0_71ck40 FIND v(dout0_71) AT=25.025n

.meas tran vdout0_72ck40 FIND v(dout0_72) AT=25.025n

.meas tran vdout0_73ck40 FIND v(dout0_73) AT=25.025n

.meas tran vdout0_74ck40 FIND v(dout0_74) AT=25.025n

.meas tran vdout0_75ck40 FIND v(dout0_75) AT=25.025n

.meas tran vdout0_76ck40 FIND v(dout0_76) AT=25.025n

.meas tran vdout0_77ck40 FIND v(dout0_77) AT=25.025n

.meas tran vdout0_78ck40 FIND v(dout0_78) AT=25.025n

.meas tran vdout0_79ck40 FIND v(dout0_79) AT=25.025n

.meas tran vdout0_80ck40 FIND v(dout0_80) AT=25.025n

.meas tran vdout0_81ck40 FIND v(dout0_81) AT=25.025n

.meas tran vdout0_82ck40 FIND v(dout0_82) AT=25.025n

.meas tran vdout0_83ck40 FIND v(dout0_83) AT=25.025n

.meas tran vdout0_84ck40 FIND v(dout0_84) AT=25.025n

.meas tran vdout0_85ck40 FIND v(dout0_85) AT=25.025n

.meas tran vdout0_86ck40 FIND v(dout0_86) AT=25.025n

.meas tran vdout0_87ck40 FIND v(dout0_87) AT=25.025n

.meas tran vdout0_88ck40 FIND v(dout0_88) AT=25.025n

.meas tran vdout0_89ck40 FIND v(dout0_89) AT=25.025n

.meas tran vdout0_90ck40 FIND v(dout0_90) AT=25.025n

.meas tran vdout0_91ck40 FIND v(dout0_91) AT=25.025n

.meas tran vdout0_92ck40 FIND v(dout0_92) AT=25.025n

.meas tran vdout0_93ck40 FIND v(dout0_93) AT=25.025n

.meas tran vdout0_94ck40 FIND v(dout0_94) AT=25.025n

.meas tran vdout0_95ck40 FIND v(dout0_95) AT=25.025n

.meas tran vdout0_96ck40 FIND v(dout0_96) AT=25.025n

.meas tran vdout0_97ck40 FIND v(dout0_97) AT=25.025n

.meas tran vdout0_98ck40 FIND v(dout0_98) AT=25.025n

.meas tran vdout0_99ck40 FIND v(dout0_99) AT=25.025n

.meas tran vdout0_100ck40 FIND v(dout0_100) AT=25.025n

.meas tran vdout0_101ck40 FIND v(dout0_101) AT=25.025n

.meas tran vdout0_102ck40 FIND v(dout0_102) AT=25.025n

.meas tran vdout0_103ck40 FIND v(dout0_103) AT=25.025n

.meas tran vdout0_104ck40 FIND v(dout0_104) AT=25.025n

.meas tran vdout0_105ck40 FIND v(dout0_105) AT=25.025n

.meas tran vdout0_106ck40 FIND v(dout0_106) AT=25.025n

.meas tran vdout0_107ck40 FIND v(dout0_107) AT=25.025n

.meas tran vdout0_108ck40 FIND v(dout0_108) AT=25.025n

.meas tran vdout0_109ck40 FIND v(dout0_109) AT=25.025n

.meas tran vdout0_110ck40 FIND v(dout0_110) AT=25.025n

.meas tran vdout0_111ck40 FIND v(dout0_111) AT=25.025n

.meas tran vdout0_112ck40 FIND v(dout0_112) AT=25.025n

.meas tran vdout0_113ck40 FIND v(dout0_113) AT=25.025n

.meas tran vdout0_114ck40 FIND v(dout0_114) AT=25.025n

.meas tran vdout0_115ck40 FIND v(dout0_115) AT=25.025n

.meas tran vdout0_116ck40 FIND v(dout0_116) AT=25.025n

.meas tran vdout0_117ck40 FIND v(dout0_117) AT=25.025n

.meas tran vdout0_118ck40 FIND v(dout0_118) AT=25.025n

.meas tran vdout0_119ck40 FIND v(dout0_119) AT=25.025n

.meas tran vdout0_120ck40 FIND v(dout0_120) AT=25.025n

.meas tran vdout0_121ck40 FIND v(dout0_121) AT=25.025n

.meas tran vdout0_122ck40 FIND v(dout0_122) AT=25.025n

.meas tran vdout0_123ck40 FIND v(dout0_123) AT=25.025n

.meas tran vdout0_124ck40 FIND v(dout0_124) AT=25.025n

.meas tran vdout0_125ck40 FIND v(dout0_125) AT=25.025n

.meas tran vdout0_126ck40 FIND v(dout0_126) AT=25.025n

.meas tran vdout0_127ck40 FIND v(dout0_127) AT=25.025n

.meas tran vdout0_128ck40 FIND v(dout0_128) AT=25.025n

.meas tran vdout0_129ck40 FIND v(dout0_129) AT=25.025n

.meas tran vdout0_130ck40 FIND v(dout0_130) AT=25.025n

.meas tran vdout0_131ck40 FIND v(dout0_131) AT=25.025n

.meas tran vdout0_132ck40 FIND v(dout0_132) AT=25.025n

.meas tran vdout0_133ck40 FIND v(dout0_133) AT=25.025n

.meas tran vdout0_134ck40 FIND v(dout0_134) AT=25.025n

.meas tran vdout0_135ck40 FIND v(dout0_135) AT=25.025n

.meas tran vdout0_136ck40 FIND v(dout0_136) AT=25.025n

.meas tran vdout0_137ck40 FIND v(dout0_137) AT=25.025n

.meas tran vdout0_138ck40 FIND v(dout0_138) AT=25.025n

.meas tran vdout0_139ck40 FIND v(dout0_139) AT=25.025n

.meas tran vdout0_140ck40 FIND v(dout0_140) AT=25.025n

.meas tran vdout0_141ck40 FIND v(dout0_141) AT=25.025n

.meas tran vdout0_142ck40 FIND v(dout0_142) AT=25.025n

.meas tran vdout0_143ck40 FIND v(dout0_143) AT=25.025n

.meas tran vdout0_144ck40 FIND v(dout0_144) AT=25.025n

.meas tran vdout0_145ck40 FIND v(dout0_145) AT=25.025n

.meas tran vdout0_146ck40 FIND v(dout0_146) AT=25.025n

.meas tran vdout0_147ck40 FIND v(dout0_147) AT=25.025n

.meas tran vdout0_148ck40 FIND v(dout0_148) AT=25.025n

.meas tran vdout0_149ck40 FIND v(dout0_149) AT=25.025n

.meas tran vdout0_150ck40 FIND v(dout0_150) AT=25.025n

.meas tran vdout0_151ck40 FIND v(dout0_151) AT=25.025n

.meas tran vdout0_152ck40 FIND v(dout0_152) AT=25.025n

.meas tran vdout0_153ck40 FIND v(dout0_153) AT=25.025n

.meas tran vdout0_154ck40 FIND v(dout0_154) AT=25.025n

.meas tran vdout0_155ck40 FIND v(dout0_155) AT=25.025n

.meas tran vdout0_156ck40 FIND v(dout0_156) AT=25.025n

.meas tran vdout0_157ck40 FIND v(dout0_157) AT=25.025n

.meas tran vdout0_158ck40 FIND v(dout0_158) AT=25.025n

.meas tran vdout0_159ck40 FIND v(dout0_159) AT=25.025n

.meas tran vdout0_160ck40 FIND v(dout0_160) AT=25.025n

.meas tran vdout0_161ck40 FIND v(dout0_161) AT=25.025n

.meas tran vdout0_162ck40 FIND v(dout0_162) AT=25.025n

.meas tran vdout0_163ck40 FIND v(dout0_163) AT=25.025n

.meas tran vdout0_164ck40 FIND v(dout0_164) AT=25.025n

.meas tran vdout0_165ck40 FIND v(dout0_165) AT=25.025n

.meas tran vdout0_166ck40 FIND v(dout0_166) AT=25.025n

.meas tran vdout0_167ck40 FIND v(dout0_167) AT=25.025n

.meas tran vdout0_168ck40 FIND v(dout0_168) AT=25.025n

.meas tran vdout0_169ck40 FIND v(dout0_169) AT=25.025n

.meas tran vdout0_170ck40 FIND v(dout0_170) AT=25.025n

.meas tran vdout0_171ck40 FIND v(dout0_171) AT=25.025n

.meas tran vdout0_172ck40 FIND v(dout0_172) AT=25.025n

.meas tran vdout0_173ck40 FIND v(dout0_173) AT=25.025n

.meas tran vdout0_174ck40 FIND v(dout0_174) AT=25.025n

.meas tran vdout0_175ck40 FIND v(dout0_175) AT=25.025n

.meas tran vdout0_176ck40 FIND v(dout0_176) AT=25.025n

.meas tran vdout0_177ck40 FIND v(dout0_177) AT=25.025n

.meas tran vdout0_178ck40 FIND v(dout0_178) AT=25.025n

.meas tran vdout0_179ck40 FIND v(dout0_179) AT=25.025n

.meas tran vdout0_180ck40 FIND v(dout0_180) AT=25.025n

.meas tran vdout0_181ck40 FIND v(dout0_181) AT=25.025n

.meas tran vdout0_182ck40 FIND v(dout0_182) AT=25.025n

.meas tran vdout0_183ck40 FIND v(dout0_183) AT=25.025n

.meas tran vdout0_184ck40 FIND v(dout0_184) AT=25.025n

.meas tran vdout0_185ck40 FIND v(dout0_185) AT=25.025n

.meas tran vdout0_186ck40 FIND v(dout0_186) AT=25.025n

.meas tran vdout0_187ck40 FIND v(dout0_187) AT=25.025n

.meas tran vdout0_188ck40 FIND v(dout0_188) AT=25.025n

.meas tran vdout0_189ck40 FIND v(dout0_189) AT=25.025n

.meas tran vdout0_190ck40 FIND v(dout0_190) AT=25.025n

.meas tran vdout0_191ck40 FIND v(dout0_191) AT=25.025n

.meas tran vdout0_192ck40 FIND v(dout0_192) AT=25.025n

.meas tran vdout0_193ck40 FIND v(dout0_193) AT=25.025n

.meas tran vdout0_194ck40 FIND v(dout0_194) AT=25.025n

.meas tran vdout0_195ck40 FIND v(dout0_195) AT=25.025n

.meas tran vdout0_196ck40 FIND v(dout0_196) AT=25.025n

.meas tran vdout0_197ck40 FIND v(dout0_197) AT=25.025n

.meas tran vdout0_198ck40 FIND v(dout0_198) AT=25.025n

.meas tran vdout0_199ck40 FIND v(dout0_199) AT=25.025n

.meas tran vdout0_200ck40 FIND v(dout0_200) AT=25.025n

.meas tran vdout0_201ck40 FIND v(dout0_201) AT=25.025n

.meas tran vdout0_202ck40 FIND v(dout0_202) AT=25.025n

.meas tran vdout0_203ck40 FIND v(dout0_203) AT=25.025n

.meas tran vdout0_204ck40 FIND v(dout0_204) AT=25.025n

.meas tran vdout0_205ck40 FIND v(dout0_205) AT=25.025n

.meas tran vdout0_206ck40 FIND v(dout0_206) AT=25.025n

.meas tran vdout0_207ck40 FIND v(dout0_207) AT=25.025n

.meas tran vdout0_208ck40 FIND v(dout0_208) AT=25.025n

.meas tran vdout0_209ck40 FIND v(dout0_209) AT=25.025n

.meas tran vdout0_210ck40 FIND v(dout0_210) AT=25.025n

.meas tran vdout0_211ck40 FIND v(dout0_211) AT=25.025n

.meas tran vdout0_212ck40 FIND v(dout0_212) AT=25.025n

.meas tran vdout0_213ck40 FIND v(dout0_213) AT=25.025n

.meas tran vdout0_214ck40 FIND v(dout0_214) AT=25.025n

.meas tran vdout0_215ck40 FIND v(dout0_215) AT=25.025n

.meas tran vdout0_216ck40 FIND v(dout0_216) AT=25.025n

.meas tran vdout0_217ck40 FIND v(dout0_217) AT=25.025n

.meas tran vdout0_218ck40 FIND v(dout0_218) AT=25.025n

.meas tran vdout0_219ck40 FIND v(dout0_219) AT=25.025n

.meas tran vdout0_220ck40 FIND v(dout0_220) AT=25.025n

.meas tran vdout0_221ck40 FIND v(dout0_221) AT=25.025n

.meas tran vdout0_222ck40 FIND v(dout0_222) AT=25.025n

.meas tran vdout0_223ck40 FIND v(dout0_223) AT=25.025n

.meas tran vdout0_224ck40 FIND v(dout0_224) AT=25.025n

.meas tran vdout0_225ck40 FIND v(dout0_225) AT=25.025n

.meas tran vdout0_226ck40 FIND v(dout0_226) AT=25.025n

.meas tran vdout0_227ck40 FIND v(dout0_227) AT=25.025n

.meas tran vdout0_228ck40 FIND v(dout0_228) AT=25.025n

.meas tran vdout0_229ck40 FIND v(dout0_229) AT=25.025n

.meas tran vdout0_230ck40 FIND v(dout0_230) AT=25.025n

.meas tran vdout0_231ck40 FIND v(dout0_231) AT=25.025n

.meas tran vdout0_232ck40 FIND v(dout0_232) AT=25.025n

.meas tran vdout0_233ck40 FIND v(dout0_233) AT=25.025n

.meas tran vdout0_234ck40 FIND v(dout0_234) AT=25.025n

.meas tran vdout0_235ck40 FIND v(dout0_235) AT=25.025n

.meas tran vdout0_236ck40 FIND v(dout0_236) AT=25.025n

.meas tran vdout0_237ck40 FIND v(dout0_237) AT=25.025n

.meas tran vdout0_238ck40 FIND v(dout0_238) AT=25.025n

.meas tran vdout0_239ck40 FIND v(dout0_239) AT=25.025n

.meas tran vdout0_240ck40 FIND v(dout0_240) AT=25.025n

.meas tran vdout0_241ck40 FIND v(dout0_241) AT=25.025n

.meas tran vdout0_242ck40 FIND v(dout0_242) AT=25.025n

.meas tran vdout0_243ck40 FIND v(dout0_243) AT=25.025n

.meas tran vdout0_244ck40 FIND v(dout0_244) AT=25.025n

.meas tran vdout0_245ck40 FIND v(dout0_245) AT=25.025n

.meas tran vdout0_246ck40 FIND v(dout0_246) AT=25.025n

.meas tran vdout0_247ck40 FIND v(dout0_247) AT=25.025n

.meas tran vdout0_248ck40 FIND v(dout0_248) AT=25.025n

.meas tran vdout0_249ck40 FIND v(dout0_249) AT=25.025n

.meas tran vdout0_250ck40 FIND v(dout0_250) AT=25.025n

.meas tran vdout0_251ck40 FIND v(dout0_251) AT=25.025n

.meas tran vdout0_252ck40 FIND v(dout0_252) AT=25.025n

.meas tran vdout0_253ck40 FIND v(dout0_253) AT=25.025n

.meas tran vdout0_254ck40 FIND v(dout0_254) AT=25.025n

.meas tran vdout0_255ck40 FIND v(dout0_255) AT=25.025n

.meas tran vdout0_0ck60 FIND v(dout0_0) AT=35.025n

.meas tran vdout0_1ck60 FIND v(dout0_1) AT=35.025n

.meas tran vdout0_2ck60 FIND v(dout0_2) AT=35.025n

.meas tran vdout0_3ck60 FIND v(dout0_3) AT=35.025n

.meas tran vdout0_4ck60 FIND v(dout0_4) AT=35.025n

.meas tran vdout0_5ck60 FIND v(dout0_5) AT=35.025n

.meas tran vdout0_6ck60 FIND v(dout0_6) AT=35.025n

.meas tran vdout0_7ck60 FIND v(dout0_7) AT=35.025n

.meas tran vdout0_8ck60 FIND v(dout0_8) AT=35.025n

.meas tran vdout0_9ck60 FIND v(dout0_9) AT=35.025n

.meas tran vdout0_10ck60 FIND v(dout0_10) AT=35.025n

.meas tran vdout0_11ck60 FIND v(dout0_11) AT=35.025n

.meas tran vdout0_12ck60 FIND v(dout0_12) AT=35.025n

.meas tran vdout0_13ck60 FIND v(dout0_13) AT=35.025n

.meas tran vdout0_14ck60 FIND v(dout0_14) AT=35.025n

.meas tran vdout0_15ck60 FIND v(dout0_15) AT=35.025n

.meas tran vdout0_16ck60 FIND v(dout0_16) AT=35.025n

.meas tran vdout0_17ck60 FIND v(dout0_17) AT=35.025n

.meas tran vdout0_18ck60 FIND v(dout0_18) AT=35.025n

.meas tran vdout0_19ck60 FIND v(dout0_19) AT=35.025n

.meas tran vdout0_20ck60 FIND v(dout0_20) AT=35.025n

.meas tran vdout0_21ck60 FIND v(dout0_21) AT=35.025n

.meas tran vdout0_22ck60 FIND v(dout0_22) AT=35.025n

.meas tran vdout0_23ck60 FIND v(dout0_23) AT=35.025n

.meas tran vdout0_24ck60 FIND v(dout0_24) AT=35.025n

.meas tran vdout0_25ck60 FIND v(dout0_25) AT=35.025n

.meas tran vdout0_26ck60 FIND v(dout0_26) AT=35.025n

.meas tran vdout0_27ck60 FIND v(dout0_27) AT=35.025n

.meas tran vdout0_28ck60 FIND v(dout0_28) AT=35.025n

.meas tran vdout0_29ck60 FIND v(dout0_29) AT=35.025n

.meas tran vdout0_30ck60 FIND v(dout0_30) AT=35.025n

.meas tran vdout0_31ck60 FIND v(dout0_31) AT=35.025n

.meas tran vdout0_32ck60 FIND v(dout0_32) AT=35.025n

.meas tran vdout0_33ck60 FIND v(dout0_33) AT=35.025n

.meas tran vdout0_34ck60 FIND v(dout0_34) AT=35.025n

.meas tran vdout0_35ck60 FIND v(dout0_35) AT=35.025n

.meas tran vdout0_36ck60 FIND v(dout0_36) AT=35.025n

.meas tran vdout0_37ck60 FIND v(dout0_37) AT=35.025n

.meas tran vdout0_38ck60 FIND v(dout0_38) AT=35.025n

.meas tran vdout0_39ck60 FIND v(dout0_39) AT=35.025n

.meas tran vdout0_40ck60 FIND v(dout0_40) AT=35.025n

.meas tran vdout0_41ck60 FIND v(dout0_41) AT=35.025n

.meas tran vdout0_42ck60 FIND v(dout0_42) AT=35.025n

.meas tran vdout0_43ck60 FIND v(dout0_43) AT=35.025n

.meas tran vdout0_44ck60 FIND v(dout0_44) AT=35.025n

.meas tran vdout0_45ck60 FIND v(dout0_45) AT=35.025n

.meas tran vdout0_46ck60 FIND v(dout0_46) AT=35.025n

.meas tran vdout0_47ck60 FIND v(dout0_47) AT=35.025n

.meas tran vdout0_48ck60 FIND v(dout0_48) AT=35.025n

.meas tran vdout0_49ck60 FIND v(dout0_49) AT=35.025n

.meas tran vdout0_50ck60 FIND v(dout0_50) AT=35.025n

.meas tran vdout0_51ck60 FIND v(dout0_51) AT=35.025n

.meas tran vdout0_52ck60 FIND v(dout0_52) AT=35.025n

.meas tran vdout0_53ck60 FIND v(dout0_53) AT=35.025n

.meas tran vdout0_54ck60 FIND v(dout0_54) AT=35.025n

.meas tran vdout0_55ck60 FIND v(dout0_55) AT=35.025n

.meas tran vdout0_56ck60 FIND v(dout0_56) AT=35.025n

.meas tran vdout0_57ck60 FIND v(dout0_57) AT=35.025n

.meas tran vdout0_58ck60 FIND v(dout0_58) AT=35.025n

.meas tran vdout0_59ck60 FIND v(dout0_59) AT=35.025n

.meas tran vdout0_60ck60 FIND v(dout0_60) AT=35.025n

.meas tran vdout0_61ck60 FIND v(dout0_61) AT=35.025n

.meas tran vdout0_62ck60 FIND v(dout0_62) AT=35.025n

.meas tran vdout0_63ck60 FIND v(dout0_63) AT=35.025n

.meas tran vdout0_64ck60 FIND v(dout0_64) AT=35.025n

.meas tran vdout0_65ck60 FIND v(dout0_65) AT=35.025n

.meas tran vdout0_66ck60 FIND v(dout0_66) AT=35.025n

.meas tran vdout0_67ck60 FIND v(dout0_67) AT=35.025n

.meas tran vdout0_68ck60 FIND v(dout0_68) AT=35.025n

.meas tran vdout0_69ck60 FIND v(dout0_69) AT=35.025n

.meas tran vdout0_70ck60 FIND v(dout0_70) AT=35.025n

.meas tran vdout0_71ck60 FIND v(dout0_71) AT=35.025n

.meas tran vdout0_72ck60 FIND v(dout0_72) AT=35.025n

.meas tran vdout0_73ck60 FIND v(dout0_73) AT=35.025n

.meas tran vdout0_74ck60 FIND v(dout0_74) AT=35.025n

.meas tran vdout0_75ck60 FIND v(dout0_75) AT=35.025n

.meas tran vdout0_76ck60 FIND v(dout0_76) AT=35.025n

.meas tran vdout0_77ck60 FIND v(dout0_77) AT=35.025n

.meas tran vdout0_78ck60 FIND v(dout0_78) AT=35.025n

.meas tran vdout0_79ck60 FIND v(dout0_79) AT=35.025n

.meas tran vdout0_80ck60 FIND v(dout0_80) AT=35.025n

.meas tran vdout0_81ck60 FIND v(dout0_81) AT=35.025n

.meas tran vdout0_82ck60 FIND v(dout0_82) AT=35.025n

.meas tran vdout0_83ck60 FIND v(dout0_83) AT=35.025n

.meas tran vdout0_84ck60 FIND v(dout0_84) AT=35.025n

.meas tran vdout0_85ck60 FIND v(dout0_85) AT=35.025n

.meas tran vdout0_86ck60 FIND v(dout0_86) AT=35.025n

.meas tran vdout0_87ck60 FIND v(dout0_87) AT=35.025n

.meas tran vdout0_88ck60 FIND v(dout0_88) AT=35.025n

.meas tran vdout0_89ck60 FIND v(dout0_89) AT=35.025n

.meas tran vdout0_90ck60 FIND v(dout0_90) AT=35.025n

.meas tran vdout0_91ck60 FIND v(dout0_91) AT=35.025n

.meas tran vdout0_92ck60 FIND v(dout0_92) AT=35.025n

.meas tran vdout0_93ck60 FIND v(dout0_93) AT=35.025n

.meas tran vdout0_94ck60 FIND v(dout0_94) AT=35.025n

.meas tran vdout0_95ck60 FIND v(dout0_95) AT=35.025n

.meas tran vdout0_96ck60 FIND v(dout0_96) AT=35.025n

.meas tran vdout0_97ck60 FIND v(dout0_97) AT=35.025n

.meas tran vdout0_98ck60 FIND v(dout0_98) AT=35.025n

.meas tran vdout0_99ck60 FIND v(dout0_99) AT=35.025n

.meas tran vdout0_100ck60 FIND v(dout0_100) AT=35.025n

.meas tran vdout0_101ck60 FIND v(dout0_101) AT=35.025n

.meas tran vdout0_102ck60 FIND v(dout0_102) AT=35.025n

.meas tran vdout0_103ck60 FIND v(dout0_103) AT=35.025n

.meas tran vdout0_104ck60 FIND v(dout0_104) AT=35.025n

.meas tran vdout0_105ck60 FIND v(dout0_105) AT=35.025n

.meas tran vdout0_106ck60 FIND v(dout0_106) AT=35.025n

.meas tran vdout0_107ck60 FIND v(dout0_107) AT=35.025n

.meas tran vdout0_108ck60 FIND v(dout0_108) AT=35.025n

.meas tran vdout0_109ck60 FIND v(dout0_109) AT=35.025n

.meas tran vdout0_110ck60 FIND v(dout0_110) AT=35.025n

.meas tran vdout0_111ck60 FIND v(dout0_111) AT=35.025n

.meas tran vdout0_112ck60 FIND v(dout0_112) AT=35.025n

.meas tran vdout0_113ck60 FIND v(dout0_113) AT=35.025n

.meas tran vdout0_114ck60 FIND v(dout0_114) AT=35.025n

.meas tran vdout0_115ck60 FIND v(dout0_115) AT=35.025n

.meas tran vdout0_116ck60 FIND v(dout0_116) AT=35.025n

.meas tran vdout0_117ck60 FIND v(dout0_117) AT=35.025n

.meas tran vdout0_118ck60 FIND v(dout0_118) AT=35.025n

.meas tran vdout0_119ck60 FIND v(dout0_119) AT=35.025n

.meas tran vdout0_120ck60 FIND v(dout0_120) AT=35.025n

.meas tran vdout0_121ck60 FIND v(dout0_121) AT=35.025n

.meas tran vdout0_122ck60 FIND v(dout0_122) AT=35.025n

.meas tran vdout0_123ck60 FIND v(dout0_123) AT=35.025n

.meas tran vdout0_124ck60 FIND v(dout0_124) AT=35.025n

.meas tran vdout0_125ck60 FIND v(dout0_125) AT=35.025n

.meas tran vdout0_126ck60 FIND v(dout0_126) AT=35.025n

.meas tran vdout0_127ck60 FIND v(dout0_127) AT=35.025n

.meas tran vdout0_128ck60 FIND v(dout0_128) AT=35.025n

.meas tran vdout0_129ck60 FIND v(dout0_129) AT=35.025n

.meas tran vdout0_130ck60 FIND v(dout0_130) AT=35.025n

.meas tran vdout0_131ck60 FIND v(dout0_131) AT=35.025n

.meas tran vdout0_132ck60 FIND v(dout0_132) AT=35.025n

.meas tran vdout0_133ck60 FIND v(dout0_133) AT=35.025n

.meas tran vdout0_134ck60 FIND v(dout0_134) AT=35.025n

.meas tran vdout0_135ck60 FIND v(dout0_135) AT=35.025n

.meas tran vdout0_136ck60 FIND v(dout0_136) AT=35.025n

.meas tran vdout0_137ck60 FIND v(dout0_137) AT=35.025n

.meas tran vdout0_138ck60 FIND v(dout0_138) AT=35.025n

.meas tran vdout0_139ck60 FIND v(dout0_139) AT=35.025n

.meas tran vdout0_140ck60 FIND v(dout0_140) AT=35.025n

.meas tran vdout0_141ck60 FIND v(dout0_141) AT=35.025n

.meas tran vdout0_142ck60 FIND v(dout0_142) AT=35.025n

.meas tran vdout0_143ck60 FIND v(dout0_143) AT=35.025n

.meas tran vdout0_144ck60 FIND v(dout0_144) AT=35.025n

.meas tran vdout0_145ck60 FIND v(dout0_145) AT=35.025n

.meas tran vdout0_146ck60 FIND v(dout0_146) AT=35.025n

.meas tran vdout0_147ck60 FIND v(dout0_147) AT=35.025n

.meas tran vdout0_148ck60 FIND v(dout0_148) AT=35.025n

.meas tran vdout0_149ck60 FIND v(dout0_149) AT=35.025n

.meas tran vdout0_150ck60 FIND v(dout0_150) AT=35.025n

.meas tran vdout0_151ck60 FIND v(dout0_151) AT=35.025n

.meas tran vdout0_152ck60 FIND v(dout0_152) AT=35.025n

.meas tran vdout0_153ck60 FIND v(dout0_153) AT=35.025n

.meas tran vdout0_154ck60 FIND v(dout0_154) AT=35.025n

.meas tran vdout0_155ck60 FIND v(dout0_155) AT=35.025n

.meas tran vdout0_156ck60 FIND v(dout0_156) AT=35.025n

.meas tran vdout0_157ck60 FIND v(dout0_157) AT=35.025n

.meas tran vdout0_158ck60 FIND v(dout0_158) AT=35.025n

.meas tran vdout0_159ck60 FIND v(dout0_159) AT=35.025n

.meas tran vdout0_160ck60 FIND v(dout0_160) AT=35.025n

.meas tran vdout0_161ck60 FIND v(dout0_161) AT=35.025n

.meas tran vdout0_162ck60 FIND v(dout0_162) AT=35.025n

.meas tran vdout0_163ck60 FIND v(dout0_163) AT=35.025n

.meas tran vdout0_164ck60 FIND v(dout0_164) AT=35.025n

.meas tran vdout0_165ck60 FIND v(dout0_165) AT=35.025n

.meas tran vdout0_166ck60 FIND v(dout0_166) AT=35.025n

.meas tran vdout0_167ck60 FIND v(dout0_167) AT=35.025n

.meas tran vdout0_168ck60 FIND v(dout0_168) AT=35.025n

.meas tran vdout0_169ck60 FIND v(dout0_169) AT=35.025n

.meas tran vdout0_170ck60 FIND v(dout0_170) AT=35.025n

.meas tran vdout0_171ck60 FIND v(dout0_171) AT=35.025n

.meas tran vdout0_172ck60 FIND v(dout0_172) AT=35.025n

.meas tran vdout0_173ck60 FIND v(dout0_173) AT=35.025n

.meas tran vdout0_174ck60 FIND v(dout0_174) AT=35.025n

.meas tran vdout0_175ck60 FIND v(dout0_175) AT=35.025n

.meas tran vdout0_176ck60 FIND v(dout0_176) AT=35.025n

.meas tran vdout0_177ck60 FIND v(dout0_177) AT=35.025n

.meas tran vdout0_178ck60 FIND v(dout0_178) AT=35.025n

.meas tran vdout0_179ck60 FIND v(dout0_179) AT=35.025n

.meas tran vdout0_180ck60 FIND v(dout0_180) AT=35.025n

.meas tran vdout0_181ck60 FIND v(dout0_181) AT=35.025n

.meas tran vdout0_182ck60 FIND v(dout0_182) AT=35.025n

.meas tran vdout0_183ck60 FIND v(dout0_183) AT=35.025n

.meas tran vdout0_184ck60 FIND v(dout0_184) AT=35.025n

.meas tran vdout0_185ck60 FIND v(dout0_185) AT=35.025n

.meas tran vdout0_186ck60 FIND v(dout0_186) AT=35.025n

.meas tran vdout0_187ck60 FIND v(dout0_187) AT=35.025n

.meas tran vdout0_188ck60 FIND v(dout0_188) AT=35.025n

.meas tran vdout0_189ck60 FIND v(dout0_189) AT=35.025n

.meas tran vdout0_190ck60 FIND v(dout0_190) AT=35.025n

.meas tran vdout0_191ck60 FIND v(dout0_191) AT=35.025n

.meas tran vdout0_192ck60 FIND v(dout0_192) AT=35.025n

.meas tran vdout0_193ck60 FIND v(dout0_193) AT=35.025n

.meas tran vdout0_194ck60 FIND v(dout0_194) AT=35.025n

.meas tran vdout0_195ck60 FIND v(dout0_195) AT=35.025n

.meas tran vdout0_196ck60 FIND v(dout0_196) AT=35.025n

.meas tran vdout0_197ck60 FIND v(dout0_197) AT=35.025n

.meas tran vdout0_198ck60 FIND v(dout0_198) AT=35.025n

.meas tran vdout0_199ck60 FIND v(dout0_199) AT=35.025n

.meas tran vdout0_200ck60 FIND v(dout0_200) AT=35.025n

.meas tran vdout0_201ck60 FIND v(dout0_201) AT=35.025n

.meas tran vdout0_202ck60 FIND v(dout0_202) AT=35.025n

.meas tran vdout0_203ck60 FIND v(dout0_203) AT=35.025n

.meas tran vdout0_204ck60 FIND v(dout0_204) AT=35.025n

.meas tran vdout0_205ck60 FIND v(dout0_205) AT=35.025n

.meas tran vdout0_206ck60 FIND v(dout0_206) AT=35.025n

.meas tran vdout0_207ck60 FIND v(dout0_207) AT=35.025n

.meas tran vdout0_208ck60 FIND v(dout0_208) AT=35.025n

.meas tran vdout0_209ck60 FIND v(dout0_209) AT=35.025n

.meas tran vdout0_210ck60 FIND v(dout0_210) AT=35.025n

.meas tran vdout0_211ck60 FIND v(dout0_211) AT=35.025n

.meas tran vdout0_212ck60 FIND v(dout0_212) AT=35.025n

.meas tran vdout0_213ck60 FIND v(dout0_213) AT=35.025n

.meas tran vdout0_214ck60 FIND v(dout0_214) AT=35.025n

.meas tran vdout0_215ck60 FIND v(dout0_215) AT=35.025n

.meas tran vdout0_216ck60 FIND v(dout0_216) AT=35.025n

.meas tran vdout0_217ck60 FIND v(dout0_217) AT=35.025n

.meas tran vdout0_218ck60 FIND v(dout0_218) AT=35.025n

.meas tran vdout0_219ck60 FIND v(dout0_219) AT=35.025n

.meas tran vdout0_220ck60 FIND v(dout0_220) AT=35.025n

.meas tran vdout0_221ck60 FIND v(dout0_221) AT=35.025n

.meas tran vdout0_222ck60 FIND v(dout0_222) AT=35.025n

.meas tran vdout0_223ck60 FIND v(dout0_223) AT=35.025n

.meas tran vdout0_224ck60 FIND v(dout0_224) AT=35.025n

.meas tran vdout0_225ck60 FIND v(dout0_225) AT=35.025n

.meas tran vdout0_226ck60 FIND v(dout0_226) AT=35.025n

.meas tran vdout0_227ck60 FIND v(dout0_227) AT=35.025n

.meas tran vdout0_228ck60 FIND v(dout0_228) AT=35.025n

.meas tran vdout0_229ck60 FIND v(dout0_229) AT=35.025n

.meas tran vdout0_230ck60 FIND v(dout0_230) AT=35.025n

.meas tran vdout0_231ck60 FIND v(dout0_231) AT=35.025n

.meas tran vdout0_232ck60 FIND v(dout0_232) AT=35.025n

.meas tran vdout0_233ck60 FIND v(dout0_233) AT=35.025n

.meas tran vdout0_234ck60 FIND v(dout0_234) AT=35.025n

.meas tran vdout0_235ck60 FIND v(dout0_235) AT=35.025n

.meas tran vdout0_236ck60 FIND v(dout0_236) AT=35.025n

.meas tran vdout0_237ck60 FIND v(dout0_237) AT=35.025n

.meas tran vdout0_238ck60 FIND v(dout0_238) AT=35.025n

.meas tran vdout0_239ck60 FIND v(dout0_239) AT=35.025n

.meas tran vdout0_240ck60 FIND v(dout0_240) AT=35.025n

.meas tran vdout0_241ck60 FIND v(dout0_241) AT=35.025n

.meas tran vdout0_242ck60 FIND v(dout0_242) AT=35.025n

.meas tran vdout0_243ck60 FIND v(dout0_243) AT=35.025n

.meas tran vdout0_244ck60 FIND v(dout0_244) AT=35.025n

.meas tran vdout0_245ck60 FIND v(dout0_245) AT=35.025n

.meas tran vdout0_246ck60 FIND v(dout0_246) AT=35.025n

.meas tran vdout0_247ck60 FIND v(dout0_247) AT=35.025n

.meas tran vdout0_248ck60 FIND v(dout0_248) AT=35.025n

.meas tran vdout0_249ck60 FIND v(dout0_249) AT=35.025n

.meas tran vdout0_250ck60 FIND v(dout0_250) AT=35.025n

.meas tran vdout0_251ck60 FIND v(dout0_251) AT=35.025n

.meas tran vdout0_252ck60 FIND v(dout0_252) AT=35.025n

.meas tran vdout0_253ck60 FIND v(dout0_253) AT=35.025n

.meas tran vdout0_254ck60 FIND v(dout0_254) AT=35.025n

.meas tran vdout0_255ck60 FIND v(dout0_255) AT=35.025n

.meas tran vdout0_0ck140 FIND v(dout0_0) AT=75.025n

.meas tran vdout0_1ck140 FIND v(dout0_1) AT=75.025n

.meas tran vdout0_2ck140 FIND v(dout0_2) AT=75.025n

.meas tran vdout0_3ck140 FIND v(dout0_3) AT=75.025n

.meas tran vdout0_4ck140 FIND v(dout0_4) AT=75.025n

.meas tran vdout0_5ck140 FIND v(dout0_5) AT=75.025n

.meas tran vdout0_6ck140 FIND v(dout0_6) AT=75.025n

.meas tran vdout0_7ck140 FIND v(dout0_7) AT=75.025n

.meas tran vdout0_8ck140 FIND v(dout0_8) AT=75.025n

.meas tran vdout0_9ck140 FIND v(dout0_9) AT=75.025n

.meas tran vdout0_10ck140 FIND v(dout0_10) AT=75.025n

.meas tran vdout0_11ck140 FIND v(dout0_11) AT=75.025n

.meas tran vdout0_12ck140 FIND v(dout0_12) AT=75.025n

.meas tran vdout0_13ck140 FIND v(dout0_13) AT=75.025n

.meas tran vdout0_14ck140 FIND v(dout0_14) AT=75.025n

.meas tran vdout0_15ck140 FIND v(dout0_15) AT=75.025n

.meas tran vdout0_16ck140 FIND v(dout0_16) AT=75.025n

.meas tran vdout0_17ck140 FIND v(dout0_17) AT=75.025n

.meas tran vdout0_18ck140 FIND v(dout0_18) AT=75.025n

.meas tran vdout0_19ck140 FIND v(dout0_19) AT=75.025n

.meas tran vdout0_20ck140 FIND v(dout0_20) AT=75.025n

.meas tran vdout0_21ck140 FIND v(dout0_21) AT=75.025n

.meas tran vdout0_22ck140 FIND v(dout0_22) AT=75.025n

.meas tran vdout0_23ck140 FIND v(dout0_23) AT=75.025n

.meas tran vdout0_24ck140 FIND v(dout0_24) AT=75.025n

.meas tran vdout0_25ck140 FIND v(dout0_25) AT=75.025n

.meas tran vdout0_26ck140 FIND v(dout0_26) AT=75.025n

.meas tran vdout0_27ck140 FIND v(dout0_27) AT=75.025n

.meas tran vdout0_28ck140 FIND v(dout0_28) AT=75.025n

.meas tran vdout0_29ck140 FIND v(dout0_29) AT=75.025n

.meas tran vdout0_30ck140 FIND v(dout0_30) AT=75.025n

.meas tran vdout0_31ck140 FIND v(dout0_31) AT=75.025n

.meas tran vdout0_32ck140 FIND v(dout0_32) AT=75.025n

.meas tran vdout0_33ck140 FIND v(dout0_33) AT=75.025n

.meas tran vdout0_34ck140 FIND v(dout0_34) AT=75.025n

.meas tran vdout0_35ck140 FIND v(dout0_35) AT=75.025n

.meas tran vdout0_36ck140 FIND v(dout0_36) AT=75.025n

.meas tran vdout0_37ck140 FIND v(dout0_37) AT=75.025n

.meas tran vdout0_38ck140 FIND v(dout0_38) AT=75.025n

.meas tran vdout0_39ck140 FIND v(dout0_39) AT=75.025n

.meas tran vdout0_40ck140 FIND v(dout0_40) AT=75.025n

.meas tran vdout0_41ck140 FIND v(dout0_41) AT=75.025n

.meas tran vdout0_42ck140 FIND v(dout0_42) AT=75.025n

.meas tran vdout0_43ck140 FIND v(dout0_43) AT=75.025n

.meas tran vdout0_44ck140 FIND v(dout0_44) AT=75.025n

.meas tran vdout0_45ck140 FIND v(dout0_45) AT=75.025n

.meas tran vdout0_46ck140 FIND v(dout0_46) AT=75.025n

.meas tran vdout0_47ck140 FIND v(dout0_47) AT=75.025n

.meas tran vdout0_48ck140 FIND v(dout0_48) AT=75.025n

.meas tran vdout0_49ck140 FIND v(dout0_49) AT=75.025n

.meas tran vdout0_50ck140 FIND v(dout0_50) AT=75.025n

.meas tran vdout0_51ck140 FIND v(dout0_51) AT=75.025n

.meas tran vdout0_52ck140 FIND v(dout0_52) AT=75.025n

.meas tran vdout0_53ck140 FIND v(dout0_53) AT=75.025n

.meas tran vdout0_54ck140 FIND v(dout0_54) AT=75.025n

.meas tran vdout0_55ck140 FIND v(dout0_55) AT=75.025n

.meas tran vdout0_56ck140 FIND v(dout0_56) AT=75.025n

.meas tran vdout0_57ck140 FIND v(dout0_57) AT=75.025n

.meas tran vdout0_58ck140 FIND v(dout0_58) AT=75.025n

.meas tran vdout0_59ck140 FIND v(dout0_59) AT=75.025n

.meas tran vdout0_60ck140 FIND v(dout0_60) AT=75.025n

.meas tran vdout0_61ck140 FIND v(dout0_61) AT=75.025n

.meas tran vdout0_62ck140 FIND v(dout0_62) AT=75.025n

.meas tran vdout0_63ck140 FIND v(dout0_63) AT=75.025n

.meas tran vdout0_64ck140 FIND v(dout0_64) AT=75.025n

.meas tran vdout0_65ck140 FIND v(dout0_65) AT=75.025n

.meas tran vdout0_66ck140 FIND v(dout0_66) AT=75.025n

.meas tran vdout0_67ck140 FIND v(dout0_67) AT=75.025n

.meas tran vdout0_68ck140 FIND v(dout0_68) AT=75.025n

.meas tran vdout0_69ck140 FIND v(dout0_69) AT=75.025n

.meas tran vdout0_70ck140 FIND v(dout0_70) AT=75.025n

.meas tran vdout0_71ck140 FIND v(dout0_71) AT=75.025n

.meas tran vdout0_72ck140 FIND v(dout0_72) AT=75.025n

.meas tran vdout0_73ck140 FIND v(dout0_73) AT=75.025n

.meas tran vdout0_74ck140 FIND v(dout0_74) AT=75.025n

.meas tran vdout0_75ck140 FIND v(dout0_75) AT=75.025n

.meas tran vdout0_76ck140 FIND v(dout0_76) AT=75.025n

.meas tran vdout0_77ck140 FIND v(dout0_77) AT=75.025n

.meas tran vdout0_78ck140 FIND v(dout0_78) AT=75.025n

.meas tran vdout0_79ck140 FIND v(dout0_79) AT=75.025n

.meas tran vdout0_80ck140 FIND v(dout0_80) AT=75.025n

.meas tran vdout0_81ck140 FIND v(dout0_81) AT=75.025n

.meas tran vdout0_82ck140 FIND v(dout0_82) AT=75.025n

.meas tran vdout0_83ck140 FIND v(dout0_83) AT=75.025n

.meas tran vdout0_84ck140 FIND v(dout0_84) AT=75.025n

.meas tran vdout0_85ck140 FIND v(dout0_85) AT=75.025n

.meas tran vdout0_86ck140 FIND v(dout0_86) AT=75.025n

.meas tran vdout0_87ck140 FIND v(dout0_87) AT=75.025n

.meas tran vdout0_88ck140 FIND v(dout0_88) AT=75.025n

.meas tran vdout0_89ck140 FIND v(dout0_89) AT=75.025n

.meas tran vdout0_90ck140 FIND v(dout0_90) AT=75.025n

.meas tran vdout0_91ck140 FIND v(dout0_91) AT=75.025n

.meas tran vdout0_92ck140 FIND v(dout0_92) AT=75.025n

.meas tran vdout0_93ck140 FIND v(dout0_93) AT=75.025n

.meas tran vdout0_94ck140 FIND v(dout0_94) AT=75.025n

.meas tran vdout0_95ck140 FIND v(dout0_95) AT=75.025n

.meas tran vdout0_96ck140 FIND v(dout0_96) AT=75.025n

.meas tran vdout0_97ck140 FIND v(dout0_97) AT=75.025n

.meas tran vdout0_98ck140 FIND v(dout0_98) AT=75.025n

.meas tran vdout0_99ck140 FIND v(dout0_99) AT=75.025n

.meas tran vdout0_100ck140 FIND v(dout0_100) AT=75.025n

.meas tran vdout0_101ck140 FIND v(dout0_101) AT=75.025n

.meas tran vdout0_102ck140 FIND v(dout0_102) AT=75.025n

.meas tran vdout0_103ck140 FIND v(dout0_103) AT=75.025n

.meas tran vdout0_104ck140 FIND v(dout0_104) AT=75.025n

.meas tran vdout0_105ck140 FIND v(dout0_105) AT=75.025n

.meas tran vdout0_106ck140 FIND v(dout0_106) AT=75.025n

.meas tran vdout0_107ck140 FIND v(dout0_107) AT=75.025n

.meas tran vdout0_108ck140 FIND v(dout0_108) AT=75.025n

.meas tran vdout0_109ck140 FIND v(dout0_109) AT=75.025n

.meas tran vdout0_110ck140 FIND v(dout0_110) AT=75.025n

.meas tran vdout0_111ck140 FIND v(dout0_111) AT=75.025n

.meas tran vdout0_112ck140 FIND v(dout0_112) AT=75.025n

.meas tran vdout0_113ck140 FIND v(dout0_113) AT=75.025n

.meas tran vdout0_114ck140 FIND v(dout0_114) AT=75.025n

.meas tran vdout0_115ck140 FIND v(dout0_115) AT=75.025n

.meas tran vdout0_116ck140 FIND v(dout0_116) AT=75.025n

.meas tran vdout0_117ck140 FIND v(dout0_117) AT=75.025n

.meas tran vdout0_118ck140 FIND v(dout0_118) AT=75.025n

.meas tran vdout0_119ck140 FIND v(dout0_119) AT=75.025n

.meas tran vdout0_120ck140 FIND v(dout0_120) AT=75.025n

.meas tran vdout0_121ck140 FIND v(dout0_121) AT=75.025n

.meas tran vdout0_122ck140 FIND v(dout0_122) AT=75.025n

.meas tran vdout0_123ck140 FIND v(dout0_123) AT=75.025n

.meas tran vdout0_124ck140 FIND v(dout0_124) AT=75.025n

.meas tran vdout0_125ck140 FIND v(dout0_125) AT=75.025n

.meas tran vdout0_126ck140 FIND v(dout0_126) AT=75.025n

.meas tran vdout0_127ck140 FIND v(dout0_127) AT=75.025n

.meas tran vdout0_128ck140 FIND v(dout0_128) AT=75.025n

.meas tran vdout0_129ck140 FIND v(dout0_129) AT=75.025n

.meas tran vdout0_130ck140 FIND v(dout0_130) AT=75.025n

.meas tran vdout0_131ck140 FIND v(dout0_131) AT=75.025n

.meas tran vdout0_132ck140 FIND v(dout0_132) AT=75.025n

.meas tran vdout0_133ck140 FIND v(dout0_133) AT=75.025n

.meas tran vdout0_134ck140 FIND v(dout0_134) AT=75.025n

.meas tran vdout0_135ck140 FIND v(dout0_135) AT=75.025n

.meas tran vdout0_136ck140 FIND v(dout0_136) AT=75.025n

.meas tran vdout0_137ck140 FIND v(dout0_137) AT=75.025n

.meas tran vdout0_138ck140 FIND v(dout0_138) AT=75.025n

.meas tran vdout0_139ck140 FIND v(dout0_139) AT=75.025n

.meas tran vdout0_140ck140 FIND v(dout0_140) AT=75.025n

.meas tran vdout0_141ck140 FIND v(dout0_141) AT=75.025n

.meas tran vdout0_142ck140 FIND v(dout0_142) AT=75.025n

.meas tran vdout0_143ck140 FIND v(dout0_143) AT=75.025n

.meas tran vdout0_144ck140 FIND v(dout0_144) AT=75.025n

.meas tran vdout0_145ck140 FIND v(dout0_145) AT=75.025n

.meas tran vdout0_146ck140 FIND v(dout0_146) AT=75.025n

.meas tran vdout0_147ck140 FIND v(dout0_147) AT=75.025n

.meas tran vdout0_148ck140 FIND v(dout0_148) AT=75.025n

.meas tran vdout0_149ck140 FIND v(dout0_149) AT=75.025n

.meas tran vdout0_150ck140 FIND v(dout0_150) AT=75.025n

.meas tran vdout0_151ck140 FIND v(dout0_151) AT=75.025n

.meas tran vdout0_152ck140 FIND v(dout0_152) AT=75.025n

.meas tran vdout0_153ck140 FIND v(dout0_153) AT=75.025n

.meas tran vdout0_154ck140 FIND v(dout0_154) AT=75.025n

.meas tran vdout0_155ck140 FIND v(dout0_155) AT=75.025n

.meas tran vdout0_156ck140 FIND v(dout0_156) AT=75.025n

.meas tran vdout0_157ck140 FIND v(dout0_157) AT=75.025n

.meas tran vdout0_158ck140 FIND v(dout0_158) AT=75.025n

.meas tran vdout0_159ck140 FIND v(dout0_159) AT=75.025n

.meas tran vdout0_160ck140 FIND v(dout0_160) AT=75.025n

.meas tran vdout0_161ck140 FIND v(dout0_161) AT=75.025n

.meas tran vdout0_162ck140 FIND v(dout0_162) AT=75.025n

.meas tran vdout0_163ck140 FIND v(dout0_163) AT=75.025n

.meas tran vdout0_164ck140 FIND v(dout0_164) AT=75.025n

.meas tran vdout0_165ck140 FIND v(dout0_165) AT=75.025n

.meas tran vdout0_166ck140 FIND v(dout0_166) AT=75.025n

.meas tran vdout0_167ck140 FIND v(dout0_167) AT=75.025n

.meas tran vdout0_168ck140 FIND v(dout0_168) AT=75.025n

.meas tran vdout0_169ck140 FIND v(dout0_169) AT=75.025n

.meas tran vdout0_170ck140 FIND v(dout0_170) AT=75.025n

.meas tran vdout0_171ck140 FIND v(dout0_171) AT=75.025n

.meas tran vdout0_172ck140 FIND v(dout0_172) AT=75.025n

.meas tran vdout0_173ck140 FIND v(dout0_173) AT=75.025n

.meas tran vdout0_174ck140 FIND v(dout0_174) AT=75.025n

.meas tran vdout0_175ck140 FIND v(dout0_175) AT=75.025n

.meas tran vdout0_176ck140 FIND v(dout0_176) AT=75.025n

.meas tran vdout0_177ck140 FIND v(dout0_177) AT=75.025n

.meas tran vdout0_178ck140 FIND v(dout0_178) AT=75.025n

.meas tran vdout0_179ck140 FIND v(dout0_179) AT=75.025n

.meas tran vdout0_180ck140 FIND v(dout0_180) AT=75.025n

.meas tran vdout0_181ck140 FIND v(dout0_181) AT=75.025n

.meas tran vdout0_182ck140 FIND v(dout0_182) AT=75.025n

.meas tran vdout0_183ck140 FIND v(dout0_183) AT=75.025n

.meas tran vdout0_184ck140 FIND v(dout0_184) AT=75.025n

.meas tran vdout0_185ck140 FIND v(dout0_185) AT=75.025n

.meas tran vdout0_186ck140 FIND v(dout0_186) AT=75.025n

.meas tran vdout0_187ck140 FIND v(dout0_187) AT=75.025n

.meas tran vdout0_188ck140 FIND v(dout0_188) AT=75.025n

.meas tran vdout0_189ck140 FIND v(dout0_189) AT=75.025n

.meas tran vdout0_190ck140 FIND v(dout0_190) AT=75.025n

.meas tran vdout0_191ck140 FIND v(dout0_191) AT=75.025n

.meas tran vdout0_192ck140 FIND v(dout0_192) AT=75.025n

.meas tran vdout0_193ck140 FIND v(dout0_193) AT=75.025n

.meas tran vdout0_194ck140 FIND v(dout0_194) AT=75.025n

.meas tran vdout0_195ck140 FIND v(dout0_195) AT=75.025n

.meas tran vdout0_196ck140 FIND v(dout0_196) AT=75.025n

.meas tran vdout0_197ck140 FIND v(dout0_197) AT=75.025n

.meas tran vdout0_198ck140 FIND v(dout0_198) AT=75.025n

.meas tran vdout0_199ck140 FIND v(dout0_199) AT=75.025n

.meas tran vdout0_200ck140 FIND v(dout0_200) AT=75.025n

.meas tran vdout0_201ck140 FIND v(dout0_201) AT=75.025n

.meas tran vdout0_202ck140 FIND v(dout0_202) AT=75.025n

.meas tran vdout0_203ck140 FIND v(dout0_203) AT=75.025n

.meas tran vdout0_204ck140 FIND v(dout0_204) AT=75.025n

.meas tran vdout0_205ck140 FIND v(dout0_205) AT=75.025n

.meas tran vdout0_206ck140 FIND v(dout0_206) AT=75.025n

.meas tran vdout0_207ck140 FIND v(dout0_207) AT=75.025n

.meas tran vdout0_208ck140 FIND v(dout0_208) AT=75.025n

.meas tran vdout0_209ck140 FIND v(dout0_209) AT=75.025n

.meas tran vdout0_210ck140 FIND v(dout0_210) AT=75.025n

.meas tran vdout0_211ck140 FIND v(dout0_211) AT=75.025n

.meas tran vdout0_212ck140 FIND v(dout0_212) AT=75.025n

.meas tran vdout0_213ck140 FIND v(dout0_213) AT=75.025n

.meas tran vdout0_214ck140 FIND v(dout0_214) AT=75.025n

.meas tran vdout0_215ck140 FIND v(dout0_215) AT=75.025n

.meas tran vdout0_216ck140 FIND v(dout0_216) AT=75.025n

.meas tran vdout0_217ck140 FIND v(dout0_217) AT=75.025n

.meas tran vdout0_218ck140 FIND v(dout0_218) AT=75.025n

.meas tran vdout0_219ck140 FIND v(dout0_219) AT=75.025n

.meas tran vdout0_220ck140 FIND v(dout0_220) AT=75.025n

.meas tran vdout0_221ck140 FIND v(dout0_221) AT=75.025n

.meas tran vdout0_222ck140 FIND v(dout0_222) AT=75.025n

.meas tran vdout0_223ck140 FIND v(dout0_223) AT=75.025n

.meas tran vdout0_224ck140 FIND v(dout0_224) AT=75.025n

.meas tran vdout0_225ck140 FIND v(dout0_225) AT=75.025n

.meas tran vdout0_226ck140 FIND v(dout0_226) AT=75.025n

.meas tran vdout0_227ck140 FIND v(dout0_227) AT=75.025n

.meas tran vdout0_228ck140 FIND v(dout0_228) AT=75.025n

.meas tran vdout0_229ck140 FIND v(dout0_229) AT=75.025n

.meas tran vdout0_230ck140 FIND v(dout0_230) AT=75.025n

.meas tran vdout0_231ck140 FIND v(dout0_231) AT=75.025n

.meas tran vdout0_232ck140 FIND v(dout0_232) AT=75.025n

.meas tran vdout0_233ck140 FIND v(dout0_233) AT=75.025n

.meas tran vdout0_234ck140 FIND v(dout0_234) AT=75.025n

.meas tran vdout0_235ck140 FIND v(dout0_235) AT=75.025n

.meas tran vdout0_236ck140 FIND v(dout0_236) AT=75.025n

.meas tran vdout0_237ck140 FIND v(dout0_237) AT=75.025n

.meas tran vdout0_238ck140 FIND v(dout0_238) AT=75.025n

.meas tran vdout0_239ck140 FIND v(dout0_239) AT=75.025n

.meas tran vdout0_240ck140 FIND v(dout0_240) AT=75.025n

.meas tran vdout0_241ck140 FIND v(dout0_241) AT=75.025n

.meas tran vdout0_242ck140 FIND v(dout0_242) AT=75.025n

.meas tran vdout0_243ck140 FIND v(dout0_243) AT=75.025n

.meas tran vdout0_244ck140 FIND v(dout0_244) AT=75.025n

.meas tran vdout0_245ck140 FIND v(dout0_245) AT=75.025n

.meas tran vdout0_246ck140 FIND v(dout0_246) AT=75.025n

.meas tran vdout0_247ck140 FIND v(dout0_247) AT=75.025n

.meas tran vdout0_248ck140 FIND v(dout0_248) AT=75.025n

.meas tran vdout0_249ck140 FIND v(dout0_249) AT=75.025n

.meas tran vdout0_250ck140 FIND v(dout0_250) AT=75.025n

.meas tran vdout0_251ck140 FIND v(dout0_251) AT=75.025n

.meas tran vdout0_252ck140 FIND v(dout0_252) AT=75.025n

.meas tran vdout0_253ck140 FIND v(dout0_253) AT=75.025n

.meas tran vdout0_254ck140 FIND v(dout0_254) AT=75.025n

.meas tran vdout0_255ck140 FIND v(dout0_255) AT=75.025n

.meas tran vdout0_0ck150 FIND v(dout0_0) AT=80.025n

.meas tran vdout0_1ck150 FIND v(dout0_1) AT=80.025n

.meas tran vdout0_2ck150 FIND v(dout0_2) AT=80.025n

.meas tran vdout0_3ck150 FIND v(dout0_3) AT=80.025n

.meas tran vdout0_4ck150 FIND v(dout0_4) AT=80.025n

.meas tran vdout0_5ck150 FIND v(dout0_5) AT=80.025n

.meas tran vdout0_6ck150 FIND v(dout0_6) AT=80.025n

.meas tran vdout0_7ck150 FIND v(dout0_7) AT=80.025n

.meas tran vdout0_8ck150 FIND v(dout0_8) AT=80.025n

.meas tran vdout0_9ck150 FIND v(dout0_9) AT=80.025n

.meas tran vdout0_10ck150 FIND v(dout0_10) AT=80.025n

.meas tran vdout0_11ck150 FIND v(dout0_11) AT=80.025n

.meas tran vdout0_12ck150 FIND v(dout0_12) AT=80.025n

.meas tran vdout0_13ck150 FIND v(dout0_13) AT=80.025n

.meas tran vdout0_14ck150 FIND v(dout0_14) AT=80.025n

.meas tran vdout0_15ck150 FIND v(dout0_15) AT=80.025n

.meas tran vdout0_16ck150 FIND v(dout0_16) AT=80.025n

.meas tran vdout0_17ck150 FIND v(dout0_17) AT=80.025n

.meas tran vdout0_18ck150 FIND v(dout0_18) AT=80.025n

.meas tran vdout0_19ck150 FIND v(dout0_19) AT=80.025n

.meas tran vdout0_20ck150 FIND v(dout0_20) AT=80.025n

.meas tran vdout0_21ck150 FIND v(dout0_21) AT=80.025n

.meas tran vdout0_22ck150 FIND v(dout0_22) AT=80.025n

.meas tran vdout0_23ck150 FIND v(dout0_23) AT=80.025n

.meas tran vdout0_24ck150 FIND v(dout0_24) AT=80.025n

.meas tran vdout0_25ck150 FIND v(dout0_25) AT=80.025n

.meas tran vdout0_26ck150 FIND v(dout0_26) AT=80.025n

.meas tran vdout0_27ck150 FIND v(dout0_27) AT=80.025n

.meas tran vdout0_28ck150 FIND v(dout0_28) AT=80.025n

.meas tran vdout0_29ck150 FIND v(dout0_29) AT=80.025n

.meas tran vdout0_30ck150 FIND v(dout0_30) AT=80.025n

.meas tran vdout0_31ck150 FIND v(dout0_31) AT=80.025n

.meas tran vdout0_32ck150 FIND v(dout0_32) AT=80.025n

.meas tran vdout0_33ck150 FIND v(dout0_33) AT=80.025n

.meas tran vdout0_34ck150 FIND v(dout0_34) AT=80.025n

.meas tran vdout0_35ck150 FIND v(dout0_35) AT=80.025n

.meas tran vdout0_36ck150 FIND v(dout0_36) AT=80.025n

.meas tran vdout0_37ck150 FIND v(dout0_37) AT=80.025n

.meas tran vdout0_38ck150 FIND v(dout0_38) AT=80.025n

.meas tran vdout0_39ck150 FIND v(dout0_39) AT=80.025n

.meas tran vdout0_40ck150 FIND v(dout0_40) AT=80.025n

.meas tran vdout0_41ck150 FIND v(dout0_41) AT=80.025n

.meas tran vdout0_42ck150 FIND v(dout0_42) AT=80.025n

.meas tran vdout0_43ck150 FIND v(dout0_43) AT=80.025n

.meas tran vdout0_44ck150 FIND v(dout0_44) AT=80.025n

.meas tran vdout0_45ck150 FIND v(dout0_45) AT=80.025n

.meas tran vdout0_46ck150 FIND v(dout0_46) AT=80.025n

.meas tran vdout0_47ck150 FIND v(dout0_47) AT=80.025n

.meas tran vdout0_48ck150 FIND v(dout0_48) AT=80.025n

.meas tran vdout0_49ck150 FIND v(dout0_49) AT=80.025n

.meas tran vdout0_50ck150 FIND v(dout0_50) AT=80.025n

.meas tran vdout0_51ck150 FIND v(dout0_51) AT=80.025n

.meas tran vdout0_52ck150 FIND v(dout0_52) AT=80.025n

.meas tran vdout0_53ck150 FIND v(dout0_53) AT=80.025n

.meas tran vdout0_54ck150 FIND v(dout0_54) AT=80.025n

.meas tran vdout0_55ck150 FIND v(dout0_55) AT=80.025n

.meas tran vdout0_56ck150 FIND v(dout0_56) AT=80.025n

.meas tran vdout0_57ck150 FIND v(dout0_57) AT=80.025n

.meas tran vdout0_58ck150 FIND v(dout0_58) AT=80.025n

.meas tran vdout0_59ck150 FIND v(dout0_59) AT=80.025n

.meas tran vdout0_60ck150 FIND v(dout0_60) AT=80.025n

.meas tran vdout0_61ck150 FIND v(dout0_61) AT=80.025n

.meas tran vdout0_62ck150 FIND v(dout0_62) AT=80.025n

.meas tran vdout0_63ck150 FIND v(dout0_63) AT=80.025n

.meas tran vdout0_64ck150 FIND v(dout0_64) AT=80.025n

.meas tran vdout0_65ck150 FIND v(dout0_65) AT=80.025n

.meas tran vdout0_66ck150 FIND v(dout0_66) AT=80.025n

.meas tran vdout0_67ck150 FIND v(dout0_67) AT=80.025n

.meas tran vdout0_68ck150 FIND v(dout0_68) AT=80.025n

.meas tran vdout0_69ck150 FIND v(dout0_69) AT=80.025n

.meas tran vdout0_70ck150 FIND v(dout0_70) AT=80.025n

.meas tran vdout0_71ck150 FIND v(dout0_71) AT=80.025n

.meas tran vdout0_72ck150 FIND v(dout0_72) AT=80.025n

.meas tran vdout0_73ck150 FIND v(dout0_73) AT=80.025n

.meas tran vdout0_74ck150 FIND v(dout0_74) AT=80.025n

.meas tran vdout0_75ck150 FIND v(dout0_75) AT=80.025n

.meas tran vdout0_76ck150 FIND v(dout0_76) AT=80.025n

.meas tran vdout0_77ck150 FIND v(dout0_77) AT=80.025n

.meas tran vdout0_78ck150 FIND v(dout0_78) AT=80.025n

.meas tran vdout0_79ck150 FIND v(dout0_79) AT=80.025n

.meas tran vdout0_80ck150 FIND v(dout0_80) AT=80.025n

.meas tran vdout0_81ck150 FIND v(dout0_81) AT=80.025n

.meas tran vdout0_82ck150 FIND v(dout0_82) AT=80.025n

.meas tran vdout0_83ck150 FIND v(dout0_83) AT=80.025n

.meas tran vdout0_84ck150 FIND v(dout0_84) AT=80.025n

.meas tran vdout0_85ck150 FIND v(dout0_85) AT=80.025n

.meas tran vdout0_86ck150 FIND v(dout0_86) AT=80.025n

.meas tran vdout0_87ck150 FIND v(dout0_87) AT=80.025n

.meas tran vdout0_88ck150 FIND v(dout0_88) AT=80.025n

.meas tran vdout0_89ck150 FIND v(dout0_89) AT=80.025n

.meas tran vdout0_90ck150 FIND v(dout0_90) AT=80.025n

.meas tran vdout0_91ck150 FIND v(dout0_91) AT=80.025n

.meas tran vdout0_92ck150 FIND v(dout0_92) AT=80.025n

.meas tran vdout0_93ck150 FIND v(dout0_93) AT=80.025n

.meas tran vdout0_94ck150 FIND v(dout0_94) AT=80.025n

.meas tran vdout0_95ck150 FIND v(dout0_95) AT=80.025n

.meas tran vdout0_96ck150 FIND v(dout0_96) AT=80.025n

.meas tran vdout0_97ck150 FIND v(dout0_97) AT=80.025n

.meas tran vdout0_98ck150 FIND v(dout0_98) AT=80.025n

.meas tran vdout0_99ck150 FIND v(dout0_99) AT=80.025n

.meas tran vdout0_100ck150 FIND v(dout0_100) AT=80.025n

.meas tran vdout0_101ck150 FIND v(dout0_101) AT=80.025n

.meas tran vdout0_102ck150 FIND v(dout0_102) AT=80.025n

.meas tran vdout0_103ck150 FIND v(dout0_103) AT=80.025n

.meas tran vdout0_104ck150 FIND v(dout0_104) AT=80.025n

.meas tran vdout0_105ck150 FIND v(dout0_105) AT=80.025n

.meas tran vdout0_106ck150 FIND v(dout0_106) AT=80.025n

.meas tran vdout0_107ck150 FIND v(dout0_107) AT=80.025n

.meas tran vdout0_108ck150 FIND v(dout0_108) AT=80.025n

.meas tran vdout0_109ck150 FIND v(dout0_109) AT=80.025n

.meas tran vdout0_110ck150 FIND v(dout0_110) AT=80.025n

.meas tran vdout0_111ck150 FIND v(dout0_111) AT=80.025n

.meas tran vdout0_112ck150 FIND v(dout0_112) AT=80.025n

.meas tran vdout0_113ck150 FIND v(dout0_113) AT=80.025n

.meas tran vdout0_114ck150 FIND v(dout0_114) AT=80.025n

.meas tran vdout0_115ck150 FIND v(dout0_115) AT=80.025n

.meas tran vdout0_116ck150 FIND v(dout0_116) AT=80.025n

.meas tran vdout0_117ck150 FIND v(dout0_117) AT=80.025n

.meas tran vdout0_118ck150 FIND v(dout0_118) AT=80.025n

.meas tran vdout0_119ck150 FIND v(dout0_119) AT=80.025n

.meas tran vdout0_120ck150 FIND v(dout0_120) AT=80.025n

.meas tran vdout0_121ck150 FIND v(dout0_121) AT=80.025n

.meas tran vdout0_122ck150 FIND v(dout0_122) AT=80.025n

.meas tran vdout0_123ck150 FIND v(dout0_123) AT=80.025n

.meas tran vdout0_124ck150 FIND v(dout0_124) AT=80.025n

.meas tran vdout0_125ck150 FIND v(dout0_125) AT=80.025n

.meas tran vdout0_126ck150 FIND v(dout0_126) AT=80.025n

.meas tran vdout0_127ck150 FIND v(dout0_127) AT=80.025n

.meas tran vdout0_128ck150 FIND v(dout0_128) AT=80.025n

.meas tran vdout0_129ck150 FIND v(dout0_129) AT=80.025n

.meas tran vdout0_130ck150 FIND v(dout0_130) AT=80.025n

.meas tran vdout0_131ck150 FIND v(dout0_131) AT=80.025n

.meas tran vdout0_132ck150 FIND v(dout0_132) AT=80.025n

.meas tran vdout0_133ck150 FIND v(dout0_133) AT=80.025n

.meas tran vdout0_134ck150 FIND v(dout0_134) AT=80.025n

.meas tran vdout0_135ck150 FIND v(dout0_135) AT=80.025n

.meas tran vdout0_136ck150 FIND v(dout0_136) AT=80.025n

.meas tran vdout0_137ck150 FIND v(dout0_137) AT=80.025n

.meas tran vdout0_138ck150 FIND v(dout0_138) AT=80.025n

.meas tran vdout0_139ck150 FIND v(dout0_139) AT=80.025n

.meas tran vdout0_140ck150 FIND v(dout0_140) AT=80.025n

.meas tran vdout0_141ck150 FIND v(dout0_141) AT=80.025n

.meas tran vdout0_142ck150 FIND v(dout0_142) AT=80.025n

.meas tran vdout0_143ck150 FIND v(dout0_143) AT=80.025n

.meas tran vdout0_144ck150 FIND v(dout0_144) AT=80.025n

.meas tran vdout0_145ck150 FIND v(dout0_145) AT=80.025n

.meas tran vdout0_146ck150 FIND v(dout0_146) AT=80.025n

.meas tran vdout0_147ck150 FIND v(dout0_147) AT=80.025n

.meas tran vdout0_148ck150 FIND v(dout0_148) AT=80.025n

.meas tran vdout0_149ck150 FIND v(dout0_149) AT=80.025n

.meas tran vdout0_150ck150 FIND v(dout0_150) AT=80.025n

.meas tran vdout0_151ck150 FIND v(dout0_151) AT=80.025n

.meas tran vdout0_152ck150 FIND v(dout0_152) AT=80.025n

.meas tran vdout0_153ck150 FIND v(dout0_153) AT=80.025n

.meas tran vdout0_154ck150 FIND v(dout0_154) AT=80.025n

.meas tran vdout0_155ck150 FIND v(dout0_155) AT=80.025n

.meas tran vdout0_156ck150 FIND v(dout0_156) AT=80.025n

.meas tran vdout0_157ck150 FIND v(dout0_157) AT=80.025n

.meas tran vdout0_158ck150 FIND v(dout0_158) AT=80.025n

.meas tran vdout0_159ck150 FIND v(dout0_159) AT=80.025n

.meas tran vdout0_160ck150 FIND v(dout0_160) AT=80.025n

.meas tran vdout0_161ck150 FIND v(dout0_161) AT=80.025n

.meas tran vdout0_162ck150 FIND v(dout0_162) AT=80.025n

.meas tran vdout0_163ck150 FIND v(dout0_163) AT=80.025n

.meas tran vdout0_164ck150 FIND v(dout0_164) AT=80.025n

.meas tran vdout0_165ck150 FIND v(dout0_165) AT=80.025n

.meas tran vdout0_166ck150 FIND v(dout0_166) AT=80.025n

.meas tran vdout0_167ck150 FIND v(dout0_167) AT=80.025n

.meas tran vdout0_168ck150 FIND v(dout0_168) AT=80.025n

.meas tran vdout0_169ck150 FIND v(dout0_169) AT=80.025n

.meas tran vdout0_170ck150 FIND v(dout0_170) AT=80.025n

.meas tran vdout0_171ck150 FIND v(dout0_171) AT=80.025n

.meas tran vdout0_172ck150 FIND v(dout0_172) AT=80.025n

.meas tran vdout0_173ck150 FIND v(dout0_173) AT=80.025n

.meas tran vdout0_174ck150 FIND v(dout0_174) AT=80.025n

.meas tran vdout0_175ck150 FIND v(dout0_175) AT=80.025n

.meas tran vdout0_176ck150 FIND v(dout0_176) AT=80.025n

.meas tran vdout0_177ck150 FIND v(dout0_177) AT=80.025n

.meas tran vdout0_178ck150 FIND v(dout0_178) AT=80.025n

.meas tran vdout0_179ck150 FIND v(dout0_179) AT=80.025n

.meas tran vdout0_180ck150 FIND v(dout0_180) AT=80.025n

.meas tran vdout0_181ck150 FIND v(dout0_181) AT=80.025n

.meas tran vdout0_182ck150 FIND v(dout0_182) AT=80.025n

.meas tran vdout0_183ck150 FIND v(dout0_183) AT=80.025n

.meas tran vdout0_184ck150 FIND v(dout0_184) AT=80.025n

.meas tran vdout0_185ck150 FIND v(dout0_185) AT=80.025n

.meas tran vdout0_186ck150 FIND v(dout0_186) AT=80.025n

.meas tran vdout0_187ck150 FIND v(dout0_187) AT=80.025n

.meas tran vdout0_188ck150 FIND v(dout0_188) AT=80.025n

.meas tran vdout0_189ck150 FIND v(dout0_189) AT=80.025n

.meas tran vdout0_190ck150 FIND v(dout0_190) AT=80.025n

.meas tran vdout0_191ck150 FIND v(dout0_191) AT=80.025n

.meas tran vdout0_192ck150 FIND v(dout0_192) AT=80.025n

.meas tran vdout0_193ck150 FIND v(dout0_193) AT=80.025n

.meas tran vdout0_194ck150 FIND v(dout0_194) AT=80.025n

.meas tran vdout0_195ck150 FIND v(dout0_195) AT=80.025n

.meas tran vdout0_196ck150 FIND v(dout0_196) AT=80.025n

.meas tran vdout0_197ck150 FIND v(dout0_197) AT=80.025n

.meas tran vdout0_198ck150 FIND v(dout0_198) AT=80.025n

.meas tran vdout0_199ck150 FIND v(dout0_199) AT=80.025n

.meas tran vdout0_200ck150 FIND v(dout0_200) AT=80.025n

.meas tran vdout0_201ck150 FIND v(dout0_201) AT=80.025n

.meas tran vdout0_202ck150 FIND v(dout0_202) AT=80.025n

.meas tran vdout0_203ck150 FIND v(dout0_203) AT=80.025n

.meas tran vdout0_204ck150 FIND v(dout0_204) AT=80.025n

.meas tran vdout0_205ck150 FIND v(dout0_205) AT=80.025n

.meas tran vdout0_206ck150 FIND v(dout0_206) AT=80.025n

.meas tran vdout0_207ck150 FIND v(dout0_207) AT=80.025n

.meas tran vdout0_208ck150 FIND v(dout0_208) AT=80.025n

.meas tran vdout0_209ck150 FIND v(dout0_209) AT=80.025n

.meas tran vdout0_210ck150 FIND v(dout0_210) AT=80.025n

.meas tran vdout0_211ck150 FIND v(dout0_211) AT=80.025n

.meas tran vdout0_212ck150 FIND v(dout0_212) AT=80.025n

.meas tran vdout0_213ck150 FIND v(dout0_213) AT=80.025n

.meas tran vdout0_214ck150 FIND v(dout0_214) AT=80.025n

.meas tran vdout0_215ck150 FIND v(dout0_215) AT=80.025n

.meas tran vdout0_216ck150 FIND v(dout0_216) AT=80.025n

.meas tran vdout0_217ck150 FIND v(dout0_217) AT=80.025n

.meas tran vdout0_218ck150 FIND v(dout0_218) AT=80.025n

.meas tran vdout0_219ck150 FIND v(dout0_219) AT=80.025n

.meas tran vdout0_220ck150 FIND v(dout0_220) AT=80.025n

.meas tran vdout0_221ck150 FIND v(dout0_221) AT=80.025n

.meas tran vdout0_222ck150 FIND v(dout0_222) AT=80.025n

.meas tran vdout0_223ck150 FIND v(dout0_223) AT=80.025n

.meas tran vdout0_224ck150 FIND v(dout0_224) AT=80.025n

.meas tran vdout0_225ck150 FIND v(dout0_225) AT=80.025n

.meas tran vdout0_226ck150 FIND v(dout0_226) AT=80.025n

.meas tran vdout0_227ck150 FIND v(dout0_227) AT=80.025n

.meas tran vdout0_228ck150 FIND v(dout0_228) AT=80.025n

.meas tran vdout0_229ck150 FIND v(dout0_229) AT=80.025n

.meas tran vdout0_230ck150 FIND v(dout0_230) AT=80.025n

.meas tran vdout0_231ck150 FIND v(dout0_231) AT=80.025n

.meas tran vdout0_232ck150 FIND v(dout0_232) AT=80.025n

.meas tran vdout0_233ck150 FIND v(dout0_233) AT=80.025n

.meas tran vdout0_234ck150 FIND v(dout0_234) AT=80.025n

.meas tran vdout0_235ck150 FIND v(dout0_235) AT=80.025n

.meas tran vdout0_236ck150 FIND v(dout0_236) AT=80.025n

.meas tran vdout0_237ck150 FIND v(dout0_237) AT=80.025n

.meas tran vdout0_238ck150 FIND v(dout0_238) AT=80.025n

.meas tran vdout0_239ck150 FIND v(dout0_239) AT=80.025n

.meas tran vdout0_240ck150 FIND v(dout0_240) AT=80.025n

.meas tran vdout0_241ck150 FIND v(dout0_241) AT=80.025n

.meas tran vdout0_242ck150 FIND v(dout0_242) AT=80.025n

.meas tran vdout0_243ck150 FIND v(dout0_243) AT=80.025n

.meas tran vdout0_244ck150 FIND v(dout0_244) AT=80.025n

.meas tran vdout0_245ck150 FIND v(dout0_245) AT=80.025n

.meas tran vdout0_246ck150 FIND v(dout0_246) AT=80.025n

.meas tran vdout0_247ck150 FIND v(dout0_247) AT=80.025n

.meas tran vdout0_248ck150 FIND v(dout0_248) AT=80.025n

.meas tran vdout0_249ck150 FIND v(dout0_249) AT=80.025n

.meas tran vdout0_250ck150 FIND v(dout0_250) AT=80.025n

.meas tran vdout0_251ck150 FIND v(dout0_251) AT=80.025n

.meas tran vdout0_252ck150 FIND v(dout0_252) AT=80.025n

.meas tran vdout0_253ck150 FIND v(dout0_253) AT=80.025n

.meas tran vdout0_254ck150 FIND v(dout0_254) AT=80.025n

.meas tran vdout0_255ck150 FIND v(dout0_255) AT=80.025n

.meas tran vdout0_0ck160 FIND v(dout0_0) AT=85.025n

.meas tran vdout0_1ck160 FIND v(dout0_1) AT=85.025n

.meas tran vdout0_2ck160 FIND v(dout0_2) AT=85.025n

.meas tran vdout0_3ck160 FIND v(dout0_3) AT=85.025n

.meas tran vdout0_4ck160 FIND v(dout0_4) AT=85.025n

.meas tran vdout0_5ck160 FIND v(dout0_5) AT=85.025n

.meas tran vdout0_6ck160 FIND v(dout0_6) AT=85.025n

.meas tran vdout0_7ck160 FIND v(dout0_7) AT=85.025n

.meas tran vdout0_8ck160 FIND v(dout0_8) AT=85.025n

.meas tran vdout0_9ck160 FIND v(dout0_9) AT=85.025n

.meas tran vdout0_10ck160 FIND v(dout0_10) AT=85.025n

.meas tran vdout0_11ck160 FIND v(dout0_11) AT=85.025n

.meas tran vdout0_12ck160 FIND v(dout0_12) AT=85.025n

.meas tran vdout0_13ck160 FIND v(dout0_13) AT=85.025n

.meas tran vdout0_14ck160 FIND v(dout0_14) AT=85.025n

.meas tran vdout0_15ck160 FIND v(dout0_15) AT=85.025n

.meas tran vdout0_16ck160 FIND v(dout0_16) AT=85.025n

.meas tran vdout0_17ck160 FIND v(dout0_17) AT=85.025n

.meas tran vdout0_18ck160 FIND v(dout0_18) AT=85.025n

.meas tran vdout0_19ck160 FIND v(dout0_19) AT=85.025n

.meas tran vdout0_20ck160 FIND v(dout0_20) AT=85.025n

.meas tran vdout0_21ck160 FIND v(dout0_21) AT=85.025n

.meas tran vdout0_22ck160 FIND v(dout0_22) AT=85.025n

.meas tran vdout0_23ck160 FIND v(dout0_23) AT=85.025n

.meas tran vdout0_24ck160 FIND v(dout0_24) AT=85.025n

.meas tran vdout0_25ck160 FIND v(dout0_25) AT=85.025n

.meas tran vdout0_26ck160 FIND v(dout0_26) AT=85.025n

.meas tran vdout0_27ck160 FIND v(dout0_27) AT=85.025n

.meas tran vdout0_28ck160 FIND v(dout0_28) AT=85.025n

.meas tran vdout0_29ck160 FIND v(dout0_29) AT=85.025n

.meas tran vdout0_30ck160 FIND v(dout0_30) AT=85.025n

.meas tran vdout0_31ck160 FIND v(dout0_31) AT=85.025n

.meas tran vdout0_32ck160 FIND v(dout0_32) AT=85.025n

.meas tran vdout0_33ck160 FIND v(dout0_33) AT=85.025n

.meas tran vdout0_34ck160 FIND v(dout0_34) AT=85.025n

.meas tran vdout0_35ck160 FIND v(dout0_35) AT=85.025n

.meas tran vdout0_36ck160 FIND v(dout0_36) AT=85.025n

.meas tran vdout0_37ck160 FIND v(dout0_37) AT=85.025n

.meas tran vdout0_38ck160 FIND v(dout0_38) AT=85.025n

.meas tran vdout0_39ck160 FIND v(dout0_39) AT=85.025n

.meas tran vdout0_40ck160 FIND v(dout0_40) AT=85.025n

.meas tran vdout0_41ck160 FIND v(dout0_41) AT=85.025n

.meas tran vdout0_42ck160 FIND v(dout0_42) AT=85.025n

.meas tran vdout0_43ck160 FIND v(dout0_43) AT=85.025n

.meas tran vdout0_44ck160 FIND v(dout0_44) AT=85.025n

.meas tran vdout0_45ck160 FIND v(dout0_45) AT=85.025n

.meas tran vdout0_46ck160 FIND v(dout0_46) AT=85.025n

.meas tran vdout0_47ck160 FIND v(dout0_47) AT=85.025n

.meas tran vdout0_48ck160 FIND v(dout0_48) AT=85.025n

.meas tran vdout0_49ck160 FIND v(dout0_49) AT=85.025n

.meas tran vdout0_50ck160 FIND v(dout0_50) AT=85.025n

.meas tran vdout0_51ck160 FIND v(dout0_51) AT=85.025n

.meas tran vdout0_52ck160 FIND v(dout0_52) AT=85.025n

.meas tran vdout0_53ck160 FIND v(dout0_53) AT=85.025n

.meas tran vdout0_54ck160 FIND v(dout0_54) AT=85.025n

.meas tran vdout0_55ck160 FIND v(dout0_55) AT=85.025n

.meas tran vdout0_56ck160 FIND v(dout0_56) AT=85.025n

.meas tran vdout0_57ck160 FIND v(dout0_57) AT=85.025n

.meas tran vdout0_58ck160 FIND v(dout0_58) AT=85.025n

.meas tran vdout0_59ck160 FIND v(dout0_59) AT=85.025n

.meas tran vdout0_60ck160 FIND v(dout0_60) AT=85.025n

.meas tran vdout0_61ck160 FIND v(dout0_61) AT=85.025n

.meas tran vdout0_62ck160 FIND v(dout0_62) AT=85.025n

.meas tran vdout0_63ck160 FIND v(dout0_63) AT=85.025n

.meas tran vdout0_64ck160 FIND v(dout0_64) AT=85.025n

.meas tran vdout0_65ck160 FIND v(dout0_65) AT=85.025n

.meas tran vdout0_66ck160 FIND v(dout0_66) AT=85.025n

.meas tran vdout0_67ck160 FIND v(dout0_67) AT=85.025n

.meas tran vdout0_68ck160 FIND v(dout0_68) AT=85.025n

.meas tran vdout0_69ck160 FIND v(dout0_69) AT=85.025n

.meas tran vdout0_70ck160 FIND v(dout0_70) AT=85.025n

.meas tran vdout0_71ck160 FIND v(dout0_71) AT=85.025n

.meas tran vdout0_72ck160 FIND v(dout0_72) AT=85.025n

.meas tran vdout0_73ck160 FIND v(dout0_73) AT=85.025n

.meas tran vdout0_74ck160 FIND v(dout0_74) AT=85.025n

.meas tran vdout0_75ck160 FIND v(dout0_75) AT=85.025n

.meas tran vdout0_76ck160 FIND v(dout0_76) AT=85.025n

.meas tran vdout0_77ck160 FIND v(dout0_77) AT=85.025n

.meas tran vdout0_78ck160 FIND v(dout0_78) AT=85.025n

.meas tran vdout0_79ck160 FIND v(dout0_79) AT=85.025n

.meas tran vdout0_80ck160 FIND v(dout0_80) AT=85.025n

.meas tran vdout0_81ck160 FIND v(dout0_81) AT=85.025n

.meas tran vdout0_82ck160 FIND v(dout0_82) AT=85.025n

.meas tran vdout0_83ck160 FIND v(dout0_83) AT=85.025n

.meas tran vdout0_84ck160 FIND v(dout0_84) AT=85.025n

.meas tran vdout0_85ck160 FIND v(dout0_85) AT=85.025n

.meas tran vdout0_86ck160 FIND v(dout0_86) AT=85.025n

.meas tran vdout0_87ck160 FIND v(dout0_87) AT=85.025n

.meas tran vdout0_88ck160 FIND v(dout0_88) AT=85.025n

.meas tran vdout0_89ck160 FIND v(dout0_89) AT=85.025n

.meas tran vdout0_90ck160 FIND v(dout0_90) AT=85.025n

.meas tran vdout0_91ck160 FIND v(dout0_91) AT=85.025n

.meas tran vdout0_92ck160 FIND v(dout0_92) AT=85.025n

.meas tran vdout0_93ck160 FIND v(dout0_93) AT=85.025n

.meas tran vdout0_94ck160 FIND v(dout0_94) AT=85.025n

.meas tran vdout0_95ck160 FIND v(dout0_95) AT=85.025n

.meas tran vdout0_96ck160 FIND v(dout0_96) AT=85.025n

.meas tran vdout0_97ck160 FIND v(dout0_97) AT=85.025n

.meas tran vdout0_98ck160 FIND v(dout0_98) AT=85.025n

.meas tran vdout0_99ck160 FIND v(dout0_99) AT=85.025n

.meas tran vdout0_100ck160 FIND v(dout0_100) AT=85.025n

.meas tran vdout0_101ck160 FIND v(dout0_101) AT=85.025n

.meas tran vdout0_102ck160 FIND v(dout0_102) AT=85.025n

.meas tran vdout0_103ck160 FIND v(dout0_103) AT=85.025n

.meas tran vdout0_104ck160 FIND v(dout0_104) AT=85.025n

.meas tran vdout0_105ck160 FIND v(dout0_105) AT=85.025n

.meas tran vdout0_106ck160 FIND v(dout0_106) AT=85.025n

.meas tran vdout0_107ck160 FIND v(dout0_107) AT=85.025n

.meas tran vdout0_108ck160 FIND v(dout0_108) AT=85.025n

.meas tran vdout0_109ck160 FIND v(dout0_109) AT=85.025n

.meas tran vdout0_110ck160 FIND v(dout0_110) AT=85.025n

.meas tran vdout0_111ck160 FIND v(dout0_111) AT=85.025n

.meas tran vdout0_112ck160 FIND v(dout0_112) AT=85.025n

.meas tran vdout0_113ck160 FIND v(dout0_113) AT=85.025n

.meas tran vdout0_114ck160 FIND v(dout0_114) AT=85.025n

.meas tran vdout0_115ck160 FIND v(dout0_115) AT=85.025n

.meas tran vdout0_116ck160 FIND v(dout0_116) AT=85.025n

.meas tran vdout0_117ck160 FIND v(dout0_117) AT=85.025n

.meas tran vdout0_118ck160 FIND v(dout0_118) AT=85.025n

.meas tran vdout0_119ck160 FIND v(dout0_119) AT=85.025n

.meas tran vdout0_120ck160 FIND v(dout0_120) AT=85.025n

.meas tran vdout0_121ck160 FIND v(dout0_121) AT=85.025n

.meas tran vdout0_122ck160 FIND v(dout0_122) AT=85.025n

.meas tran vdout0_123ck160 FIND v(dout0_123) AT=85.025n

.meas tran vdout0_124ck160 FIND v(dout0_124) AT=85.025n

.meas tran vdout0_125ck160 FIND v(dout0_125) AT=85.025n

.meas tran vdout0_126ck160 FIND v(dout0_126) AT=85.025n

.meas tran vdout0_127ck160 FIND v(dout0_127) AT=85.025n

.meas tran vdout0_128ck160 FIND v(dout0_128) AT=85.025n

.meas tran vdout0_129ck160 FIND v(dout0_129) AT=85.025n

.meas tran vdout0_130ck160 FIND v(dout0_130) AT=85.025n

.meas tran vdout0_131ck160 FIND v(dout0_131) AT=85.025n

.meas tran vdout0_132ck160 FIND v(dout0_132) AT=85.025n

.meas tran vdout0_133ck160 FIND v(dout0_133) AT=85.025n

.meas tran vdout0_134ck160 FIND v(dout0_134) AT=85.025n

.meas tran vdout0_135ck160 FIND v(dout0_135) AT=85.025n

.meas tran vdout0_136ck160 FIND v(dout0_136) AT=85.025n

.meas tran vdout0_137ck160 FIND v(dout0_137) AT=85.025n

.meas tran vdout0_138ck160 FIND v(dout0_138) AT=85.025n

.meas tran vdout0_139ck160 FIND v(dout0_139) AT=85.025n

.meas tran vdout0_140ck160 FIND v(dout0_140) AT=85.025n

.meas tran vdout0_141ck160 FIND v(dout0_141) AT=85.025n

.meas tran vdout0_142ck160 FIND v(dout0_142) AT=85.025n

.meas tran vdout0_143ck160 FIND v(dout0_143) AT=85.025n

.meas tran vdout0_144ck160 FIND v(dout0_144) AT=85.025n

.meas tran vdout0_145ck160 FIND v(dout0_145) AT=85.025n

.meas tran vdout0_146ck160 FIND v(dout0_146) AT=85.025n

.meas tran vdout0_147ck160 FIND v(dout0_147) AT=85.025n

.meas tran vdout0_148ck160 FIND v(dout0_148) AT=85.025n

.meas tran vdout0_149ck160 FIND v(dout0_149) AT=85.025n

.meas tran vdout0_150ck160 FIND v(dout0_150) AT=85.025n

.meas tran vdout0_151ck160 FIND v(dout0_151) AT=85.025n

.meas tran vdout0_152ck160 FIND v(dout0_152) AT=85.025n

.meas tran vdout0_153ck160 FIND v(dout0_153) AT=85.025n

.meas tran vdout0_154ck160 FIND v(dout0_154) AT=85.025n

.meas tran vdout0_155ck160 FIND v(dout0_155) AT=85.025n

.meas tran vdout0_156ck160 FIND v(dout0_156) AT=85.025n

.meas tran vdout0_157ck160 FIND v(dout0_157) AT=85.025n

.meas tran vdout0_158ck160 FIND v(dout0_158) AT=85.025n

.meas tran vdout0_159ck160 FIND v(dout0_159) AT=85.025n

.meas tran vdout0_160ck160 FIND v(dout0_160) AT=85.025n

.meas tran vdout0_161ck160 FIND v(dout0_161) AT=85.025n

.meas tran vdout0_162ck160 FIND v(dout0_162) AT=85.025n

.meas tran vdout0_163ck160 FIND v(dout0_163) AT=85.025n

.meas tran vdout0_164ck160 FIND v(dout0_164) AT=85.025n

.meas tran vdout0_165ck160 FIND v(dout0_165) AT=85.025n

.meas tran vdout0_166ck160 FIND v(dout0_166) AT=85.025n

.meas tran vdout0_167ck160 FIND v(dout0_167) AT=85.025n

.meas tran vdout0_168ck160 FIND v(dout0_168) AT=85.025n

.meas tran vdout0_169ck160 FIND v(dout0_169) AT=85.025n

.meas tran vdout0_170ck160 FIND v(dout0_170) AT=85.025n

.meas tran vdout0_171ck160 FIND v(dout0_171) AT=85.025n

.meas tran vdout0_172ck160 FIND v(dout0_172) AT=85.025n

.meas tran vdout0_173ck160 FIND v(dout0_173) AT=85.025n

.meas tran vdout0_174ck160 FIND v(dout0_174) AT=85.025n

.meas tran vdout0_175ck160 FIND v(dout0_175) AT=85.025n

.meas tran vdout0_176ck160 FIND v(dout0_176) AT=85.025n

.meas tran vdout0_177ck160 FIND v(dout0_177) AT=85.025n

.meas tran vdout0_178ck160 FIND v(dout0_178) AT=85.025n

.meas tran vdout0_179ck160 FIND v(dout0_179) AT=85.025n

.meas tran vdout0_180ck160 FIND v(dout0_180) AT=85.025n

.meas tran vdout0_181ck160 FIND v(dout0_181) AT=85.025n

.meas tran vdout0_182ck160 FIND v(dout0_182) AT=85.025n

.meas tran vdout0_183ck160 FIND v(dout0_183) AT=85.025n

.meas tran vdout0_184ck160 FIND v(dout0_184) AT=85.025n

.meas tran vdout0_185ck160 FIND v(dout0_185) AT=85.025n

.meas tran vdout0_186ck160 FIND v(dout0_186) AT=85.025n

.meas tran vdout0_187ck160 FIND v(dout0_187) AT=85.025n

.meas tran vdout0_188ck160 FIND v(dout0_188) AT=85.025n

.meas tran vdout0_189ck160 FIND v(dout0_189) AT=85.025n

.meas tran vdout0_190ck160 FIND v(dout0_190) AT=85.025n

.meas tran vdout0_191ck160 FIND v(dout0_191) AT=85.025n

.meas tran vdout0_192ck160 FIND v(dout0_192) AT=85.025n

.meas tran vdout0_193ck160 FIND v(dout0_193) AT=85.025n

.meas tran vdout0_194ck160 FIND v(dout0_194) AT=85.025n

.meas tran vdout0_195ck160 FIND v(dout0_195) AT=85.025n

.meas tran vdout0_196ck160 FIND v(dout0_196) AT=85.025n

.meas tran vdout0_197ck160 FIND v(dout0_197) AT=85.025n

.meas tran vdout0_198ck160 FIND v(dout0_198) AT=85.025n

.meas tran vdout0_199ck160 FIND v(dout0_199) AT=85.025n

.meas tran vdout0_200ck160 FIND v(dout0_200) AT=85.025n

.meas tran vdout0_201ck160 FIND v(dout0_201) AT=85.025n

.meas tran vdout0_202ck160 FIND v(dout0_202) AT=85.025n

.meas tran vdout0_203ck160 FIND v(dout0_203) AT=85.025n

.meas tran vdout0_204ck160 FIND v(dout0_204) AT=85.025n

.meas tran vdout0_205ck160 FIND v(dout0_205) AT=85.025n

.meas tran vdout0_206ck160 FIND v(dout0_206) AT=85.025n

.meas tran vdout0_207ck160 FIND v(dout0_207) AT=85.025n

.meas tran vdout0_208ck160 FIND v(dout0_208) AT=85.025n

.meas tran vdout0_209ck160 FIND v(dout0_209) AT=85.025n

.meas tran vdout0_210ck160 FIND v(dout0_210) AT=85.025n

.meas tran vdout0_211ck160 FIND v(dout0_211) AT=85.025n

.meas tran vdout0_212ck160 FIND v(dout0_212) AT=85.025n

.meas tran vdout0_213ck160 FIND v(dout0_213) AT=85.025n

.meas tran vdout0_214ck160 FIND v(dout0_214) AT=85.025n

.meas tran vdout0_215ck160 FIND v(dout0_215) AT=85.025n

.meas tran vdout0_216ck160 FIND v(dout0_216) AT=85.025n

.meas tran vdout0_217ck160 FIND v(dout0_217) AT=85.025n

.meas tran vdout0_218ck160 FIND v(dout0_218) AT=85.025n

.meas tran vdout0_219ck160 FIND v(dout0_219) AT=85.025n

.meas tran vdout0_220ck160 FIND v(dout0_220) AT=85.025n

.meas tran vdout0_221ck160 FIND v(dout0_221) AT=85.025n

.meas tran vdout0_222ck160 FIND v(dout0_222) AT=85.025n

.meas tran vdout0_223ck160 FIND v(dout0_223) AT=85.025n

.meas tran vdout0_224ck160 FIND v(dout0_224) AT=85.025n

.meas tran vdout0_225ck160 FIND v(dout0_225) AT=85.025n

.meas tran vdout0_226ck160 FIND v(dout0_226) AT=85.025n

.meas tran vdout0_227ck160 FIND v(dout0_227) AT=85.025n

.meas tran vdout0_228ck160 FIND v(dout0_228) AT=85.025n

.meas tran vdout0_229ck160 FIND v(dout0_229) AT=85.025n

.meas tran vdout0_230ck160 FIND v(dout0_230) AT=85.025n

.meas tran vdout0_231ck160 FIND v(dout0_231) AT=85.025n

.meas tran vdout0_232ck160 FIND v(dout0_232) AT=85.025n

.meas tran vdout0_233ck160 FIND v(dout0_233) AT=85.025n

.meas tran vdout0_234ck160 FIND v(dout0_234) AT=85.025n

.meas tran vdout0_235ck160 FIND v(dout0_235) AT=85.025n

.meas tran vdout0_236ck160 FIND v(dout0_236) AT=85.025n

.meas tran vdout0_237ck160 FIND v(dout0_237) AT=85.025n

.meas tran vdout0_238ck160 FIND v(dout0_238) AT=85.025n

.meas tran vdout0_239ck160 FIND v(dout0_239) AT=85.025n

.meas tran vdout0_240ck160 FIND v(dout0_240) AT=85.025n

.meas tran vdout0_241ck160 FIND v(dout0_241) AT=85.025n

.meas tran vdout0_242ck160 FIND v(dout0_242) AT=85.025n

.meas tran vdout0_243ck160 FIND v(dout0_243) AT=85.025n

.meas tran vdout0_244ck160 FIND v(dout0_244) AT=85.025n

.meas tran vdout0_245ck160 FIND v(dout0_245) AT=85.025n

.meas tran vdout0_246ck160 FIND v(dout0_246) AT=85.025n

.meas tran vdout0_247ck160 FIND v(dout0_247) AT=85.025n

.meas tran vdout0_248ck160 FIND v(dout0_248) AT=85.025n

.meas tran vdout0_249ck160 FIND v(dout0_249) AT=85.025n

.meas tran vdout0_250ck160 FIND v(dout0_250) AT=85.025n

.meas tran vdout0_251ck160 FIND v(dout0_251) AT=85.025n

.meas tran vdout0_252ck160 FIND v(dout0_252) AT=85.025n

.meas tran vdout0_253ck160 FIND v(dout0_253) AT=85.025n

.meas tran vdout0_254ck160 FIND v(dout0_254) AT=85.025n

.meas tran vdout0_255ck160 FIND v(dout0_255) AT=85.025n

.meas tran vdout0_0ck280 FIND v(dout0_0) AT=145.025n

.meas tran vdout0_1ck280 FIND v(dout0_1) AT=145.025n

.meas tran vdout0_2ck280 FIND v(dout0_2) AT=145.025n

.meas tran vdout0_3ck280 FIND v(dout0_3) AT=145.025n

.meas tran vdout0_4ck280 FIND v(dout0_4) AT=145.025n

.meas tran vdout0_5ck280 FIND v(dout0_5) AT=145.025n

.meas tran vdout0_6ck280 FIND v(dout0_6) AT=145.025n

.meas tran vdout0_7ck280 FIND v(dout0_7) AT=145.025n

.meas tran vdout0_8ck280 FIND v(dout0_8) AT=145.025n

.meas tran vdout0_9ck280 FIND v(dout0_9) AT=145.025n

.meas tran vdout0_10ck280 FIND v(dout0_10) AT=145.025n

.meas tran vdout0_11ck280 FIND v(dout0_11) AT=145.025n

.meas tran vdout0_12ck280 FIND v(dout0_12) AT=145.025n

.meas tran vdout0_13ck280 FIND v(dout0_13) AT=145.025n

.meas tran vdout0_14ck280 FIND v(dout0_14) AT=145.025n

.meas tran vdout0_15ck280 FIND v(dout0_15) AT=145.025n

.meas tran vdout0_16ck280 FIND v(dout0_16) AT=145.025n

.meas tran vdout0_17ck280 FIND v(dout0_17) AT=145.025n

.meas tran vdout0_18ck280 FIND v(dout0_18) AT=145.025n

.meas tran vdout0_19ck280 FIND v(dout0_19) AT=145.025n

.meas tran vdout0_20ck280 FIND v(dout0_20) AT=145.025n

.meas tran vdout0_21ck280 FIND v(dout0_21) AT=145.025n

.meas tran vdout0_22ck280 FIND v(dout0_22) AT=145.025n

.meas tran vdout0_23ck280 FIND v(dout0_23) AT=145.025n

.meas tran vdout0_24ck280 FIND v(dout0_24) AT=145.025n

.meas tran vdout0_25ck280 FIND v(dout0_25) AT=145.025n

.meas tran vdout0_26ck280 FIND v(dout0_26) AT=145.025n

.meas tran vdout0_27ck280 FIND v(dout0_27) AT=145.025n

.meas tran vdout0_28ck280 FIND v(dout0_28) AT=145.025n

.meas tran vdout0_29ck280 FIND v(dout0_29) AT=145.025n

.meas tran vdout0_30ck280 FIND v(dout0_30) AT=145.025n

.meas tran vdout0_31ck280 FIND v(dout0_31) AT=145.025n

.meas tran vdout0_32ck280 FIND v(dout0_32) AT=145.025n

.meas tran vdout0_33ck280 FIND v(dout0_33) AT=145.025n

.meas tran vdout0_34ck280 FIND v(dout0_34) AT=145.025n

.meas tran vdout0_35ck280 FIND v(dout0_35) AT=145.025n

.meas tran vdout0_36ck280 FIND v(dout0_36) AT=145.025n

.meas tran vdout0_37ck280 FIND v(dout0_37) AT=145.025n

.meas tran vdout0_38ck280 FIND v(dout0_38) AT=145.025n

.meas tran vdout0_39ck280 FIND v(dout0_39) AT=145.025n

.meas tran vdout0_40ck280 FIND v(dout0_40) AT=145.025n

.meas tran vdout0_41ck280 FIND v(dout0_41) AT=145.025n

.meas tran vdout0_42ck280 FIND v(dout0_42) AT=145.025n

.meas tran vdout0_43ck280 FIND v(dout0_43) AT=145.025n

.meas tran vdout0_44ck280 FIND v(dout0_44) AT=145.025n

.meas tran vdout0_45ck280 FIND v(dout0_45) AT=145.025n

.meas tran vdout0_46ck280 FIND v(dout0_46) AT=145.025n

.meas tran vdout0_47ck280 FIND v(dout0_47) AT=145.025n

.meas tran vdout0_48ck280 FIND v(dout0_48) AT=145.025n

.meas tran vdout0_49ck280 FIND v(dout0_49) AT=145.025n

.meas tran vdout0_50ck280 FIND v(dout0_50) AT=145.025n

.meas tran vdout0_51ck280 FIND v(dout0_51) AT=145.025n

.meas tran vdout0_52ck280 FIND v(dout0_52) AT=145.025n

.meas tran vdout0_53ck280 FIND v(dout0_53) AT=145.025n

.meas tran vdout0_54ck280 FIND v(dout0_54) AT=145.025n

.meas tran vdout0_55ck280 FIND v(dout0_55) AT=145.025n

.meas tran vdout0_56ck280 FIND v(dout0_56) AT=145.025n

.meas tran vdout0_57ck280 FIND v(dout0_57) AT=145.025n

.meas tran vdout0_58ck280 FIND v(dout0_58) AT=145.025n

.meas tran vdout0_59ck280 FIND v(dout0_59) AT=145.025n

.meas tran vdout0_60ck280 FIND v(dout0_60) AT=145.025n

.meas tran vdout0_61ck280 FIND v(dout0_61) AT=145.025n

.meas tran vdout0_62ck280 FIND v(dout0_62) AT=145.025n

.meas tran vdout0_63ck280 FIND v(dout0_63) AT=145.025n

.meas tran vdout0_64ck280 FIND v(dout0_64) AT=145.025n

.meas tran vdout0_65ck280 FIND v(dout0_65) AT=145.025n

.meas tran vdout0_66ck280 FIND v(dout0_66) AT=145.025n

.meas tran vdout0_67ck280 FIND v(dout0_67) AT=145.025n

.meas tran vdout0_68ck280 FIND v(dout0_68) AT=145.025n

.meas tran vdout0_69ck280 FIND v(dout0_69) AT=145.025n

.meas tran vdout0_70ck280 FIND v(dout0_70) AT=145.025n

.meas tran vdout0_71ck280 FIND v(dout0_71) AT=145.025n

.meas tran vdout0_72ck280 FIND v(dout0_72) AT=145.025n

.meas tran vdout0_73ck280 FIND v(dout0_73) AT=145.025n

.meas tran vdout0_74ck280 FIND v(dout0_74) AT=145.025n

.meas tran vdout0_75ck280 FIND v(dout0_75) AT=145.025n

.meas tran vdout0_76ck280 FIND v(dout0_76) AT=145.025n

.meas tran vdout0_77ck280 FIND v(dout0_77) AT=145.025n

.meas tran vdout0_78ck280 FIND v(dout0_78) AT=145.025n

.meas tran vdout0_79ck280 FIND v(dout0_79) AT=145.025n

.meas tran vdout0_80ck280 FIND v(dout0_80) AT=145.025n

.meas tran vdout0_81ck280 FIND v(dout0_81) AT=145.025n

.meas tran vdout0_82ck280 FIND v(dout0_82) AT=145.025n

.meas tran vdout0_83ck280 FIND v(dout0_83) AT=145.025n

.meas tran vdout0_84ck280 FIND v(dout0_84) AT=145.025n

.meas tran vdout0_85ck280 FIND v(dout0_85) AT=145.025n

.meas tran vdout0_86ck280 FIND v(dout0_86) AT=145.025n

.meas tran vdout0_87ck280 FIND v(dout0_87) AT=145.025n

.meas tran vdout0_88ck280 FIND v(dout0_88) AT=145.025n

.meas tran vdout0_89ck280 FIND v(dout0_89) AT=145.025n

.meas tran vdout0_90ck280 FIND v(dout0_90) AT=145.025n

.meas tran vdout0_91ck280 FIND v(dout0_91) AT=145.025n

.meas tran vdout0_92ck280 FIND v(dout0_92) AT=145.025n

.meas tran vdout0_93ck280 FIND v(dout0_93) AT=145.025n

.meas tran vdout0_94ck280 FIND v(dout0_94) AT=145.025n

.meas tran vdout0_95ck280 FIND v(dout0_95) AT=145.025n

.meas tran vdout0_96ck280 FIND v(dout0_96) AT=145.025n

.meas tran vdout0_97ck280 FIND v(dout0_97) AT=145.025n

.meas tran vdout0_98ck280 FIND v(dout0_98) AT=145.025n

.meas tran vdout0_99ck280 FIND v(dout0_99) AT=145.025n

.meas tran vdout0_100ck280 FIND v(dout0_100) AT=145.025n

.meas tran vdout0_101ck280 FIND v(dout0_101) AT=145.025n

.meas tran vdout0_102ck280 FIND v(dout0_102) AT=145.025n

.meas tran vdout0_103ck280 FIND v(dout0_103) AT=145.025n

.meas tran vdout0_104ck280 FIND v(dout0_104) AT=145.025n

.meas tran vdout0_105ck280 FIND v(dout0_105) AT=145.025n

.meas tran vdout0_106ck280 FIND v(dout0_106) AT=145.025n

.meas tran vdout0_107ck280 FIND v(dout0_107) AT=145.025n

.meas tran vdout0_108ck280 FIND v(dout0_108) AT=145.025n

.meas tran vdout0_109ck280 FIND v(dout0_109) AT=145.025n

.meas tran vdout0_110ck280 FIND v(dout0_110) AT=145.025n

.meas tran vdout0_111ck280 FIND v(dout0_111) AT=145.025n

.meas tran vdout0_112ck280 FIND v(dout0_112) AT=145.025n

.meas tran vdout0_113ck280 FIND v(dout0_113) AT=145.025n

.meas tran vdout0_114ck280 FIND v(dout0_114) AT=145.025n

.meas tran vdout0_115ck280 FIND v(dout0_115) AT=145.025n

.meas tran vdout0_116ck280 FIND v(dout0_116) AT=145.025n

.meas tran vdout0_117ck280 FIND v(dout0_117) AT=145.025n

.meas tran vdout0_118ck280 FIND v(dout0_118) AT=145.025n

.meas tran vdout0_119ck280 FIND v(dout0_119) AT=145.025n

.meas tran vdout0_120ck280 FIND v(dout0_120) AT=145.025n

.meas tran vdout0_121ck280 FIND v(dout0_121) AT=145.025n

.meas tran vdout0_122ck280 FIND v(dout0_122) AT=145.025n

.meas tran vdout0_123ck280 FIND v(dout0_123) AT=145.025n

.meas tran vdout0_124ck280 FIND v(dout0_124) AT=145.025n

.meas tran vdout0_125ck280 FIND v(dout0_125) AT=145.025n

.meas tran vdout0_126ck280 FIND v(dout0_126) AT=145.025n

.meas tran vdout0_127ck280 FIND v(dout0_127) AT=145.025n

.meas tran vdout0_128ck280 FIND v(dout0_128) AT=145.025n

.meas tran vdout0_129ck280 FIND v(dout0_129) AT=145.025n

.meas tran vdout0_130ck280 FIND v(dout0_130) AT=145.025n

.meas tran vdout0_131ck280 FIND v(dout0_131) AT=145.025n

.meas tran vdout0_132ck280 FIND v(dout0_132) AT=145.025n

.meas tran vdout0_133ck280 FIND v(dout0_133) AT=145.025n

.meas tran vdout0_134ck280 FIND v(dout0_134) AT=145.025n

.meas tran vdout0_135ck280 FIND v(dout0_135) AT=145.025n

.meas tran vdout0_136ck280 FIND v(dout0_136) AT=145.025n

.meas tran vdout0_137ck280 FIND v(dout0_137) AT=145.025n

.meas tran vdout0_138ck280 FIND v(dout0_138) AT=145.025n

.meas tran vdout0_139ck280 FIND v(dout0_139) AT=145.025n

.meas tran vdout0_140ck280 FIND v(dout0_140) AT=145.025n

.meas tran vdout0_141ck280 FIND v(dout0_141) AT=145.025n

.meas tran vdout0_142ck280 FIND v(dout0_142) AT=145.025n

.meas tran vdout0_143ck280 FIND v(dout0_143) AT=145.025n

.meas tran vdout0_144ck280 FIND v(dout0_144) AT=145.025n

.meas tran vdout0_145ck280 FIND v(dout0_145) AT=145.025n

.meas tran vdout0_146ck280 FIND v(dout0_146) AT=145.025n

.meas tran vdout0_147ck280 FIND v(dout0_147) AT=145.025n

.meas tran vdout0_148ck280 FIND v(dout0_148) AT=145.025n

.meas tran vdout0_149ck280 FIND v(dout0_149) AT=145.025n

.meas tran vdout0_150ck280 FIND v(dout0_150) AT=145.025n

.meas tran vdout0_151ck280 FIND v(dout0_151) AT=145.025n

.meas tran vdout0_152ck280 FIND v(dout0_152) AT=145.025n

.meas tran vdout0_153ck280 FIND v(dout0_153) AT=145.025n

.meas tran vdout0_154ck280 FIND v(dout0_154) AT=145.025n

.meas tran vdout0_155ck280 FIND v(dout0_155) AT=145.025n

.meas tran vdout0_156ck280 FIND v(dout0_156) AT=145.025n

.meas tran vdout0_157ck280 FIND v(dout0_157) AT=145.025n

.meas tran vdout0_158ck280 FIND v(dout0_158) AT=145.025n

.meas tran vdout0_159ck280 FIND v(dout0_159) AT=145.025n

.meas tran vdout0_160ck280 FIND v(dout0_160) AT=145.025n

.meas tran vdout0_161ck280 FIND v(dout0_161) AT=145.025n

.meas tran vdout0_162ck280 FIND v(dout0_162) AT=145.025n

.meas tran vdout0_163ck280 FIND v(dout0_163) AT=145.025n

.meas tran vdout0_164ck280 FIND v(dout0_164) AT=145.025n

.meas tran vdout0_165ck280 FIND v(dout0_165) AT=145.025n

.meas tran vdout0_166ck280 FIND v(dout0_166) AT=145.025n

.meas tran vdout0_167ck280 FIND v(dout0_167) AT=145.025n

.meas tran vdout0_168ck280 FIND v(dout0_168) AT=145.025n

.meas tran vdout0_169ck280 FIND v(dout0_169) AT=145.025n

.meas tran vdout0_170ck280 FIND v(dout0_170) AT=145.025n

.meas tran vdout0_171ck280 FIND v(dout0_171) AT=145.025n

.meas tran vdout0_172ck280 FIND v(dout0_172) AT=145.025n

.meas tran vdout0_173ck280 FIND v(dout0_173) AT=145.025n

.meas tran vdout0_174ck280 FIND v(dout0_174) AT=145.025n

.meas tran vdout0_175ck280 FIND v(dout0_175) AT=145.025n

.meas tran vdout0_176ck280 FIND v(dout0_176) AT=145.025n

.meas tran vdout0_177ck280 FIND v(dout0_177) AT=145.025n

.meas tran vdout0_178ck280 FIND v(dout0_178) AT=145.025n

.meas tran vdout0_179ck280 FIND v(dout0_179) AT=145.025n

.meas tran vdout0_180ck280 FIND v(dout0_180) AT=145.025n

.meas tran vdout0_181ck280 FIND v(dout0_181) AT=145.025n

.meas tran vdout0_182ck280 FIND v(dout0_182) AT=145.025n

.meas tran vdout0_183ck280 FIND v(dout0_183) AT=145.025n

.meas tran vdout0_184ck280 FIND v(dout0_184) AT=145.025n

.meas tran vdout0_185ck280 FIND v(dout0_185) AT=145.025n

.meas tran vdout0_186ck280 FIND v(dout0_186) AT=145.025n

.meas tran vdout0_187ck280 FIND v(dout0_187) AT=145.025n

.meas tran vdout0_188ck280 FIND v(dout0_188) AT=145.025n

.meas tran vdout0_189ck280 FIND v(dout0_189) AT=145.025n

.meas tran vdout0_190ck280 FIND v(dout0_190) AT=145.025n

.meas tran vdout0_191ck280 FIND v(dout0_191) AT=145.025n

.meas tran vdout0_192ck280 FIND v(dout0_192) AT=145.025n

.meas tran vdout0_193ck280 FIND v(dout0_193) AT=145.025n

.meas tran vdout0_194ck280 FIND v(dout0_194) AT=145.025n

.meas tran vdout0_195ck280 FIND v(dout0_195) AT=145.025n

.meas tran vdout0_196ck280 FIND v(dout0_196) AT=145.025n

.meas tran vdout0_197ck280 FIND v(dout0_197) AT=145.025n

.meas tran vdout0_198ck280 FIND v(dout0_198) AT=145.025n

.meas tran vdout0_199ck280 FIND v(dout0_199) AT=145.025n

.meas tran vdout0_200ck280 FIND v(dout0_200) AT=145.025n

.meas tran vdout0_201ck280 FIND v(dout0_201) AT=145.025n

.meas tran vdout0_202ck280 FIND v(dout0_202) AT=145.025n

.meas tran vdout0_203ck280 FIND v(dout0_203) AT=145.025n

.meas tran vdout0_204ck280 FIND v(dout0_204) AT=145.025n

.meas tran vdout0_205ck280 FIND v(dout0_205) AT=145.025n

.meas tran vdout0_206ck280 FIND v(dout0_206) AT=145.025n

.meas tran vdout0_207ck280 FIND v(dout0_207) AT=145.025n

.meas tran vdout0_208ck280 FIND v(dout0_208) AT=145.025n

.meas tran vdout0_209ck280 FIND v(dout0_209) AT=145.025n

.meas tran vdout0_210ck280 FIND v(dout0_210) AT=145.025n

.meas tran vdout0_211ck280 FIND v(dout0_211) AT=145.025n

.meas tran vdout0_212ck280 FIND v(dout0_212) AT=145.025n

.meas tran vdout0_213ck280 FIND v(dout0_213) AT=145.025n

.meas tran vdout0_214ck280 FIND v(dout0_214) AT=145.025n

.meas tran vdout0_215ck280 FIND v(dout0_215) AT=145.025n

.meas tran vdout0_216ck280 FIND v(dout0_216) AT=145.025n

.meas tran vdout0_217ck280 FIND v(dout0_217) AT=145.025n

.meas tran vdout0_218ck280 FIND v(dout0_218) AT=145.025n

.meas tran vdout0_219ck280 FIND v(dout0_219) AT=145.025n

.meas tran vdout0_220ck280 FIND v(dout0_220) AT=145.025n

.meas tran vdout0_221ck280 FIND v(dout0_221) AT=145.025n

.meas tran vdout0_222ck280 FIND v(dout0_222) AT=145.025n

.meas tran vdout0_223ck280 FIND v(dout0_223) AT=145.025n

.meas tran vdout0_224ck280 FIND v(dout0_224) AT=145.025n

.meas tran vdout0_225ck280 FIND v(dout0_225) AT=145.025n

.meas tran vdout0_226ck280 FIND v(dout0_226) AT=145.025n

.meas tran vdout0_227ck280 FIND v(dout0_227) AT=145.025n

.meas tran vdout0_228ck280 FIND v(dout0_228) AT=145.025n

.meas tran vdout0_229ck280 FIND v(dout0_229) AT=145.025n

.meas tran vdout0_230ck280 FIND v(dout0_230) AT=145.025n

.meas tran vdout0_231ck280 FIND v(dout0_231) AT=145.025n

.meas tran vdout0_232ck280 FIND v(dout0_232) AT=145.025n

.meas tran vdout0_233ck280 FIND v(dout0_233) AT=145.025n

.meas tran vdout0_234ck280 FIND v(dout0_234) AT=145.025n

.meas tran vdout0_235ck280 FIND v(dout0_235) AT=145.025n

.meas tran vdout0_236ck280 FIND v(dout0_236) AT=145.025n

.meas tran vdout0_237ck280 FIND v(dout0_237) AT=145.025n

.meas tran vdout0_238ck280 FIND v(dout0_238) AT=145.025n

.meas tran vdout0_239ck280 FIND v(dout0_239) AT=145.025n

.meas tran vdout0_240ck280 FIND v(dout0_240) AT=145.025n

.meas tran vdout0_241ck280 FIND v(dout0_241) AT=145.025n

.meas tran vdout0_242ck280 FIND v(dout0_242) AT=145.025n

.meas tran vdout0_243ck280 FIND v(dout0_243) AT=145.025n

.meas tran vdout0_244ck280 FIND v(dout0_244) AT=145.025n

.meas tran vdout0_245ck280 FIND v(dout0_245) AT=145.025n

.meas tran vdout0_246ck280 FIND v(dout0_246) AT=145.025n

.meas tran vdout0_247ck280 FIND v(dout0_247) AT=145.025n

.meas tran vdout0_248ck280 FIND v(dout0_248) AT=145.025n

.meas tran vdout0_249ck280 FIND v(dout0_249) AT=145.025n

.meas tran vdout0_250ck280 FIND v(dout0_250) AT=145.025n

.meas tran vdout0_251ck280 FIND v(dout0_251) AT=145.025n

.meas tran vdout0_252ck280 FIND v(dout0_252) AT=145.025n

.meas tran vdout0_253ck280 FIND v(dout0_253) AT=145.025n

.meas tran vdout0_254ck280 FIND v(dout0_254) AT=145.025n

.meas tran vdout0_255ck280 FIND v(dout0_255) AT=145.025n

.meas tran vdout0_0ck290 FIND v(dout0_0) AT=150.025n

.meas tran vdout0_1ck290 FIND v(dout0_1) AT=150.025n

.meas tran vdout0_2ck290 FIND v(dout0_2) AT=150.025n

.meas tran vdout0_3ck290 FIND v(dout0_3) AT=150.025n

.meas tran vdout0_4ck290 FIND v(dout0_4) AT=150.025n

.meas tran vdout0_5ck290 FIND v(dout0_5) AT=150.025n

.meas tran vdout0_6ck290 FIND v(dout0_6) AT=150.025n

.meas tran vdout0_7ck290 FIND v(dout0_7) AT=150.025n

.meas tran vdout0_8ck290 FIND v(dout0_8) AT=150.025n

.meas tran vdout0_9ck290 FIND v(dout0_9) AT=150.025n

.meas tran vdout0_10ck290 FIND v(dout0_10) AT=150.025n

.meas tran vdout0_11ck290 FIND v(dout0_11) AT=150.025n

.meas tran vdout0_12ck290 FIND v(dout0_12) AT=150.025n

.meas tran vdout0_13ck290 FIND v(dout0_13) AT=150.025n

.meas tran vdout0_14ck290 FIND v(dout0_14) AT=150.025n

.meas tran vdout0_15ck290 FIND v(dout0_15) AT=150.025n

.meas tran vdout0_16ck290 FIND v(dout0_16) AT=150.025n

.meas tran vdout0_17ck290 FIND v(dout0_17) AT=150.025n

.meas tran vdout0_18ck290 FIND v(dout0_18) AT=150.025n

.meas tran vdout0_19ck290 FIND v(dout0_19) AT=150.025n

.meas tran vdout0_20ck290 FIND v(dout0_20) AT=150.025n

.meas tran vdout0_21ck290 FIND v(dout0_21) AT=150.025n

.meas tran vdout0_22ck290 FIND v(dout0_22) AT=150.025n

.meas tran vdout0_23ck290 FIND v(dout0_23) AT=150.025n

.meas tran vdout0_24ck290 FIND v(dout0_24) AT=150.025n

.meas tran vdout0_25ck290 FIND v(dout0_25) AT=150.025n

.meas tran vdout0_26ck290 FIND v(dout0_26) AT=150.025n

.meas tran vdout0_27ck290 FIND v(dout0_27) AT=150.025n

.meas tran vdout0_28ck290 FIND v(dout0_28) AT=150.025n

.meas tran vdout0_29ck290 FIND v(dout0_29) AT=150.025n

.meas tran vdout0_30ck290 FIND v(dout0_30) AT=150.025n

.meas tran vdout0_31ck290 FIND v(dout0_31) AT=150.025n

.meas tran vdout0_32ck290 FIND v(dout0_32) AT=150.025n

.meas tran vdout0_33ck290 FIND v(dout0_33) AT=150.025n

.meas tran vdout0_34ck290 FIND v(dout0_34) AT=150.025n

.meas tran vdout0_35ck290 FIND v(dout0_35) AT=150.025n

.meas tran vdout0_36ck290 FIND v(dout0_36) AT=150.025n

.meas tran vdout0_37ck290 FIND v(dout0_37) AT=150.025n

.meas tran vdout0_38ck290 FIND v(dout0_38) AT=150.025n

.meas tran vdout0_39ck290 FIND v(dout0_39) AT=150.025n

.meas tran vdout0_40ck290 FIND v(dout0_40) AT=150.025n

.meas tran vdout0_41ck290 FIND v(dout0_41) AT=150.025n

.meas tran vdout0_42ck290 FIND v(dout0_42) AT=150.025n

.meas tran vdout0_43ck290 FIND v(dout0_43) AT=150.025n

.meas tran vdout0_44ck290 FIND v(dout0_44) AT=150.025n

.meas tran vdout0_45ck290 FIND v(dout0_45) AT=150.025n

.meas tran vdout0_46ck290 FIND v(dout0_46) AT=150.025n

.meas tran vdout0_47ck290 FIND v(dout0_47) AT=150.025n

.meas tran vdout0_48ck290 FIND v(dout0_48) AT=150.025n

.meas tran vdout0_49ck290 FIND v(dout0_49) AT=150.025n

.meas tran vdout0_50ck290 FIND v(dout0_50) AT=150.025n

.meas tran vdout0_51ck290 FIND v(dout0_51) AT=150.025n

.meas tran vdout0_52ck290 FIND v(dout0_52) AT=150.025n

.meas tran vdout0_53ck290 FIND v(dout0_53) AT=150.025n

.meas tran vdout0_54ck290 FIND v(dout0_54) AT=150.025n

.meas tran vdout0_55ck290 FIND v(dout0_55) AT=150.025n

.meas tran vdout0_56ck290 FIND v(dout0_56) AT=150.025n

.meas tran vdout0_57ck290 FIND v(dout0_57) AT=150.025n

.meas tran vdout0_58ck290 FIND v(dout0_58) AT=150.025n

.meas tran vdout0_59ck290 FIND v(dout0_59) AT=150.025n

.meas tran vdout0_60ck290 FIND v(dout0_60) AT=150.025n

.meas tran vdout0_61ck290 FIND v(dout0_61) AT=150.025n

.meas tran vdout0_62ck290 FIND v(dout0_62) AT=150.025n

.meas tran vdout0_63ck290 FIND v(dout0_63) AT=150.025n

.meas tran vdout0_64ck290 FIND v(dout0_64) AT=150.025n

.meas tran vdout0_65ck290 FIND v(dout0_65) AT=150.025n

.meas tran vdout0_66ck290 FIND v(dout0_66) AT=150.025n

.meas tran vdout0_67ck290 FIND v(dout0_67) AT=150.025n

.meas tran vdout0_68ck290 FIND v(dout0_68) AT=150.025n

.meas tran vdout0_69ck290 FIND v(dout0_69) AT=150.025n

.meas tran vdout0_70ck290 FIND v(dout0_70) AT=150.025n

.meas tran vdout0_71ck290 FIND v(dout0_71) AT=150.025n

.meas tran vdout0_72ck290 FIND v(dout0_72) AT=150.025n

.meas tran vdout0_73ck290 FIND v(dout0_73) AT=150.025n

.meas tran vdout0_74ck290 FIND v(dout0_74) AT=150.025n

.meas tran vdout0_75ck290 FIND v(dout0_75) AT=150.025n

.meas tran vdout0_76ck290 FIND v(dout0_76) AT=150.025n

.meas tran vdout0_77ck290 FIND v(dout0_77) AT=150.025n

.meas tran vdout0_78ck290 FIND v(dout0_78) AT=150.025n

.meas tran vdout0_79ck290 FIND v(dout0_79) AT=150.025n

.meas tran vdout0_80ck290 FIND v(dout0_80) AT=150.025n

.meas tran vdout0_81ck290 FIND v(dout0_81) AT=150.025n

.meas tran vdout0_82ck290 FIND v(dout0_82) AT=150.025n

.meas tran vdout0_83ck290 FIND v(dout0_83) AT=150.025n

.meas tran vdout0_84ck290 FIND v(dout0_84) AT=150.025n

.meas tran vdout0_85ck290 FIND v(dout0_85) AT=150.025n

.meas tran vdout0_86ck290 FIND v(dout0_86) AT=150.025n

.meas tran vdout0_87ck290 FIND v(dout0_87) AT=150.025n

.meas tran vdout0_88ck290 FIND v(dout0_88) AT=150.025n

.meas tran vdout0_89ck290 FIND v(dout0_89) AT=150.025n

.meas tran vdout0_90ck290 FIND v(dout0_90) AT=150.025n

.meas tran vdout0_91ck290 FIND v(dout0_91) AT=150.025n

.meas tran vdout0_92ck290 FIND v(dout0_92) AT=150.025n

.meas tran vdout0_93ck290 FIND v(dout0_93) AT=150.025n

.meas tran vdout0_94ck290 FIND v(dout0_94) AT=150.025n

.meas tran vdout0_95ck290 FIND v(dout0_95) AT=150.025n

.meas tran vdout0_96ck290 FIND v(dout0_96) AT=150.025n

.meas tran vdout0_97ck290 FIND v(dout0_97) AT=150.025n

.meas tran vdout0_98ck290 FIND v(dout0_98) AT=150.025n

.meas tran vdout0_99ck290 FIND v(dout0_99) AT=150.025n

.meas tran vdout0_100ck290 FIND v(dout0_100) AT=150.025n

.meas tran vdout0_101ck290 FIND v(dout0_101) AT=150.025n

.meas tran vdout0_102ck290 FIND v(dout0_102) AT=150.025n

.meas tran vdout0_103ck290 FIND v(dout0_103) AT=150.025n

.meas tran vdout0_104ck290 FIND v(dout0_104) AT=150.025n

.meas tran vdout0_105ck290 FIND v(dout0_105) AT=150.025n

.meas tran vdout0_106ck290 FIND v(dout0_106) AT=150.025n

.meas tran vdout0_107ck290 FIND v(dout0_107) AT=150.025n

.meas tran vdout0_108ck290 FIND v(dout0_108) AT=150.025n

.meas tran vdout0_109ck290 FIND v(dout0_109) AT=150.025n

.meas tran vdout0_110ck290 FIND v(dout0_110) AT=150.025n

.meas tran vdout0_111ck290 FIND v(dout0_111) AT=150.025n

.meas tran vdout0_112ck290 FIND v(dout0_112) AT=150.025n

.meas tran vdout0_113ck290 FIND v(dout0_113) AT=150.025n

.meas tran vdout0_114ck290 FIND v(dout0_114) AT=150.025n

.meas tran vdout0_115ck290 FIND v(dout0_115) AT=150.025n

.meas tran vdout0_116ck290 FIND v(dout0_116) AT=150.025n

.meas tran vdout0_117ck290 FIND v(dout0_117) AT=150.025n

.meas tran vdout0_118ck290 FIND v(dout0_118) AT=150.025n

.meas tran vdout0_119ck290 FIND v(dout0_119) AT=150.025n

.meas tran vdout0_120ck290 FIND v(dout0_120) AT=150.025n

.meas tran vdout0_121ck290 FIND v(dout0_121) AT=150.025n

.meas tran vdout0_122ck290 FIND v(dout0_122) AT=150.025n

.meas tran vdout0_123ck290 FIND v(dout0_123) AT=150.025n

.meas tran vdout0_124ck290 FIND v(dout0_124) AT=150.025n

.meas tran vdout0_125ck290 FIND v(dout0_125) AT=150.025n

.meas tran vdout0_126ck290 FIND v(dout0_126) AT=150.025n

.meas tran vdout0_127ck290 FIND v(dout0_127) AT=150.025n

.meas tran vdout0_128ck290 FIND v(dout0_128) AT=150.025n

.meas tran vdout0_129ck290 FIND v(dout0_129) AT=150.025n

.meas tran vdout0_130ck290 FIND v(dout0_130) AT=150.025n

.meas tran vdout0_131ck290 FIND v(dout0_131) AT=150.025n

.meas tran vdout0_132ck290 FIND v(dout0_132) AT=150.025n

.meas tran vdout0_133ck290 FIND v(dout0_133) AT=150.025n

.meas tran vdout0_134ck290 FIND v(dout0_134) AT=150.025n

.meas tran vdout0_135ck290 FIND v(dout0_135) AT=150.025n

.meas tran vdout0_136ck290 FIND v(dout0_136) AT=150.025n

.meas tran vdout0_137ck290 FIND v(dout0_137) AT=150.025n

.meas tran vdout0_138ck290 FIND v(dout0_138) AT=150.025n

.meas tran vdout0_139ck290 FIND v(dout0_139) AT=150.025n

.meas tran vdout0_140ck290 FIND v(dout0_140) AT=150.025n

.meas tran vdout0_141ck290 FIND v(dout0_141) AT=150.025n

.meas tran vdout0_142ck290 FIND v(dout0_142) AT=150.025n

.meas tran vdout0_143ck290 FIND v(dout0_143) AT=150.025n

.meas tran vdout0_144ck290 FIND v(dout0_144) AT=150.025n

.meas tran vdout0_145ck290 FIND v(dout0_145) AT=150.025n

.meas tran vdout0_146ck290 FIND v(dout0_146) AT=150.025n

.meas tran vdout0_147ck290 FIND v(dout0_147) AT=150.025n

.meas tran vdout0_148ck290 FIND v(dout0_148) AT=150.025n

.meas tran vdout0_149ck290 FIND v(dout0_149) AT=150.025n

.meas tran vdout0_150ck290 FIND v(dout0_150) AT=150.025n

.meas tran vdout0_151ck290 FIND v(dout0_151) AT=150.025n

.meas tran vdout0_152ck290 FIND v(dout0_152) AT=150.025n

.meas tran vdout0_153ck290 FIND v(dout0_153) AT=150.025n

.meas tran vdout0_154ck290 FIND v(dout0_154) AT=150.025n

.meas tran vdout0_155ck290 FIND v(dout0_155) AT=150.025n

.meas tran vdout0_156ck290 FIND v(dout0_156) AT=150.025n

.meas tran vdout0_157ck290 FIND v(dout0_157) AT=150.025n

.meas tran vdout0_158ck290 FIND v(dout0_158) AT=150.025n

.meas tran vdout0_159ck290 FIND v(dout0_159) AT=150.025n

.meas tran vdout0_160ck290 FIND v(dout0_160) AT=150.025n

.meas tran vdout0_161ck290 FIND v(dout0_161) AT=150.025n

.meas tran vdout0_162ck290 FIND v(dout0_162) AT=150.025n

.meas tran vdout0_163ck290 FIND v(dout0_163) AT=150.025n

.meas tran vdout0_164ck290 FIND v(dout0_164) AT=150.025n

.meas tran vdout0_165ck290 FIND v(dout0_165) AT=150.025n

.meas tran vdout0_166ck290 FIND v(dout0_166) AT=150.025n

.meas tran vdout0_167ck290 FIND v(dout0_167) AT=150.025n

.meas tran vdout0_168ck290 FIND v(dout0_168) AT=150.025n

.meas tran vdout0_169ck290 FIND v(dout0_169) AT=150.025n

.meas tran vdout0_170ck290 FIND v(dout0_170) AT=150.025n

.meas tran vdout0_171ck290 FIND v(dout0_171) AT=150.025n

.meas tran vdout0_172ck290 FIND v(dout0_172) AT=150.025n

.meas tran vdout0_173ck290 FIND v(dout0_173) AT=150.025n

.meas tran vdout0_174ck290 FIND v(dout0_174) AT=150.025n

.meas tran vdout0_175ck290 FIND v(dout0_175) AT=150.025n

.meas tran vdout0_176ck290 FIND v(dout0_176) AT=150.025n

.meas tran vdout0_177ck290 FIND v(dout0_177) AT=150.025n

.meas tran vdout0_178ck290 FIND v(dout0_178) AT=150.025n

.meas tran vdout0_179ck290 FIND v(dout0_179) AT=150.025n

.meas tran vdout0_180ck290 FIND v(dout0_180) AT=150.025n

.meas tran vdout0_181ck290 FIND v(dout0_181) AT=150.025n

.meas tran vdout0_182ck290 FIND v(dout0_182) AT=150.025n

.meas tran vdout0_183ck290 FIND v(dout0_183) AT=150.025n

.meas tran vdout0_184ck290 FIND v(dout0_184) AT=150.025n

.meas tran vdout0_185ck290 FIND v(dout0_185) AT=150.025n

.meas tran vdout0_186ck290 FIND v(dout0_186) AT=150.025n

.meas tran vdout0_187ck290 FIND v(dout0_187) AT=150.025n

.meas tran vdout0_188ck290 FIND v(dout0_188) AT=150.025n

.meas tran vdout0_189ck290 FIND v(dout0_189) AT=150.025n

.meas tran vdout0_190ck290 FIND v(dout0_190) AT=150.025n

.meas tran vdout0_191ck290 FIND v(dout0_191) AT=150.025n

.meas tran vdout0_192ck290 FIND v(dout0_192) AT=150.025n

.meas tran vdout0_193ck290 FIND v(dout0_193) AT=150.025n

.meas tran vdout0_194ck290 FIND v(dout0_194) AT=150.025n

.meas tran vdout0_195ck290 FIND v(dout0_195) AT=150.025n

.meas tran vdout0_196ck290 FIND v(dout0_196) AT=150.025n

.meas tran vdout0_197ck290 FIND v(dout0_197) AT=150.025n

.meas tran vdout0_198ck290 FIND v(dout0_198) AT=150.025n

.meas tran vdout0_199ck290 FIND v(dout0_199) AT=150.025n

.meas tran vdout0_200ck290 FIND v(dout0_200) AT=150.025n

.meas tran vdout0_201ck290 FIND v(dout0_201) AT=150.025n

.meas tran vdout0_202ck290 FIND v(dout0_202) AT=150.025n

.meas tran vdout0_203ck290 FIND v(dout0_203) AT=150.025n

.meas tran vdout0_204ck290 FIND v(dout0_204) AT=150.025n

.meas tran vdout0_205ck290 FIND v(dout0_205) AT=150.025n

.meas tran vdout0_206ck290 FIND v(dout0_206) AT=150.025n

.meas tran vdout0_207ck290 FIND v(dout0_207) AT=150.025n

.meas tran vdout0_208ck290 FIND v(dout0_208) AT=150.025n

.meas tran vdout0_209ck290 FIND v(dout0_209) AT=150.025n

.meas tran vdout0_210ck290 FIND v(dout0_210) AT=150.025n

.meas tran vdout0_211ck290 FIND v(dout0_211) AT=150.025n

.meas tran vdout0_212ck290 FIND v(dout0_212) AT=150.025n

.meas tran vdout0_213ck290 FIND v(dout0_213) AT=150.025n

.meas tran vdout0_214ck290 FIND v(dout0_214) AT=150.025n

.meas tran vdout0_215ck290 FIND v(dout0_215) AT=150.025n

.meas tran vdout0_216ck290 FIND v(dout0_216) AT=150.025n

.meas tran vdout0_217ck290 FIND v(dout0_217) AT=150.025n

.meas tran vdout0_218ck290 FIND v(dout0_218) AT=150.025n

.meas tran vdout0_219ck290 FIND v(dout0_219) AT=150.025n

.meas tran vdout0_220ck290 FIND v(dout0_220) AT=150.025n

.meas tran vdout0_221ck290 FIND v(dout0_221) AT=150.025n

.meas tran vdout0_222ck290 FIND v(dout0_222) AT=150.025n

.meas tran vdout0_223ck290 FIND v(dout0_223) AT=150.025n

.meas tran vdout0_224ck290 FIND v(dout0_224) AT=150.025n

.meas tran vdout0_225ck290 FIND v(dout0_225) AT=150.025n

.meas tran vdout0_226ck290 FIND v(dout0_226) AT=150.025n

.meas tran vdout0_227ck290 FIND v(dout0_227) AT=150.025n

.meas tran vdout0_228ck290 FIND v(dout0_228) AT=150.025n

.meas tran vdout0_229ck290 FIND v(dout0_229) AT=150.025n

.meas tran vdout0_230ck290 FIND v(dout0_230) AT=150.025n

.meas tran vdout0_231ck290 FIND v(dout0_231) AT=150.025n

.meas tran vdout0_232ck290 FIND v(dout0_232) AT=150.025n

.meas tran vdout0_233ck290 FIND v(dout0_233) AT=150.025n

.meas tran vdout0_234ck290 FIND v(dout0_234) AT=150.025n

.meas tran vdout0_235ck290 FIND v(dout0_235) AT=150.025n

.meas tran vdout0_236ck290 FIND v(dout0_236) AT=150.025n

.meas tran vdout0_237ck290 FIND v(dout0_237) AT=150.025n

.meas tran vdout0_238ck290 FIND v(dout0_238) AT=150.025n

.meas tran vdout0_239ck290 FIND v(dout0_239) AT=150.025n

.meas tran vdout0_240ck290 FIND v(dout0_240) AT=150.025n

.meas tran vdout0_241ck290 FIND v(dout0_241) AT=150.025n

.meas tran vdout0_242ck290 FIND v(dout0_242) AT=150.025n

.meas tran vdout0_243ck290 FIND v(dout0_243) AT=150.025n

.meas tran vdout0_244ck290 FIND v(dout0_244) AT=150.025n

.meas tran vdout0_245ck290 FIND v(dout0_245) AT=150.025n

.meas tran vdout0_246ck290 FIND v(dout0_246) AT=150.025n

.meas tran vdout0_247ck290 FIND v(dout0_247) AT=150.025n

.meas tran vdout0_248ck290 FIND v(dout0_248) AT=150.025n

.meas tran vdout0_249ck290 FIND v(dout0_249) AT=150.025n

.meas tran vdout0_250ck290 FIND v(dout0_250) AT=150.025n

.meas tran vdout0_251ck290 FIND v(dout0_251) AT=150.025n

.meas tran vdout0_252ck290 FIND v(dout0_252) AT=150.025n

.meas tran vdout0_253ck290 FIND v(dout0_253) AT=150.025n

.meas tran vdout0_254ck290 FIND v(dout0_254) AT=150.025n

.meas tran vdout0_255ck290 FIND v(dout0_255) AT=150.025n

.meas tran vdout0_0ck300 FIND v(dout0_0) AT=155.025n

.meas tran vdout0_1ck300 FIND v(dout0_1) AT=155.025n

.meas tran vdout0_2ck300 FIND v(dout0_2) AT=155.025n

.meas tran vdout0_3ck300 FIND v(dout0_3) AT=155.025n

.meas tran vdout0_4ck300 FIND v(dout0_4) AT=155.025n

.meas tran vdout0_5ck300 FIND v(dout0_5) AT=155.025n

.meas tran vdout0_6ck300 FIND v(dout0_6) AT=155.025n

.meas tran vdout0_7ck300 FIND v(dout0_7) AT=155.025n

.meas tran vdout0_8ck300 FIND v(dout0_8) AT=155.025n

.meas tran vdout0_9ck300 FIND v(dout0_9) AT=155.025n

.meas tran vdout0_10ck300 FIND v(dout0_10) AT=155.025n

.meas tran vdout0_11ck300 FIND v(dout0_11) AT=155.025n

.meas tran vdout0_12ck300 FIND v(dout0_12) AT=155.025n

.meas tran vdout0_13ck300 FIND v(dout0_13) AT=155.025n

.meas tran vdout0_14ck300 FIND v(dout0_14) AT=155.025n

.meas tran vdout0_15ck300 FIND v(dout0_15) AT=155.025n

.meas tran vdout0_16ck300 FIND v(dout0_16) AT=155.025n

.meas tran vdout0_17ck300 FIND v(dout0_17) AT=155.025n

.meas tran vdout0_18ck300 FIND v(dout0_18) AT=155.025n

.meas tran vdout0_19ck300 FIND v(dout0_19) AT=155.025n

.meas tran vdout0_20ck300 FIND v(dout0_20) AT=155.025n

.meas tran vdout0_21ck300 FIND v(dout0_21) AT=155.025n

.meas tran vdout0_22ck300 FIND v(dout0_22) AT=155.025n

.meas tran vdout0_23ck300 FIND v(dout0_23) AT=155.025n

.meas tran vdout0_24ck300 FIND v(dout0_24) AT=155.025n

.meas tran vdout0_25ck300 FIND v(dout0_25) AT=155.025n

.meas tran vdout0_26ck300 FIND v(dout0_26) AT=155.025n

.meas tran vdout0_27ck300 FIND v(dout0_27) AT=155.025n

.meas tran vdout0_28ck300 FIND v(dout0_28) AT=155.025n

.meas tran vdout0_29ck300 FIND v(dout0_29) AT=155.025n

.meas tran vdout0_30ck300 FIND v(dout0_30) AT=155.025n

.meas tran vdout0_31ck300 FIND v(dout0_31) AT=155.025n

.meas tran vdout0_32ck300 FIND v(dout0_32) AT=155.025n

.meas tran vdout0_33ck300 FIND v(dout0_33) AT=155.025n

.meas tran vdout0_34ck300 FIND v(dout0_34) AT=155.025n

.meas tran vdout0_35ck300 FIND v(dout0_35) AT=155.025n

.meas tran vdout0_36ck300 FIND v(dout0_36) AT=155.025n

.meas tran vdout0_37ck300 FIND v(dout0_37) AT=155.025n

.meas tran vdout0_38ck300 FIND v(dout0_38) AT=155.025n

.meas tran vdout0_39ck300 FIND v(dout0_39) AT=155.025n

.meas tran vdout0_40ck300 FIND v(dout0_40) AT=155.025n

.meas tran vdout0_41ck300 FIND v(dout0_41) AT=155.025n

.meas tran vdout0_42ck300 FIND v(dout0_42) AT=155.025n

.meas tran vdout0_43ck300 FIND v(dout0_43) AT=155.025n

.meas tran vdout0_44ck300 FIND v(dout0_44) AT=155.025n

.meas tran vdout0_45ck300 FIND v(dout0_45) AT=155.025n

.meas tran vdout0_46ck300 FIND v(dout0_46) AT=155.025n

.meas tran vdout0_47ck300 FIND v(dout0_47) AT=155.025n

.meas tran vdout0_48ck300 FIND v(dout0_48) AT=155.025n

.meas tran vdout0_49ck300 FIND v(dout0_49) AT=155.025n

.meas tran vdout0_50ck300 FIND v(dout0_50) AT=155.025n

.meas tran vdout0_51ck300 FIND v(dout0_51) AT=155.025n

.meas tran vdout0_52ck300 FIND v(dout0_52) AT=155.025n

.meas tran vdout0_53ck300 FIND v(dout0_53) AT=155.025n

.meas tran vdout0_54ck300 FIND v(dout0_54) AT=155.025n

.meas tran vdout0_55ck300 FIND v(dout0_55) AT=155.025n

.meas tran vdout0_56ck300 FIND v(dout0_56) AT=155.025n

.meas tran vdout0_57ck300 FIND v(dout0_57) AT=155.025n

.meas tran vdout0_58ck300 FIND v(dout0_58) AT=155.025n

.meas tran vdout0_59ck300 FIND v(dout0_59) AT=155.025n

.meas tran vdout0_60ck300 FIND v(dout0_60) AT=155.025n

.meas tran vdout0_61ck300 FIND v(dout0_61) AT=155.025n

.meas tran vdout0_62ck300 FIND v(dout0_62) AT=155.025n

.meas tran vdout0_63ck300 FIND v(dout0_63) AT=155.025n

.meas tran vdout0_64ck300 FIND v(dout0_64) AT=155.025n

.meas tran vdout0_65ck300 FIND v(dout0_65) AT=155.025n

.meas tran vdout0_66ck300 FIND v(dout0_66) AT=155.025n

.meas tran vdout0_67ck300 FIND v(dout0_67) AT=155.025n

.meas tran vdout0_68ck300 FIND v(dout0_68) AT=155.025n

.meas tran vdout0_69ck300 FIND v(dout0_69) AT=155.025n

.meas tran vdout0_70ck300 FIND v(dout0_70) AT=155.025n

.meas tran vdout0_71ck300 FIND v(dout0_71) AT=155.025n

.meas tran vdout0_72ck300 FIND v(dout0_72) AT=155.025n

.meas tran vdout0_73ck300 FIND v(dout0_73) AT=155.025n

.meas tran vdout0_74ck300 FIND v(dout0_74) AT=155.025n

.meas tran vdout0_75ck300 FIND v(dout0_75) AT=155.025n

.meas tran vdout0_76ck300 FIND v(dout0_76) AT=155.025n

.meas tran vdout0_77ck300 FIND v(dout0_77) AT=155.025n

.meas tran vdout0_78ck300 FIND v(dout0_78) AT=155.025n

.meas tran vdout0_79ck300 FIND v(dout0_79) AT=155.025n

.meas tran vdout0_80ck300 FIND v(dout0_80) AT=155.025n

.meas tran vdout0_81ck300 FIND v(dout0_81) AT=155.025n

.meas tran vdout0_82ck300 FIND v(dout0_82) AT=155.025n

.meas tran vdout0_83ck300 FIND v(dout0_83) AT=155.025n

.meas tran vdout0_84ck300 FIND v(dout0_84) AT=155.025n

.meas tran vdout0_85ck300 FIND v(dout0_85) AT=155.025n

.meas tran vdout0_86ck300 FIND v(dout0_86) AT=155.025n

.meas tran vdout0_87ck300 FIND v(dout0_87) AT=155.025n

.meas tran vdout0_88ck300 FIND v(dout0_88) AT=155.025n

.meas tran vdout0_89ck300 FIND v(dout0_89) AT=155.025n

.meas tran vdout0_90ck300 FIND v(dout0_90) AT=155.025n

.meas tran vdout0_91ck300 FIND v(dout0_91) AT=155.025n

.meas tran vdout0_92ck300 FIND v(dout0_92) AT=155.025n

.meas tran vdout0_93ck300 FIND v(dout0_93) AT=155.025n

.meas tran vdout0_94ck300 FIND v(dout0_94) AT=155.025n

.meas tran vdout0_95ck300 FIND v(dout0_95) AT=155.025n

.meas tran vdout0_96ck300 FIND v(dout0_96) AT=155.025n

.meas tran vdout0_97ck300 FIND v(dout0_97) AT=155.025n

.meas tran vdout0_98ck300 FIND v(dout0_98) AT=155.025n

.meas tran vdout0_99ck300 FIND v(dout0_99) AT=155.025n

.meas tran vdout0_100ck300 FIND v(dout0_100) AT=155.025n

.meas tran vdout0_101ck300 FIND v(dout0_101) AT=155.025n

.meas tran vdout0_102ck300 FIND v(dout0_102) AT=155.025n

.meas tran vdout0_103ck300 FIND v(dout0_103) AT=155.025n

.meas tran vdout0_104ck300 FIND v(dout0_104) AT=155.025n

.meas tran vdout0_105ck300 FIND v(dout0_105) AT=155.025n

.meas tran vdout0_106ck300 FIND v(dout0_106) AT=155.025n

.meas tran vdout0_107ck300 FIND v(dout0_107) AT=155.025n

.meas tran vdout0_108ck300 FIND v(dout0_108) AT=155.025n

.meas tran vdout0_109ck300 FIND v(dout0_109) AT=155.025n

.meas tran vdout0_110ck300 FIND v(dout0_110) AT=155.025n

.meas tran vdout0_111ck300 FIND v(dout0_111) AT=155.025n

.meas tran vdout0_112ck300 FIND v(dout0_112) AT=155.025n

.meas tran vdout0_113ck300 FIND v(dout0_113) AT=155.025n

.meas tran vdout0_114ck300 FIND v(dout0_114) AT=155.025n

.meas tran vdout0_115ck300 FIND v(dout0_115) AT=155.025n

.meas tran vdout0_116ck300 FIND v(dout0_116) AT=155.025n

.meas tran vdout0_117ck300 FIND v(dout0_117) AT=155.025n

.meas tran vdout0_118ck300 FIND v(dout0_118) AT=155.025n

.meas tran vdout0_119ck300 FIND v(dout0_119) AT=155.025n

.meas tran vdout0_120ck300 FIND v(dout0_120) AT=155.025n

.meas tran vdout0_121ck300 FIND v(dout0_121) AT=155.025n

.meas tran vdout0_122ck300 FIND v(dout0_122) AT=155.025n

.meas tran vdout0_123ck300 FIND v(dout0_123) AT=155.025n

.meas tran vdout0_124ck300 FIND v(dout0_124) AT=155.025n

.meas tran vdout0_125ck300 FIND v(dout0_125) AT=155.025n

.meas tran vdout0_126ck300 FIND v(dout0_126) AT=155.025n

.meas tran vdout0_127ck300 FIND v(dout0_127) AT=155.025n

.meas tran vdout0_128ck300 FIND v(dout0_128) AT=155.025n

.meas tran vdout0_129ck300 FIND v(dout0_129) AT=155.025n

.meas tran vdout0_130ck300 FIND v(dout0_130) AT=155.025n

.meas tran vdout0_131ck300 FIND v(dout0_131) AT=155.025n

.meas tran vdout0_132ck300 FIND v(dout0_132) AT=155.025n

.meas tran vdout0_133ck300 FIND v(dout0_133) AT=155.025n

.meas tran vdout0_134ck300 FIND v(dout0_134) AT=155.025n

.meas tran vdout0_135ck300 FIND v(dout0_135) AT=155.025n

.meas tran vdout0_136ck300 FIND v(dout0_136) AT=155.025n

.meas tran vdout0_137ck300 FIND v(dout0_137) AT=155.025n

.meas tran vdout0_138ck300 FIND v(dout0_138) AT=155.025n

.meas tran vdout0_139ck300 FIND v(dout0_139) AT=155.025n

.meas tran vdout0_140ck300 FIND v(dout0_140) AT=155.025n

.meas tran vdout0_141ck300 FIND v(dout0_141) AT=155.025n

.meas tran vdout0_142ck300 FIND v(dout0_142) AT=155.025n

.meas tran vdout0_143ck300 FIND v(dout0_143) AT=155.025n

.meas tran vdout0_144ck300 FIND v(dout0_144) AT=155.025n

.meas tran vdout0_145ck300 FIND v(dout0_145) AT=155.025n

.meas tran vdout0_146ck300 FIND v(dout0_146) AT=155.025n

.meas tran vdout0_147ck300 FIND v(dout0_147) AT=155.025n

.meas tran vdout0_148ck300 FIND v(dout0_148) AT=155.025n

.meas tran vdout0_149ck300 FIND v(dout0_149) AT=155.025n

.meas tran vdout0_150ck300 FIND v(dout0_150) AT=155.025n

.meas tran vdout0_151ck300 FIND v(dout0_151) AT=155.025n

.meas tran vdout0_152ck300 FIND v(dout0_152) AT=155.025n

.meas tran vdout0_153ck300 FIND v(dout0_153) AT=155.025n

.meas tran vdout0_154ck300 FIND v(dout0_154) AT=155.025n

.meas tran vdout0_155ck300 FIND v(dout0_155) AT=155.025n

.meas tran vdout0_156ck300 FIND v(dout0_156) AT=155.025n

.meas tran vdout0_157ck300 FIND v(dout0_157) AT=155.025n

.meas tran vdout0_158ck300 FIND v(dout0_158) AT=155.025n

.meas tran vdout0_159ck300 FIND v(dout0_159) AT=155.025n

.meas tran vdout0_160ck300 FIND v(dout0_160) AT=155.025n

.meas tran vdout0_161ck300 FIND v(dout0_161) AT=155.025n

.meas tran vdout0_162ck300 FIND v(dout0_162) AT=155.025n

.meas tran vdout0_163ck300 FIND v(dout0_163) AT=155.025n

.meas tran vdout0_164ck300 FIND v(dout0_164) AT=155.025n

.meas tran vdout0_165ck300 FIND v(dout0_165) AT=155.025n

.meas tran vdout0_166ck300 FIND v(dout0_166) AT=155.025n

.meas tran vdout0_167ck300 FIND v(dout0_167) AT=155.025n

.meas tran vdout0_168ck300 FIND v(dout0_168) AT=155.025n

.meas tran vdout0_169ck300 FIND v(dout0_169) AT=155.025n

.meas tran vdout0_170ck300 FIND v(dout0_170) AT=155.025n

.meas tran vdout0_171ck300 FIND v(dout0_171) AT=155.025n

.meas tran vdout0_172ck300 FIND v(dout0_172) AT=155.025n

.meas tran vdout0_173ck300 FIND v(dout0_173) AT=155.025n

.meas tran vdout0_174ck300 FIND v(dout0_174) AT=155.025n

.meas tran vdout0_175ck300 FIND v(dout0_175) AT=155.025n

.meas tran vdout0_176ck300 FIND v(dout0_176) AT=155.025n

.meas tran vdout0_177ck300 FIND v(dout0_177) AT=155.025n

.meas tran vdout0_178ck300 FIND v(dout0_178) AT=155.025n

.meas tran vdout0_179ck300 FIND v(dout0_179) AT=155.025n

.meas tran vdout0_180ck300 FIND v(dout0_180) AT=155.025n

.meas tran vdout0_181ck300 FIND v(dout0_181) AT=155.025n

.meas tran vdout0_182ck300 FIND v(dout0_182) AT=155.025n

.meas tran vdout0_183ck300 FIND v(dout0_183) AT=155.025n

.meas tran vdout0_184ck300 FIND v(dout0_184) AT=155.025n

.meas tran vdout0_185ck300 FIND v(dout0_185) AT=155.025n

.meas tran vdout0_186ck300 FIND v(dout0_186) AT=155.025n

.meas tran vdout0_187ck300 FIND v(dout0_187) AT=155.025n

.meas tran vdout0_188ck300 FIND v(dout0_188) AT=155.025n

.meas tran vdout0_189ck300 FIND v(dout0_189) AT=155.025n

.meas tran vdout0_190ck300 FIND v(dout0_190) AT=155.025n

.meas tran vdout0_191ck300 FIND v(dout0_191) AT=155.025n

.meas tran vdout0_192ck300 FIND v(dout0_192) AT=155.025n

.meas tran vdout0_193ck300 FIND v(dout0_193) AT=155.025n

.meas tran vdout0_194ck300 FIND v(dout0_194) AT=155.025n

.meas tran vdout0_195ck300 FIND v(dout0_195) AT=155.025n

.meas tran vdout0_196ck300 FIND v(dout0_196) AT=155.025n

.meas tran vdout0_197ck300 FIND v(dout0_197) AT=155.025n

.meas tran vdout0_198ck300 FIND v(dout0_198) AT=155.025n

.meas tran vdout0_199ck300 FIND v(dout0_199) AT=155.025n

.meas tran vdout0_200ck300 FIND v(dout0_200) AT=155.025n

.meas tran vdout0_201ck300 FIND v(dout0_201) AT=155.025n

.meas tran vdout0_202ck300 FIND v(dout0_202) AT=155.025n

.meas tran vdout0_203ck300 FIND v(dout0_203) AT=155.025n

.meas tran vdout0_204ck300 FIND v(dout0_204) AT=155.025n

.meas tran vdout0_205ck300 FIND v(dout0_205) AT=155.025n

.meas tran vdout0_206ck300 FIND v(dout0_206) AT=155.025n

.meas tran vdout0_207ck300 FIND v(dout0_207) AT=155.025n

.meas tran vdout0_208ck300 FIND v(dout0_208) AT=155.025n

.meas tran vdout0_209ck300 FIND v(dout0_209) AT=155.025n

.meas tran vdout0_210ck300 FIND v(dout0_210) AT=155.025n

.meas tran vdout0_211ck300 FIND v(dout0_211) AT=155.025n

.meas tran vdout0_212ck300 FIND v(dout0_212) AT=155.025n

.meas tran vdout0_213ck300 FIND v(dout0_213) AT=155.025n

.meas tran vdout0_214ck300 FIND v(dout0_214) AT=155.025n

.meas tran vdout0_215ck300 FIND v(dout0_215) AT=155.025n

.meas tran vdout0_216ck300 FIND v(dout0_216) AT=155.025n

.meas tran vdout0_217ck300 FIND v(dout0_217) AT=155.025n

.meas tran vdout0_218ck300 FIND v(dout0_218) AT=155.025n

.meas tran vdout0_219ck300 FIND v(dout0_219) AT=155.025n

.meas tran vdout0_220ck300 FIND v(dout0_220) AT=155.025n

.meas tran vdout0_221ck300 FIND v(dout0_221) AT=155.025n

.meas tran vdout0_222ck300 FIND v(dout0_222) AT=155.025n

.meas tran vdout0_223ck300 FIND v(dout0_223) AT=155.025n

.meas tran vdout0_224ck300 FIND v(dout0_224) AT=155.025n

.meas tran vdout0_225ck300 FIND v(dout0_225) AT=155.025n

.meas tran vdout0_226ck300 FIND v(dout0_226) AT=155.025n

.meas tran vdout0_227ck300 FIND v(dout0_227) AT=155.025n

.meas tran vdout0_228ck300 FIND v(dout0_228) AT=155.025n

.meas tran vdout0_229ck300 FIND v(dout0_229) AT=155.025n

.meas tran vdout0_230ck300 FIND v(dout0_230) AT=155.025n

.meas tran vdout0_231ck300 FIND v(dout0_231) AT=155.025n

.meas tran vdout0_232ck300 FIND v(dout0_232) AT=155.025n

.meas tran vdout0_233ck300 FIND v(dout0_233) AT=155.025n

.meas tran vdout0_234ck300 FIND v(dout0_234) AT=155.025n

.meas tran vdout0_235ck300 FIND v(dout0_235) AT=155.025n

.meas tran vdout0_236ck300 FIND v(dout0_236) AT=155.025n

.meas tran vdout0_237ck300 FIND v(dout0_237) AT=155.025n

.meas tran vdout0_238ck300 FIND v(dout0_238) AT=155.025n

.meas tran vdout0_239ck300 FIND v(dout0_239) AT=155.025n

.meas tran vdout0_240ck300 FIND v(dout0_240) AT=155.025n

.meas tran vdout0_241ck300 FIND v(dout0_241) AT=155.025n

.meas tran vdout0_242ck300 FIND v(dout0_242) AT=155.025n

.meas tran vdout0_243ck300 FIND v(dout0_243) AT=155.025n

.meas tran vdout0_244ck300 FIND v(dout0_244) AT=155.025n

.meas tran vdout0_245ck300 FIND v(dout0_245) AT=155.025n

.meas tran vdout0_246ck300 FIND v(dout0_246) AT=155.025n

.meas tran vdout0_247ck300 FIND v(dout0_247) AT=155.025n

.meas tran vdout0_248ck300 FIND v(dout0_248) AT=155.025n

.meas tran vdout0_249ck300 FIND v(dout0_249) AT=155.025n

.meas tran vdout0_250ck300 FIND v(dout0_250) AT=155.025n

.meas tran vdout0_251ck300 FIND v(dout0_251) AT=155.025n

.meas tran vdout0_252ck300 FIND v(dout0_252) AT=155.025n

.meas tran vdout0_253ck300 FIND v(dout0_253) AT=155.025n

.meas tran vdout0_254ck300 FIND v(dout0_254) AT=155.025n

.meas tran vdout0_255ck300 FIND v(dout0_255) AT=155.025n

.meas tran vdout0_0ck340 FIND v(dout0_0) AT=175.025n

.meas tran vdout0_1ck340 FIND v(dout0_1) AT=175.025n

.meas tran vdout0_2ck340 FIND v(dout0_2) AT=175.025n

.meas tran vdout0_3ck340 FIND v(dout0_3) AT=175.025n

.meas tran vdout0_4ck340 FIND v(dout0_4) AT=175.025n

.meas tran vdout0_5ck340 FIND v(dout0_5) AT=175.025n

.meas tran vdout0_6ck340 FIND v(dout0_6) AT=175.025n

.meas tran vdout0_7ck340 FIND v(dout0_7) AT=175.025n

.meas tran vdout0_8ck340 FIND v(dout0_8) AT=175.025n

.meas tran vdout0_9ck340 FIND v(dout0_9) AT=175.025n

.meas tran vdout0_10ck340 FIND v(dout0_10) AT=175.025n

.meas tran vdout0_11ck340 FIND v(dout0_11) AT=175.025n

.meas tran vdout0_12ck340 FIND v(dout0_12) AT=175.025n

.meas tran vdout0_13ck340 FIND v(dout0_13) AT=175.025n

.meas tran vdout0_14ck340 FIND v(dout0_14) AT=175.025n

.meas tran vdout0_15ck340 FIND v(dout0_15) AT=175.025n

.meas tran vdout0_16ck340 FIND v(dout0_16) AT=175.025n

.meas tran vdout0_17ck340 FIND v(dout0_17) AT=175.025n

.meas tran vdout0_18ck340 FIND v(dout0_18) AT=175.025n

.meas tran vdout0_19ck340 FIND v(dout0_19) AT=175.025n

.meas tran vdout0_20ck340 FIND v(dout0_20) AT=175.025n

.meas tran vdout0_21ck340 FIND v(dout0_21) AT=175.025n

.meas tran vdout0_22ck340 FIND v(dout0_22) AT=175.025n

.meas tran vdout0_23ck340 FIND v(dout0_23) AT=175.025n

.meas tran vdout0_24ck340 FIND v(dout0_24) AT=175.025n

.meas tran vdout0_25ck340 FIND v(dout0_25) AT=175.025n

.meas tran vdout0_26ck340 FIND v(dout0_26) AT=175.025n

.meas tran vdout0_27ck340 FIND v(dout0_27) AT=175.025n

.meas tran vdout0_28ck340 FIND v(dout0_28) AT=175.025n

.meas tran vdout0_29ck340 FIND v(dout0_29) AT=175.025n

.meas tran vdout0_30ck340 FIND v(dout0_30) AT=175.025n

.meas tran vdout0_31ck340 FIND v(dout0_31) AT=175.025n

.meas tran vdout0_32ck340 FIND v(dout0_32) AT=175.025n

.meas tran vdout0_33ck340 FIND v(dout0_33) AT=175.025n

.meas tran vdout0_34ck340 FIND v(dout0_34) AT=175.025n

.meas tran vdout0_35ck340 FIND v(dout0_35) AT=175.025n

.meas tran vdout0_36ck340 FIND v(dout0_36) AT=175.025n

.meas tran vdout0_37ck340 FIND v(dout0_37) AT=175.025n

.meas tran vdout0_38ck340 FIND v(dout0_38) AT=175.025n

.meas tran vdout0_39ck340 FIND v(dout0_39) AT=175.025n

.meas tran vdout0_40ck340 FIND v(dout0_40) AT=175.025n

.meas tran vdout0_41ck340 FIND v(dout0_41) AT=175.025n

.meas tran vdout0_42ck340 FIND v(dout0_42) AT=175.025n

.meas tran vdout0_43ck340 FIND v(dout0_43) AT=175.025n

.meas tran vdout0_44ck340 FIND v(dout0_44) AT=175.025n

.meas tran vdout0_45ck340 FIND v(dout0_45) AT=175.025n

.meas tran vdout0_46ck340 FIND v(dout0_46) AT=175.025n

.meas tran vdout0_47ck340 FIND v(dout0_47) AT=175.025n

.meas tran vdout0_48ck340 FIND v(dout0_48) AT=175.025n

.meas tran vdout0_49ck340 FIND v(dout0_49) AT=175.025n

.meas tran vdout0_50ck340 FIND v(dout0_50) AT=175.025n

.meas tran vdout0_51ck340 FIND v(dout0_51) AT=175.025n

.meas tran vdout0_52ck340 FIND v(dout0_52) AT=175.025n

.meas tran vdout0_53ck340 FIND v(dout0_53) AT=175.025n

.meas tran vdout0_54ck340 FIND v(dout0_54) AT=175.025n

.meas tran vdout0_55ck340 FIND v(dout0_55) AT=175.025n

.meas tran vdout0_56ck340 FIND v(dout0_56) AT=175.025n

.meas tran vdout0_57ck340 FIND v(dout0_57) AT=175.025n

.meas tran vdout0_58ck340 FIND v(dout0_58) AT=175.025n

.meas tran vdout0_59ck340 FIND v(dout0_59) AT=175.025n

.meas tran vdout0_60ck340 FIND v(dout0_60) AT=175.025n

.meas tran vdout0_61ck340 FIND v(dout0_61) AT=175.025n

.meas tran vdout0_62ck340 FIND v(dout0_62) AT=175.025n

.meas tran vdout0_63ck340 FIND v(dout0_63) AT=175.025n

.meas tran vdout0_64ck340 FIND v(dout0_64) AT=175.025n

.meas tran vdout0_65ck340 FIND v(dout0_65) AT=175.025n

.meas tran vdout0_66ck340 FIND v(dout0_66) AT=175.025n

.meas tran vdout0_67ck340 FIND v(dout0_67) AT=175.025n

.meas tran vdout0_68ck340 FIND v(dout0_68) AT=175.025n

.meas tran vdout0_69ck340 FIND v(dout0_69) AT=175.025n

.meas tran vdout0_70ck340 FIND v(dout0_70) AT=175.025n

.meas tran vdout0_71ck340 FIND v(dout0_71) AT=175.025n

.meas tran vdout0_72ck340 FIND v(dout0_72) AT=175.025n

.meas tran vdout0_73ck340 FIND v(dout0_73) AT=175.025n

.meas tran vdout0_74ck340 FIND v(dout0_74) AT=175.025n

.meas tran vdout0_75ck340 FIND v(dout0_75) AT=175.025n

.meas tran vdout0_76ck340 FIND v(dout0_76) AT=175.025n

.meas tran vdout0_77ck340 FIND v(dout0_77) AT=175.025n

.meas tran vdout0_78ck340 FIND v(dout0_78) AT=175.025n

.meas tran vdout0_79ck340 FIND v(dout0_79) AT=175.025n

.meas tran vdout0_80ck340 FIND v(dout0_80) AT=175.025n

.meas tran vdout0_81ck340 FIND v(dout0_81) AT=175.025n

.meas tran vdout0_82ck340 FIND v(dout0_82) AT=175.025n

.meas tran vdout0_83ck340 FIND v(dout0_83) AT=175.025n

.meas tran vdout0_84ck340 FIND v(dout0_84) AT=175.025n

.meas tran vdout0_85ck340 FIND v(dout0_85) AT=175.025n

.meas tran vdout0_86ck340 FIND v(dout0_86) AT=175.025n

.meas tran vdout0_87ck340 FIND v(dout0_87) AT=175.025n

.meas tran vdout0_88ck340 FIND v(dout0_88) AT=175.025n

.meas tran vdout0_89ck340 FIND v(dout0_89) AT=175.025n

.meas tran vdout0_90ck340 FIND v(dout0_90) AT=175.025n

.meas tran vdout0_91ck340 FIND v(dout0_91) AT=175.025n

.meas tran vdout0_92ck340 FIND v(dout0_92) AT=175.025n

.meas tran vdout0_93ck340 FIND v(dout0_93) AT=175.025n

.meas tran vdout0_94ck340 FIND v(dout0_94) AT=175.025n

.meas tran vdout0_95ck340 FIND v(dout0_95) AT=175.025n

.meas tran vdout0_96ck340 FIND v(dout0_96) AT=175.025n

.meas tran vdout0_97ck340 FIND v(dout0_97) AT=175.025n

.meas tran vdout0_98ck340 FIND v(dout0_98) AT=175.025n

.meas tran vdout0_99ck340 FIND v(dout0_99) AT=175.025n

.meas tran vdout0_100ck340 FIND v(dout0_100) AT=175.025n

.meas tran vdout0_101ck340 FIND v(dout0_101) AT=175.025n

.meas tran vdout0_102ck340 FIND v(dout0_102) AT=175.025n

.meas tran vdout0_103ck340 FIND v(dout0_103) AT=175.025n

.meas tran vdout0_104ck340 FIND v(dout0_104) AT=175.025n

.meas tran vdout0_105ck340 FIND v(dout0_105) AT=175.025n

.meas tran vdout0_106ck340 FIND v(dout0_106) AT=175.025n

.meas tran vdout0_107ck340 FIND v(dout0_107) AT=175.025n

.meas tran vdout0_108ck340 FIND v(dout0_108) AT=175.025n

.meas tran vdout0_109ck340 FIND v(dout0_109) AT=175.025n

.meas tran vdout0_110ck340 FIND v(dout0_110) AT=175.025n

.meas tran vdout0_111ck340 FIND v(dout0_111) AT=175.025n

.meas tran vdout0_112ck340 FIND v(dout0_112) AT=175.025n

.meas tran vdout0_113ck340 FIND v(dout0_113) AT=175.025n

.meas tran vdout0_114ck340 FIND v(dout0_114) AT=175.025n

.meas tran vdout0_115ck340 FIND v(dout0_115) AT=175.025n

.meas tran vdout0_116ck340 FIND v(dout0_116) AT=175.025n

.meas tran vdout0_117ck340 FIND v(dout0_117) AT=175.025n

.meas tran vdout0_118ck340 FIND v(dout0_118) AT=175.025n

.meas tran vdout0_119ck340 FIND v(dout0_119) AT=175.025n

.meas tran vdout0_120ck340 FIND v(dout0_120) AT=175.025n

.meas tran vdout0_121ck340 FIND v(dout0_121) AT=175.025n

.meas tran vdout0_122ck340 FIND v(dout0_122) AT=175.025n

.meas tran vdout0_123ck340 FIND v(dout0_123) AT=175.025n

.meas tran vdout0_124ck340 FIND v(dout0_124) AT=175.025n

.meas tran vdout0_125ck340 FIND v(dout0_125) AT=175.025n

.meas tran vdout0_126ck340 FIND v(dout0_126) AT=175.025n

.meas tran vdout0_127ck340 FIND v(dout0_127) AT=175.025n

.meas tran vdout0_128ck340 FIND v(dout0_128) AT=175.025n

.meas tran vdout0_129ck340 FIND v(dout0_129) AT=175.025n

.meas tran vdout0_130ck340 FIND v(dout0_130) AT=175.025n

.meas tran vdout0_131ck340 FIND v(dout0_131) AT=175.025n

.meas tran vdout0_132ck340 FIND v(dout0_132) AT=175.025n

.meas tran vdout0_133ck340 FIND v(dout0_133) AT=175.025n

.meas tran vdout0_134ck340 FIND v(dout0_134) AT=175.025n

.meas tran vdout0_135ck340 FIND v(dout0_135) AT=175.025n

.meas tran vdout0_136ck340 FIND v(dout0_136) AT=175.025n

.meas tran vdout0_137ck340 FIND v(dout0_137) AT=175.025n

.meas tran vdout0_138ck340 FIND v(dout0_138) AT=175.025n

.meas tran vdout0_139ck340 FIND v(dout0_139) AT=175.025n

.meas tran vdout0_140ck340 FIND v(dout0_140) AT=175.025n

.meas tran vdout0_141ck340 FIND v(dout0_141) AT=175.025n

.meas tran vdout0_142ck340 FIND v(dout0_142) AT=175.025n

.meas tran vdout0_143ck340 FIND v(dout0_143) AT=175.025n

.meas tran vdout0_144ck340 FIND v(dout0_144) AT=175.025n

.meas tran vdout0_145ck340 FIND v(dout0_145) AT=175.025n

.meas tran vdout0_146ck340 FIND v(dout0_146) AT=175.025n

.meas tran vdout0_147ck340 FIND v(dout0_147) AT=175.025n

.meas tran vdout0_148ck340 FIND v(dout0_148) AT=175.025n

.meas tran vdout0_149ck340 FIND v(dout0_149) AT=175.025n

.meas tran vdout0_150ck340 FIND v(dout0_150) AT=175.025n

.meas tran vdout0_151ck340 FIND v(dout0_151) AT=175.025n

.meas tran vdout0_152ck340 FIND v(dout0_152) AT=175.025n

.meas tran vdout0_153ck340 FIND v(dout0_153) AT=175.025n

.meas tran vdout0_154ck340 FIND v(dout0_154) AT=175.025n

.meas tran vdout0_155ck340 FIND v(dout0_155) AT=175.025n

.meas tran vdout0_156ck340 FIND v(dout0_156) AT=175.025n

.meas tran vdout0_157ck340 FIND v(dout0_157) AT=175.025n

.meas tran vdout0_158ck340 FIND v(dout0_158) AT=175.025n

.meas tran vdout0_159ck340 FIND v(dout0_159) AT=175.025n

.meas tran vdout0_160ck340 FIND v(dout0_160) AT=175.025n

.meas tran vdout0_161ck340 FIND v(dout0_161) AT=175.025n

.meas tran vdout0_162ck340 FIND v(dout0_162) AT=175.025n

.meas tran vdout0_163ck340 FIND v(dout0_163) AT=175.025n

.meas tran vdout0_164ck340 FIND v(dout0_164) AT=175.025n

.meas tran vdout0_165ck340 FIND v(dout0_165) AT=175.025n

.meas tran vdout0_166ck340 FIND v(dout0_166) AT=175.025n

.meas tran vdout0_167ck340 FIND v(dout0_167) AT=175.025n

.meas tran vdout0_168ck340 FIND v(dout0_168) AT=175.025n

.meas tran vdout0_169ck340 FIND v(dout0_169) AT=175.025n

.meas tran vdout0_170ck340 FIND v(dout0_170) AT=175.025n

.meas tran vdout0_171ck340 FIND v(dout0_171) AT=175.025n

.meas tran vdout0_172ck340 FIND v(dout0_172) AT=175.025n

.meas tran vdout0_173ck340 FIND v(dout0_173) AT=175.025n

.meas tran vdout0_174ck340 FIND v(dout0_174) AT=175.025n

.meas tran vdout0_175ck340 FIND v(dout0_175) AT=175.025n

.meas tran vdout0_176ck340 FIND v(dout0_176) AT=175.025n

.meas tran vdout0_177ck340 FIND v(dout0_177) AT=175.025n

.meas tran vdout0_178ck340 FIND v(dout0_178) AT=175.025n

.meas tran vdout0_179ck340 FIND v(dout0_179) AT=175.025n

.meas tran vdout0_180ck340 FIND v(dout0_180) AT=175.025n

.meas tran vdout0_181ck340 FIND v(dout0_181) AT=175.025n

.meas tran vdout0_182ck340 FIND v(dout0_182) AT=175.025n

.meas tran vdout0_183ck340 FIND v(dout0_183) AT=175.025n

.meas tran vdout0_184ck340 FIND v(dout0_184) AT=175.025n

.meas tran vdout0_185ck340 FIND v(dout0_185) AT=175.025n

.meas tran vdout0_186ck340 FIND v(dout0_186) AT=175.025n

.meas tran vdout0_187ck340 FIND v(dout0_187) AT=175.025n

.meas tran vdout0_188ck340 FIND v(dout0_188) AT=175.025n

.meas tran vdout0_189ck340 FIND v(dout0_189) AT=175.025n

.meas tran vdout0_190ck340 FIND v(dout0_190) AT=175.025n

.meas tran vdout0_191ck340 FIND v(dout0_191) AT=175.025n

.meas tran vdout0_192ck340 FIND v(dout0_192) AT=175.025n

.meas tran vdout0_193ck340 FIND v(dout0_193) AT=175.025n

.meas tran vdout0_194ck340 FIND v(dout0_194) AT=175.025n

.meas tran vdout0_195ck340 FIND v(dout0_195) AT=175.025n

.meas tran vdout0_196ck340 FIND v(dout0_196) AT=175.025n

.meas tran vdout0_197ck340 FIND v(dout0_197) AT=175.025n

.meas tran vdout0_198ck340 FIND v(dout0_198) AT=175.025n

.meas tran vdout0_199ck340 FIND v(dout0_199) AT=175.025n

.meas tran vdout0_200ck340 FIND v(dout0_200) AT=175.025n

.meas tran vdout0_201ck340 FIND v(dout0_201) AT=175.025n

.meas tran vdout0_202ck340 FIND v(dout0_202) AT=175.025n

.meas tran vdout0_203ck340 FIND v(dout0_203) AT=175.025n

.meas tran vdout0_204ck340 FIND v(dout0_204) AT=175.025n

.meas tran vdout0_205ck340 FIND v(dout0_205) AT=175.025n

.meas tran vdout0_206ck340 FIND v(dout0_206) AT=175.025n

.meas tran vdout0_207ck340 FIND v(dout0_207) AT=175.025n

.meas tran vdout0_208ck340 FIND v(dout0_208) AT=175.025n

.meas tran vdout0_209ck340 FIND v(dout0_209) AT=175.025n

.meas tran vdout0_210ck340 FIND v(dout0_210) AT=175.025n

.meas tran vdout0_211ck340 FIND v(dout0_211) AT=175.025n

.meas tran vdout0_212ck340 FIND v(dout0_212) AT=175.025n

.meas tran vdout0_213ck340 FIND v(dout0_213) AT=175.025n

.meas tran vdout0_214ck340 FIND v(dout0_214) AT=175.025n

.meas tran vdout0_215ck340 FIND v(dout0_215) AT=175.025n

.meas tran vdout0_216ck340 FIND v(dout0_216) AT=175.025n

.meas tran vdout0_217ck340 FIND v(dout0_217) AT=175.025n

.meas tran vdout0_218ck340 FIND v(dout0_218) AT=175.025n

.meas tran vdout0_219ck340 FIND v(dout0_219) AT=175.025n

.meas tran vdout0_220ck340 FIND v(dout0_220) AT=175.025n

.meas tran vdout0_221ck340 FIND v(dout0_221) AT=175.025n

.meas tran vdout0_222ck340 FIND v(dout0_222) AT=175.025n

.meas tran vdout0_223ck340 FIND v(dout0_223) AT=175.025n

.meas tran vdout0_224ck340 FIND v(dout0_224) AT=175.025n

.meas tran vdout0_225ck340 FIND v(dout0_225) AT=175.025n

.meas tran vdout0_226ck340 FIND v(dout0_226) AT=175.025n

.meas tran vdout0_227ck340 FIND v(dout0_227) AT=175.025n

.meas tran vdout0_228ck340 FIND v(dout0_228) AT=175.025n

.meas tran vdout0_229ck340 FIND v(dout0_229) AT=175.025n

.meas tran vdout0_230ck340 FIND v(dout0_230) AT=175.025n

.meas tran vdout0_231ck340 FIND v(dout0_231) AT=175.025n

.meas tran vdout0_232ck340 FIND v(dout0_232) AT=175.025n

.meas tran vdout0_233ck340 FIND v(dout0_233) AT=175.025n

.meas tran vdout0_234ck340 FIND v(dout0_234) AT=175.025n

.meas tran vdout0_235ck340 FIND v(dout0_235) AT=175.025n

.meas tran vdout0_236ck340 FIND v(dout0_236) AT=175.025n

.meas tran vdout0_237ck340 FIND v(dout0_237) AT=175.025n

.meas tran vdout0_238ck340 FIND v(dout0_238) AT=175.025n

.meas tran vdout0_239ck340 FIND v(dout0_239) AT=175.025n

.meas tran vdout0_240ck340 FIND v(dout0_240) AT=175.025n

.meas tran vdout0_241ck340 FIND v(dout0_241) AT=175.025n

.meas tran vdout0_242ck340 FIND v(dout0_242) AT=175.025n

.meas tran vdout0_243ck340 FIND v(dout0_243) AT=175.025n

.meas tran vdout0_244ck340 FIND v(dout0_244) AT=175.025n

.meas tran vdout0_245ck340 FIND v(dout0_245) AT=175.025n

.meas tran vdout0_246ck340 FIND v(dout0_246) AT=175.025n

.meas tran vdout0_247ck340 FIND v(dout0_247) AT=175.025n

.meas tran vdout0_248ck340 FIND v(dout0_248) AT=175.025n

.meas tran vdout0_249ck340 FIND v(dout0_249) AT=175.025n

.meas tran vdout0_250ck340 FIND v(dout0_250) AT=175.025n

.meas tran vdout0_251ck340 FIND v(dout0_251) AT=175.025n

.meas tran vdout0_252ck340 FIND v(dout0_252) AT=175.025n

.meas tran vdout0_253ck340 FIND v(dout0_253) AT=175.025n

.meas tran vdout0_254ck340 FIND v(dout0_254) AT=175.025n

.meas tran vdout0_255ck340 FIND v(dout0_255) AT=175.025n

.meas tran vdout0_0ck350 FIND v(dout0_0) AT=180.025n

.meas tran vdout0_1ck350 FIND v(dout0_1) AT=180.025n

.meas tran vdout0_2ck350 FIND v(dout0_2) AT=180.025n

.meas tran vdout0_3ck350 FIND v(dout0_3) AT=180.025n

.meas tran vdout0_4ck350 FIND v(dout0_4) AT=180.025n

.meas tran vdout0_5ck350 FIND v(dout0_5) AT=180.025n

.meas tran vdout0_6ck350 FIND v(dout0_6) AT=180.025n

.meas tran vdout0_7ck350 FIND v(dout0_7) AT=180.025n

.meas tran vdout0_8ck350 FIND v(dout0_8) AT=180.025n

.meas tran vdout0_9ck350 FIND v(dout0_9) AT=180.025n

.meas tran vdout0_10ck350 FIND v(dout0_10) AT=180.025n

.meas tran vdout0_11ck350 FIND v(dout0_11) AT=180.025n

.meas tran vdout0_12ck350 FIND v(dout0_12) AT=180.025n

.meas tran vdout0_13ck350 FIND v(dout0_13) AT=180.025n

.meas tran vdout0_14ck350 FIND v(dout0_14) AT=180.025n

.meas tran vdout0_15ck350 FIND v(dout0_15) AT=180.025n

.meas tran vdout0_16ck350 FIND v(dout0_16) AT=180.025n

.meas tran vdout0_17ck350 FIND v(dout0_17) AT=180.025n

.meas tran vdout0_18ck350 FIND v(dout0_18) AT=180.025n

.meas tran vdout0_19ck350 FIND v(dout0_19) AT=180.025n

.meas tran vdout0_20ck350 FIND v(dout0_20) AT=180.025n

.meas tran vdout0_21ck350 FIND v(dout0_21) AT=180.025n

.meas tran vdout0_22ck350 FIND v(dout0_22) AT=180.025n

.meas tran vdout0_23ck350 FIND v(dout0_23) AT=180.025n

.meas tran vdout0_24ck350 FIND v(dout0_24) AT=180.025n

.meas tran vdout0_25ck350 FIND v(dout0_25) AT=180.025n

.meas tran vdout0_26ck350 FIND v(dout0_26) AT=180.025n

.meas tran vdout0_27ck350 FIND v(dout0_27) AT=180.025n

.meas tran vdout0_28ck350 FIND v(dout0_28) AT=180.025n

.meas tran vdout0_29ck350 FIND v(dout0_29) AT=180.025n

.meas tran vdout0_30ck350 FIND v(dout0_30) AT=180.025n

.meas tran vdout0_31ck350 FIND v(dout0_31) AT=180.025n

.meas tran vdout0_32ck350 FIND v(dout0_32) AT=180.025n

.meas tran vdout0_33ck350 FIND v(dout0_33) AT=180.025n

.meas tran vdout0_34ck350 FIND v(dout0_34) AT=180.025n

.meas tran vdout0_35ck350 FIND v(dout0_35) AT=180.025n

.meas tran vdout0_36ck350 FIND v(dout0_36) AT=180.025n

.meas tran vdout0_37ck350 FIND v(dout0_37) AT=180.025n

.meas tran vdout0_38ck350 FIND v(dout0_38) AT=180.025n

.meas tran vdout0_39ck350 FIND v(dout0_39) AT=180.025n

.meas tran vdout0_40ck350 FIND v(dout0_40) AT=180.025n

.meas tran vdout0_41ck350 FIND v(dout0_41) AT=180.025n

.meas tran vdout0_42ck350 FIND v(dout0_42) AT=180.025n

.meas tran vdout0_43ck350 FIND v(dout0_43) AT=180.025n

.meas tran vdout0_44ck350 FIND v(dout0_44) AT=180.025n

.meas tran vdout0_45ck350 FIND v(dout0_45) AT=180.025n

.meas tran vdout0_46ck350 FIND v(dout0_46) AT=180.025n

.meas tran vdout0_47ck350 FIND v(dout0_47) AT=180.025n

.meas tran vdout0_48ck350 FIND v(dout0_48) AT=180.025n

.meas tran vdout0_49ck350 FIND v(dout0_49) AT=180.025n

.meas tran vdout0_50ck350 FIND v(dout0_50) AT=180.025n

.meas tran vdout0_51ck350 FIND v(dout0_51) AT=180.025n

.meas tran vdout0_52ck350 FIND v(dout0_52) AT=180.025n

.meas tran vdout0_53ck350 FIND v(dout0_53) AT=180.025n

.meas tran vdout0_54ck350 FIND v(dout0_54) AT=180.025n

.meas tran vdout0_55ck350 FIND v(dout0_55) AT=180.025n

.meas tran vdout0_56ck350 FIND v(dout0_56) AT=180.025n

.meas tran vdout0_57ck350 FIND v(dout0_57) AT=180.025n

.meas tran vdout0_58ck350 FIND v(dout0_58) AT=180.025n

.meas tran vdout0_59ck350 FIND v(dout0_59) AT=180.025n

.meas tran vdout0_60ck350 FIND v(dout0_60) AT=180.025n

.meas tran vdout0_61ck350 FIND v(dout0_61) AT=180.025n

.meas tran vdout0_62ck350 FIND v(dout0_62) AT=180.025n

.meas tran vdout0_63ck350 FIND v(dout0_63) AT=180.025n

.meas tran vdout0_64ck350 FIND v(dout0_64) AT=180.025n

.meas tran vdout0_65ck350 FIND v(dout0_65) AT=180.025n

.meas tran vdout0_66ck350 FIND v(dout0_66) AT=180.025n

.meas tran vdout0_67ck350 FIND v(dout0_67) AT=180.025n

.meas tran vdout0_68ck350 FIND v(dout0_68) AT=180.025n

.meas tran vdout0_69ck350 FIND v(dout0_69) AT=180.025n

.meas tran vdout0_70ck350 FIND v(dout0_70) AT=180.025n

.meas tran vdout0_71ck350 FIND v(dout0_71) AT=180.025n

.meas tran vdout0_72ck350 FIND v(dout0_72) AT=180.025n

.meas tran vdout0_73ck350 FIND v(dout0_73) AT=180.025n

.meas tran vdout0_74ck350 FIND v(dout0_74) AT=180.025n

.meas tran vdout0_75ck350 FIND v(dout0_75) AT=180.025n

.meas tran vdout0_76ck350 FIND v(dout0_76) AT=180.025n

.meas tran vdout0_77ck350 FIND v(dout0_77) AT=180.025n

.meas tran vdout0_78ck350 FIND v(dout0_78) AT=180.025n

.meas tran vdout0_79ck350 FIND v(dout0_79) AT=180.025n

.meas tran vdout0_80ck350 FIND v(dout0_80) AT=180.025n

.meas tran vdout0_81ck350 FIND v(dout0_81) AT=180.025n

.meas tran vdout0_82ck350 FIND v(dout0_82) AT=180.025n

.meas tran vdout0_83ck350 FIND v(dout0_83) AT=180.025n

.meas tran vdout0_84ck350 FIND v(dout0_84) AT=180.025n

.meas tran vdout0_85ck350 FIND v(dout0_85) AT=180.025n

.meas tran vdout0_86ck350 FIND v(dout0_86) AT=180.025n

.meas tran vdout0_87ck350 FIND v(dout0_87) AT=180.025n

.meas tran vdout0_88ck350 FIND v(dout0_88) AT=180.025n

.meas tran vdout0_89ck350 FIND v(dout0_89) AT=180.025n

.meas tran vdout0_90ck350 FIND v(dout0_90) AT=180.025n

.meas tran vdout0_91ck350 FIND v(dout0_91) AT=180.025n

.meas tran vdout0_92ck350 FIND v(dout0_92) AT=180.025n

.meas tran vdout0_93ck350 FIND v(dout0_93) AT=180.025n

.meas tran vdout0_94ck350 FIND v(dout0_94) AT=180.025n

.meas tran vdout0_95ck350 FIND v(dout0_95) AT=180.025n

.meas tran vdout0_96ck350 FIND v(dout0_96) AT=180.025n

.meas tran vdout0_97ck350 FIND v(dout0_97) AT=180.025n

.meas tran vdout0_98ck350 FIND v(dout0_98) AT=180.025n

.meas tran vdout0_99ck350 FIND v(dout0_99) AT=180.025n

.meas tran vdout0_100ck350 FIND v(dout0_100) AT=180.025n

.meas tran vdout0_101ck350 FIND v(dout0_101) AT=180.025n

.meas tran vdout0_102ck350 FIND v(dout0_102) AT=180.025n

.meas tran vdout0_103ck350 FIND v(dout0_103) AT=180.025n

.meas tran vdout0_104ck350 FIND v(dout0_104) AT=180.025n

.meas tran vdout0_105ck350 FIND v(dout0_105) AT=180.025n

.meas tran vdout0_106ck350 FIND v(dout0_106) AT=180.025n

.meas tran vdout0_107ck350 FIND v(dout0_107) AT=180.025n

.meas tran vdout0_108ck350 FIND v(dout0_108) AT=180.025n

.meas tran vdout0_109ck350 FIND v(dout0_109) AT=180.025n

.meas tran vdout0_110ck350 FIND v(dout0_110) AT=180.025n

.meas tran vdout0_111ck350 FIND v(dout0_111) AT=180.025n

.meas tran vdout0_112ck350 FIND v(dout0_112) AT=180.025n

.meas tran vdout0_113ck350 FIND v(dout0_113) AT=180.025n

.meas tran vdout0_114ck350 FIND v(dout0_114) AT=180.025n

.meas tran vdout0_115ck350 FIND v(dout0_115) AT=180.025n

.meas tran vdout0_116ck350 FIND v(dout0_116) AT=180.025n

.meas tran vdout0_117ck350 FIND v(dout0_117) AT=180.025n

.meas tran vdout0_118ck350 FIND v(dout0_118) AT=180.025n

.meas tran vdout0_119ck350 FIND v(dout0_119) AT=180.025n

.meas tran vdout0_120ck350 FIND v(dout0_120) AT=180.025n

.meas tran vdout0_121ck350 FIND v(dout0_121) AT=180.025n

.meas tran vdout0_122ck350 FIND v(dout0_122) AT=180.025n

.meas tran vdout0_123ck350 FIND v(dout0_123) AT=180.025n

.meas tran vdout0_124ck350 FIND v(dout0_124) AT=180.025n

.meas tran vdout0_125ck350 FIND v(dout0_125) AT=180.025n

.meas tran vdout0_126ck350 FIND v(dout0_126) AT=180.025n

.meas tran vdout0_127ck350 FIND v(dout0_127) AT=180.025n

.meas tran vdout0_128ck350 FIND v(dout0_128) AT=180.025n

.meas tran vdout0_129ck350 FIND v(dout0_129) AT=180.025n

.meas tran vdout0_130ck350 FIND v(dout0_130) AT=180.025n

.meas tran vdout0_131ck350 FIND v(dout0_131) AT=180.025n

.meas tran vdout0_132ck350 FIND v(dout0_132) AT=180.025n

.meas tran vdout0_133ck350 FIND v(dout0_133) AT=180.025n

.meas tran vdout0_134ck350 FIND v(dout0_134) AT=180.025n

.meas tran vdout0_135ck350 FIND v(dout0_135) AT=180.025n

.meas tran vdout0_136ck350 FIND v(dout0_136) AT=180.025n

.meas tran vdout0_137ck350 FIND v(dout0_137) AT=180.025n

.meas tran vdout0_138ck350 FIND v(dout0_138) AT=180.025n

.meas tran vdout0_139ck350 FIND v(dout0_139) AT=180.025n

.meas tran vdout0_140ck350 FIND v(dout0_140) AT=180.025n

.meas tran vdout0_141ck350 FIND v(dout0_141) AT=180.025n

.meas tran vdout0_142ck350 FIND v(dout0_142) AT=180.025n

.meas tran vdout0_143ck350 FIND v(dout0_143) AT=180.025n

.meas tran vdout0_144ck350 FIND v(dout0_144) AT=180.025n

.meas tran vdout0_145ck350 FIND v(dout0_145) AT=180.025n

.meas tran vdout0_146ck350 FIND v(dout0_146) AT=180.025n

.meas tran vdout0_147ck350 FIND v(dout0_147) AT=180.025n

.meas tran vdout0_148ck350 FIND v(dout0_148) AT=180.025n

.meas tran vdout0_149ck350 FIND v(dout0_149) AT=180.025n

.meas tran vdout0_150ck350 FIND v(dout0_150) AT=180.025n

.meas tran vdout0_151ck350 FIND v(dout0_151) AT=180.025n

.meas tran vdout0_152ck350 FIND v(dout0_152) AT=180.025n

.meas tran vdout0_153ck350 FIND v(dout0_153) AT=180.025n

.meas tran vdout0_154ck350 FIND v(dout0_154) AT=180.025n

.meas tran vdout0_155ck350 FIND v(dout0_155) AT=180.025n

.meas tran vdout0_156ck350 FIND v(dout0_156) AT=180.025n

.meas tran vdout0_157ck350 FIND v(dout0_157) AT=180.025n

.meas tran vdout0_158ck350 FIND v(dout0_158) AT=180.025n

.meas tran vdout0_159ck350 FIND v(dout0_159) AT=180.025n

.meas tran vdout0_160ck350 FIND v(dout0_160) AT=180.025n

.meas tran vdout0_161ck350 FIND v(dout0_161) AT=180.025n

.meas tran vdout0_162ck350 FIND v(dout0_162) AT=180.025n

.meas tran vdout0_163ck350 FIND v(dout0_163) AT=180.025n

.meas tran vdout0_164ck350 FIND v(dout0_164) AT=180.025n

.meas tran vdout0_165ck350 FIND v(dout0_165) AT=180.025n

.meas tran vdout0_166ck350 FIND v(dout0_166) AT=180.025n

.meas tran vdout0_167ck350 FIND v(dout0_167) AT=180.025n

.meas tran vdout0_168ck350 FIND v(dout0_168) AT=180.025n

.meas tran vdout0_169ck350 FIND v(dout0_169) AT=180.025n

.meas tran vdout0_170ck350 FIND v(dout0_170) AT=180.025n

.meas tran vdout0_171ck350 FIND v(dout0_171) AT=180.025n

.meas tran vdout0_172ck350 FIND v(dout0_172) AT=180.025n

.meas tran vdout0_173ck350 FIND v(dout0_173) AT=180.025n

.meas tran vdout0_174ck350 FIND v(dout0_174) AT=180.025n

.meas tran vdout0_175ck350 FIND v(dout0_175) AT=180.025n

.meas tran vdout0_176ck350 FIND v(dout0_176) AT=180.025n

.meas tran vdout0_177ck350 FIND v(dout0_177) AT=180.025n

.meas tran vdout0_178ck350 FIND v(dout0_178) AT=180.025n

.meas tran vdout0_179ck350 FIND v(dout0_179) AT=180.025n

.meas tran vdout0_180ck350 FIND v(dout0_180) AT=180.025n

.meas tran vdout0_181ck350 FIND v(dout0_181) AT=180.025n

.meas tran vdout0_182ck350 FIND v(dout0_182) AT=180.025n

.meas tran vdout0_183ck350 FIND v(dout0_183) AT=180.025n

.meas tran vdout0_184ck350 FIND v(dout0_184) AT=180.025n

.meas tran vdout0_185ck350 FIND v(dout0_185) AT=180.025n

.meas tran vdout0_186ck350 FIND v(dout0_186) AT=180.025n

.meas tran vdout0_187ck350 FIND v(dout0_187) AT=180.025n

.meas tran vdout0_188ck350 FIND v(dout0_188) AT=180.025n

.meas tran vdout0_189ck350 FIND v(dout0_189) AT=180.025n

.meas tran vdout0_190ck350 FIND v(dout0_190) AT=180.025n

.meas tran vdout0_191ck350 FIND v(dout0_191) AT=180.025n

.meas tran vdout0_192ck350 FIND v(dout0_192) AT=180.025n

.meas tran vdout0_193ck350 FIND v(dout0_193) AT=180.025n

.meas tran vdout0_194ck350 FIND v(dout0_194) AT=180.025n

.meas tran vdout0_195ck350 FIND v(dout0_195) AT=180.025n

.meas tran vdout0_196ck350 FIND v(dout0_196) AT=180.025n

.meas tran vdout0_197ck350 FIND v(dout0_197) AT=180.025n

.meas tran vdout0_198ck350 FIND v(dout0_198) AT=180.025n

.meas tran vdout0_199ck350 FIND v(dout0_199) AT=180.025n

.meas tran vdout0_200ck350 FIND v(dout0_200) AT=180.025n

.meas tran vdout0_201ck350 FIND v(dout0_201) AT=180.025n

.meas tran vdout0_202ck350 FIND v(dout0_202) AT=180.025n

.meas tran vdout0_203ck350 FIND v(dout0_203) AT=180.025n

.meas tran vdout0_204ck350 FIND v(dout0_204) AT=180.025n

.meas tran vdout0_205ck350 FIND v(dout0_205) AT=180.025n

.meas tran vdout0_206ck350 FIND v(dout0_206) AT=180.025n

.meas tran vdout0_207ck350 FIND v(dout0_207) AT=180.025n

.meas tran vdout0_208ck350 FIND v(dout0_208) AT=180.025n

.meas tran vdout0_209ck350 FIND v(dout0_209) AT=180.025n

.meas tran vdout0_210ck350 FIND v(dout0_210) AT=180.025n

.meas tran vdout0_211ck350 FIND v(dout0_211) AT=180.025n

.meas tran vdout0_212ck350 FIND v(dout0_212) AT=180.025n

.meas tran vdout0_213ck350 FIND v(dout0_213) AT=180.025n

.meas tran vdout0_214ck350 FIND v(dout0_214) AT=180.025n

.meas tran vdout0_215ck350 FIND v(dout0_215) AT=180.025n

.meas tran vdout0_216ck350 FIND v(dout0_216) AT=180.025n

.meas tran vdout0_217ck350 FIND v(dout0_217) AT=180.025n

.meas tran vdout0_218ck350 FIND v(dout0_218) AT=180.025n

.meas tran vdout0_219ck350 FIND v(dout0_219) AT=180.025n

.meas tran vdout0_220ck350 FIND v(dout0_220) AT=180.025n

.meas tran vdout0_221ck350 FIND v(dout0_221) AT=180.025n

.meas tran vdout0_222ck350 FIND v(dout0_222) AT=180.025n

.meas tran vdout0_223ck350 FIND v(dout0_223) AT=180.025n

.meas tran vdout0_224ck350 FIND v(dout0_224) AT=180.025n

.meas tran vdout0_225ck350 FIND v(dout0_225) AT=180.025n

.meas tran vdout0_226ck350 FIND v(dout0_226) AT=180.025n

.meas tran vdout0_227ck350 FIND v(dout0_227) AT=180.025n

.meas tran vdout0_228ck350 FIND v(dout0_228) AT=180.025n

.meas tran vdout0_229ck350 FIND v(dout0_229) AT=180.025n

.meas tran vdout0_230ck350 FIND v(dout0_230) AT=180.025n

.meas tran vdout0_231ck350 FIND v(dout0_231) AT=180.025n

.meas tran vdout0_232ck350 FIND v(dout0_232) AT=180.025n

.meas tran vdout0_233ck350 FIND v(dout0_233) AT=180.025n

.meas tran vdout0_234ck350 FIND v(dout0_234) AT=180.025n

.meas tran vdout0_235ck350 FIND v(dout0_235) AT=180.025n

.meas tran vdout0_236ck350 FIND v(dout0_236) AT=180.025n

.meas tran vdout0_237ck350 FIND v(dout0_237) AT=180.025n

.meas tran vdout0_238ck350 FIND v(dout0_238) AT=180.025n

.meas tran vdout0_239ck350 FIND v(dout0_239) AT=180.025n

.meas tran vdout0_240ck350 FIND v(dout0_240) AT=180.025n

.meas tran vdout0_241ck350 FIND v(dout0_241) AT=180.025n

.meas tran vdout0_242ck350 FIND v(dout0_242) AT=180.025n

.meas tran vdout0_243ck350 FIND v(dout0_243) AT=180.025n

.meas tran vdout0_244ck350 FIND v(dout0_244) AT=180.025n

.meas tran vdout0_245ck350 FIND v(dout0_245) AT=180.025n

.meas tran vdout0_246ck350 FIND v(dout0_246) AT=180.025n

.meas tran vdout0_247ck350 FIND v(dout0_247) AT=180.025n

.meas tran vdout0_248ck350 FIND v(dout0_248) AT=180.025n

.meas tran vdout0_249ck350 FIND v(dout0_249) AT=180.025n

.meas tran vdout0_250ck350 FIND v(dout0_250) AT=180.025n

.meas tran vdout0_251ck350 FIND v(dout0_251) AT=180.025n

.meas tran vdout0_252ck350 FIND v(dout0_252) AT=180.025n

.meas tran vdout0_253ck350 FIND v(dout0_253) AT=180.025n

.meas tran vdout0_254ck350 FIND v(dout0_254) AT=180.025n

.meas tran vdout0_255ck350 FIND v(dout0_255) AT=180.025n

.meas tran vdout0_0ck370 FIND v(dout0_0) AT=190.025n

.meas tran vdout0_1ck370 FIND v(dout0_1) AT=190.025n

.meas tran vdout0_2ck370 FIND v(dout0_2) AT=190.025n

.meas tran vdout0_3ck370 FIND v(dout0_3) AT=190.025n

.meas tran vdout0_4ck370 FIND v(dout0_4) AT=190.025n

.meas tran vdout0_5ck370 FIND v(dout0_5) AT=190.025n

.meas tran vdout0_6ck370 FIND v(dout0_6) AT=190.025n

.meas tran vdout0_7ck370 FIND v(dout0_7) AT=190.025n

.meas tran vdout0_8ck370 FIND v(dout0_8) AT=190.025n

.meas tran vdout0_9ck370 FIND v(dout0_9) AT=190.025n

.meas tran vdout0_10ck370 FIND v(dout0_10) AT=190.025n

.meas tran vdout0_11ck370 FIND v(dout0_11) AT=190.025n

.meas tran vdout0_12ck370 FIND v(dout0_12) AT=190.025n

.meas tran vdout0_13ck370 FIND v(dout0_13) AT=190.025n

.meas tran vdout0_14ck370 FIND v(dout0_14) AT=190.025n

.meas tran vdout0_15ck370 FIND v(dout0_15) AT=190.025n

.meas tran vdout0_16ck370 FIND v(dout0_16) AT=190.025n

.meas tran vdout0_17ck370 FIND v(dout0_17) AT=190.025n

.meas tran vdout0_18ck370 FIND v(dout0_18) AT=190.025n

.meas tran vdout0_19ck370 FIND v(dout0_19) AT=190.025n

.meas tran vdout0_20ck370 FIND v(dout0_20) AT=190.025n

.meas tran vdout0_21ck370 FIND v(dout0_21) AT=190.025n

.meas tran vdout0_22ck370 FIND v(dout0_22) AT=190.025n

.meas tran vdout0_23ck370 FIND v(dout0_23) AT=190.025n

.meas tran vdout0_24ck370 FIND v(dout0_24) AT=190.025n

.meas tran vdout0_25ck370 FIND v(dout0_25) AT=190.025n

.meas tran vdout0_26ck370 FIND v(dout0_26) AT=190.025n

.meas tran vdout0_27ck370 FIND v(dout0_27) AT=190.025n

.meas tran vdout0_28ck370 FIND v(dout0_28) AT=190.025n

.meas tran vdout0_29ck370 FIND v(dout0_29) AT=190.025n

.meas tran vdout0_30ck370 FIND v(dout0_30) AT=190.025n

.meas tran vdout0_31ck370 FIND v(dout0_31) AT=190.025n

.meas tran vdout0_32ck370 FIND v(dout0_32) AT=190.025n

.meas tran vdout0_33ck370 FIND v(dout0_33) AT=190.025n

.meas tran vdout0_34ck370 FIND v(dout0_34) AT=190.025n

.meas tran vdout0_35ck370 FIND v(dout0_35) AT=190.025n

.meas tran vdout0_36ck370 FIND v(dout0_36) AT=190.025n

.meas tran vdout0_37ck370 FIND v(dout0_37) AT=190.025n

.meas tran vdout0_38ck370 FIND v(dout0_38) AT=190.025n

.meas tran vdout0_39ck370 FIND v(dout0_39) AT=190.025n

.meas tran vdout0_40ck370 FIND v(dout0_40) AT=190.025n

.meas tran vdout0_41ck370 FIND v(dout0_41) AT=190.025n

.meas tran vdout0_42ck370 FIND v(dout0_42) AT=190.025n

.meas tran vdout0_43ck370 FIND v(dout0_43) AT=190.025n

.meas tran vdout0_44ck370 FIND v(dout0_44) AT=190.025n

.meas tran vdout0_45ck370 FIND v(dout0_45) AT=190.025n

.meas tran vdout0_46ck370 FIND v(dout0_46) AT=190.025n

.meas tran vdout0_47ck370 FIND v(dout0_47) AT=190.025n

.meas tran vdout0_48ck370 FIND v(dout0_48) AT=190.025n

.meas tran vdout0_49ck370 FIND v(dout0_49) AT=190.025n

.meas tran vdout0_50ck370 FIND v(dout0_50) AT=190.025n

.meas tran vdout0_51ck370 FIND v(dout0_51) AT=190.025n

.meas tran vdout0_52ck370 FIND v(dout0_52) AT=190.025n

.meas tran vdout0_53ck370 FIND v(dout0_53) AT=190.025n

.meas tran vdout0_54ck370 FIND v(dout0_54) AT=190.025n

.meas tran vdout0_55ck370 FIND v(dout0_55) AT=190.025n

.meas tran vdout0_56ck370 FIND v(dout0_56) AT=190.025n

.meas tran vdout0_57ck370 FIND v(dout0_57) AT=190.025n

.meas tran vdout0_58ck370 FIND v(dout0_58) AT=190.025n

.meas tran vdout0_59ck370 FIND v(dout0_59) AT=190.025n

.meas tran vdout0_60ck370 FIND v(dout0_60) AT=190.025n

.meas tran vdout0_61ck370 FIND v(dout0_61) AT=190.025n

.meas tran vdout0_62ck370 FIND v(dout0_62) AT=190.025n

.meas tran vdout0_63ck370 FIND v(dout0_63) AT=190.025n

.meas tran vdout0_64ck370 FIND v(dout0_64) AT=190.025n

.meas tran vdout0_65ck370 FIND v(dout0_65) AT=190.025n

.meas tran vdout0_66ck370 FIND v(dout0_66) AT=190.025n

.meas tran vdout0_67ck370 FIND v(dout0_67) AT=190.025n

.meas tran vdout0_68ck370 FIND v(dout0_68) AT=190.025n

.meas tran vdout0_69ck370 FIND v(dout0_69) AT=190.025n

.meas tran vdout0_70ck370 FIND v(dout0_70) AT=190.025n

.meas tran vdout0_71ck370 FIND v(dout0_71) AT=190.025n

.meas tran vdout0_72ck370 FIND v(dout0_72) AT=190.025n

.meas tran vdout0_73ck370 FIND v(dout0_73) AT=190.025n

.meas tran vdout0_74ck370 FIND v(dout0_74) AT=190.025n

.meas tran vdout0_75ck370 FIND v(dout0_75) AT=190.025n

.meas tran vdout0_76ck370 FIND v(dout0_76) AT=190.025n

.meas tran vdout0_77ck370 FIND v(dout0_77) AT=190.025n

.meas tran vdout0_78ck370 FIND v(dout0_78) AT=190.025n

.meas tran vdout0_79ck370 FIND v(dout0_79) AT=190.025n

.meas tran vdout0_80ck370 FIND v(dout0_80) AT=190.025n

.meas tran vdout0_81ck370 FIND v(dout0_81) AT=190.025n

.meas tran vdout0_82ck370 FIND v(dout0_82) AT=190.025n

.meas tran vdout0_83ck370 FIND v(dout0_83) AT=190.025n

.meas tran vdout0_84ck370 FIND v(dout0_84) AT=190.025n

.meas tran vdout0_85ck370 FIND v(dout0_85) AT=190.025n

.meas tran vdout0_86ck370 FIND v(dout0_86) AT=190.025n

.meas tran vdout0_87ck370 FIND v(dout0_87) AT=190.025n

.meas tran vdout0_88ck370 FIND v(dout0_88) AT=190.025n

.meas tran vdout0_89ck370 FIND v(dout0_89) AT=190.025n

.meas tran vdout0_90ck370 FIND v(dout0_90) AT=190.025n

.meas tran vdout0_91ck370 FIND v(dout0_91) AT=190.025n

.meas tran vdout0_92ck370 FIND v(dout0_92) AT=190.025n

.meas tran vdout0_93ck370 FIND v(dout0_93) AT=190.025n

.meas tran vdout0_94ck370 FIND v(dout0_94) AT=190.025n

.meas tran vdout0_95ck370 FIND v(dout0_95) AT=190.025n

.meas tran vdout0_96ck370 FIND v(dout0_96) AT=190.025n

.meas tran vdout0_97ck370 FIND v(dout0_97) AT=190.025n

.meas tran vdout0_98ck370 FIND v(dout0_98) AT=190.025n

.meas tran vdout0_99ck370 FIND v(dout0_99) AT=190.025n

.meas tran vdout0_100ck370 FIND v(dout0_100) AT=190.025n

.meas tran vdout0_101ck370 FIND v(dout0_101) AT=190.025n

.meas tran vdout0_102ck370 FIND v(dout0_102) AT=190.025n

.meas tran vdout0_103ck370 FIND v(dout0_103) AT=190.025n

.meas tran vdout0_104ck370 FIND v(dout0_104) AT=190.025n

.meas tran vdout0_105ck370 FIND v(dout0_105) AT=190.025n

.meas tran vdout0_106ck370 FIND v(dout0_106) AT=190.025n

.meas tran vdout0_107ck370 FIND v(dout0_107) AT=190.025n

.meas tran vdout0_108ck370 FIND v(dout0_108) AT=190.025n

.meas tran vdout0_109ck370 FIND v(dout0_109) AT=190.025n

.meas tran vdout0_110ck370 FIND v(dout0_110) AT=190.025n

.meas tran vdout0_111ck370 FIND v(dout0_111) AT=190.025n

.meas tran vdout0_112ck370 FIND v(dout0_112) AT=190.025n

.meas tran vdout0_113ck370 FIND v(dout0_113) AT=190.025n

.meas tran vdout0_114ck370 FIND v(dout0_114) AT=190.025n

.meas tran vdout0_115ck370 FIND v(dout0_115) AT=190.025n

.meas tran vdout0_116ck370 FIND v(dout0_116) AT=190.025n

.meas tran vdout0_117ck370 FIND v(dout0_117) AT=190.025n

.meas tran vdout0_118ck370 FIND v(dout0_118) AT=190.025n

.meas tran vdout0_119ck370 FIND v(dout0_119) AT=190.025n

.meas tran vdout0_120ck370 FIND v(dout0_120) AT=190.025n

.meas tran vdout0_121ck370 FIND v(dout0_121) AT=190.025n

.meas tran vdout0_122ck370 FIND v(dout0_122) AT=190.025n

.meas tran vdout0_123ck370 FIND v(dout0_123) AT=190.025n

.meas tran vdout0_124ck370 FIND v(dout0_124) AT=190.025n

.meas tran vdout0_125ck370 FIND v(dout0_125) AT=190.025n

.meas tran vdout0_126ck370 FIND v(dout0_126) AT=190.025n

.meas tran vdout0_127ck370 FIND v(dout0_127) AT=190.025n

.meas tran vdout0_128ck370 FIND v(dout0_128) AT=190.025n

.meas tran vdout0_129ck370 FIND v(dout0_129) AT=190.025n

.meas tran vdout0_130ck370 FIND v(dout0_130) AT=190.025n

.meas tran vdout0_131ck370 FIND v(dout0_131) AT=190.025n

.meas tran vdout0_132ck370 FIND v(dout0_132) AT=190.025n

.meas tran vdout0_133ck370 FIND v(dout0_133) AT=190.025n

.meas tran vdout0_134ck370 FIND v(dout0_134) AT=190.025n

.meas tran vdout0_135ck370 FIND v(dout0_135) AT=190.025n

.meas tran vdout0_136ck370 FIND v(dout0_136) AT=190.025n

.meas tran vdout0_137ck370 FIND v(dout0_137) AT=190.025n

.meas tran vdout0_138ck370 FIND v(dout0_138) AT=190.025n

.meas tran vdout0_139ck370 FIND v(dout0_139) AT=190.025n

.meas tran vdout0_140ck370 FIND v(dout0_140) AT=190.025n

.meas tran vdout0_141ck370 FIND v(dout0_141) AT=190.025n

.meas tran vdout0_142ck370 FIND v(dout0_142) AT=190.025n

.meas tran vdout0_143ck370 FIND v(dout0_143) AT=190.025n

.meas tran vdout0_144ck370 FIND v(dout0_144) AT=190.025n

.meas tran vdout0_145ck370 FIND v(dout0_145) AT=190.025n

.meas tran vdout0_146ck370 FIND v(dout0_146) AT=190.025n

.meas tran vdout0_147ck370 FIND v(dout0_147) AT=190.025n

.meas tran vdout0_148ck370 FIND v(dout0_148) AT=190.025n

.meas tran vdout0_149ck370 FIND v(dout0_149) AT=190.025n

.meas tran vdout0_150ck370 FIND v(dout0_150) AT=190.025n

.meas tran vdout0_151ck370 FIND v(dout0_151) AT=190.025n

.meas tran vdout0_152ck370 FIND v(dout0_152) AT=190.025n

.meas tran vdout0_153ck370 FIND v(dout0_153) AT=190.025n

.meas tran vdout0_154ck370 FIND v(dout0_154) AT=190.025n

.meas tran vdout0_155ck370 FIND v(dout0_155) AT=190.025n

.meas tran vdout0_156ck370 FIND v(dout0_156) AT=190.025n

.meas tran vdout0_157ck370 FIND v(dout0_157) AT=190.025n

.meas tran vdout0_158ck370 FIND v(dout0_158) AT=190.025n

.meas tran vdout0_159ck370 FIND v(dout0_159) AT=190.025n

.meas tran vdout0_160ck370 FIND v(dout0_160) AT=190.025n

.meas tran vdout0_161ck370 FIND v(dout0_161) AT=190.025n

.meas tran vdout0_162ck370 FIND v(dout0_162) AT=190.025n

.meas tran vdout0_163ck370 FIND v(dout0_163) AT=190.025n

.meas tran vdout0_164ck370 FIND v(dout0_164) AT=190.025n

.meas tran vdout0_165ck370 FIND v(dout0_165) AT=190.025n

.meas tran vdout0_166ck370 FIND v(dout0_166) AT=190.025n

.meas tran vdout0_167ck370 FIND v(dout0_167) AT=190.025n

.meas tran vdout0_168ck370 FIND v(dout0_168) AT=190.025n

.meas tran vdout0_169ck370 FIND v(dout0_169) AT=190.025n

.meas tran vdout0_170ck370 FIND v(dout0_170) AT=190.025n

.meas tran vdout0_171ck370 FIND v(dout0_171) AT=190.025n

.meas tran vdout0_172ck370 FIND v(dout0_172) AT=190.025n

.meas tran vdout0_173ck370 FIND v(dout0_173) AT=190.025n

.meas tran vdout0_174ck370 FIND v(dout0_174) AT=190.025n

.meas tran vdout0_175ck370 FIND v(dout0_175) AT=190.025n

.meas tran vdout0_176ck370 FIND v(dout0_176) AT=190.025n

.meas tran vdout0_177ck370 FIND v(dout0_177) AT=190.025n

.meas tran vdout0_178ck370 FIND v(dout0_178) AT=190.025n

.meas tran vdout0_179ck370 FIND v(dout0_179) AT=190.025n

.meas tran vdout0_180ck370 FIND v(dout0_180) AT=190.025n

.meas tran vdout0_181ck370 FIND v(dout0_181) AT=190.025n

.meas tran vdout0_182ck370 FIND v(dout0_182) AT=190.025n

.meas tran vdout0_183ck370 FIND v(dout0_183) AT=190.025n

.meas tran vdout0_184ck370 FIND v(dout0_184) AT=190.025n

.meas tran vdout0_185ck370 FIND v(dout0_185) AT=190.025n

.meas tran vdout0_186ck370 FIND v(dout0_186) AT=190.025n

.meas tran vdout0_187ck370 FIND v(dout0_187) AT=190.025n

.meas tran vdout0_188ck370 FIND v(dout0_188) AT=190.025n

.meas tran vdout0_189ck370 FIND v(dout0_189) AT=190.025n

.meas tran vdout0_190ck370 FIND v(dout0_190) AT=190.025n

.meas tran vdout0_191ck370 FIND v(dout0_191) AT=190.025n

.meas tran vdout0_192ck370 FIND v(dout0_192) AT=190.025n

.meas tran vdout0_193ck370 FIND v(dout0_193) AT=190.025n

.meas tran vdout0_194ck370 FIND v(dout0_194) AT=190.025n

.meas tran vdout0_195ck370 FIND v(dout0_195) AT=190.025n

.meas tran vdout0_196ck370 FIND v(dout0_196) AT=190.025n

.meas tran vdout0_197ck370 FIND v(dout0_197) AT=190.025n

.meas tran vdout0_198ck370 FIND v(dout0_198) AT=190.025n

.meas tran vdout0_199ck370 FIND v(dout0_199) AT=190.025n

.meas tran vdout0_200ck370 FIND v(dout0_200) AT=190.025n

.meas tran vdout0_201ck370 FIND v(dout0_201) AT=190.025n

.meas tran vdout0_202ck370 FIND v(dout0_202) AT=190.025n

.meas tran vdout0_203ck370 FIND v(dout0_203) AT=190.025n

.meas tran vdout0_204ck370 FIND v(dout0_204) AT=190.025n

.meas tran vdout0_205ck370 FIND v(dout0_205) AT=190.025n

.meas tran vdout0_206ck370 FIND v(dout0_206) AT=190.025n

.meas tran vdout0_207ck370 FIND v(dout0_207) AT=190.025n

.meas tran vdout0_208ck370 FIND v(dout0_208) AT=190.025n

.meas tran vdout0_209ck370 FIND v(dout0_209) AT=190.025n

.meas tran vdout0_210ck370 FIND v(dout0_210) AT=190.025n

.meas tran vdout0_211ck370 FIND v(dout0_211) AT=190.025n

.meas tran vdout0_212ck370 FIND v(dout0_212) AT=190.025n

.meas tran vdout0_213ck370 FIND v(dout0_213) AT=190.025n

.meas tran vdout0_214ck370 FIND v(dout0_214) AT=190.025n

.meas tran vdout0_215ck370 FIND v(dout0_215) AT=190.025n

.meas tran vdout0_216ck370 FIND v(dout0_216) AT=190.025n

.meas tran vdout0_217ck370 FIND v(dout0_217) AT=190.025n

.meas tran vdout0_218ck370 FIND v(dout0_218) AT=190.025n

.meas tran vdout0_219ck370 FIND v(dout0_219) AT=190.025n

.meas tran vdout0_220ck370 FIND v(dout0_220) AT=190.025n

.meas tran vdout0_221ck370 FIND v(dout0_221) AT=190.025n

.meas tran vdout0_222ck370 FIND v(dout0_222) AT=190.025n

.meas tran vdout0_223ck370 FIND v(dout0_223) AT=190.025n

.meas tran vdout0_224ck370 FIND v(dout0_224) AT=190.025n

.meas tran vdout0_225ck370 FIND v(dout0_225) AT=190.025n

.meas tran vdout0_226ck370 FIND v(dout0_226) AT=190.025n

.meas tran vdout0_227ck370 FIND v(dout0_227) AT=190.025n

.meas tran vdout0_228ck370 FIND v(dout0_228) AT=190.025n

.meas tran vdout0_229ck370 FIND v(dout0_229) AT=190.025n

.meas tran vdout0_230ck370 FIND v(dout0_230) AT=190.025n

.meas tran vdout0_231ck370 FIND v(dout0_231) AT=190.025n

.meas tran vdout0_232ck370 FIND v(dout0_232) AT=190.025n

.meas tran vdout0_233ck370 FIND v(dout0_233) AT=190.025n

.meas tran vdout0_234ck370 FIND v(dout0_234) AT=190.025n

.meas tran vdout0_235ck370 FIND v(dout0_235) AT=190.025n

.meas tran vdout0_236ck370 FIND v(dout0_236) AT=190.025n

.meas tran vdout0_237ck370 FIND v(dout0_237) AT=190.025n

.meas tran vdout0_238ck370 FIND v(dout0_238) AT=190.025n

.meas tran vdout0_239ck370 FIND v(dout0_239) AT=190.025n

.meas tran vdout0_240ck370 FIND v(dout0_240) AT=190.025n

.meas tran vdout0_241ck370 FIND v(dout0_241) AT=190.025n

.meas tran vdout0_242ck370 FIND v(dout0_242) AT=190.025n

.meas tran vdout0_243ck370 FIND v(dout0_243) AT=190.025n

.meas tran vdout0_244ck370 FIND v(dout0_244) AT=190.025n

.meas tran vdout0_245ck370 FIND v(dout0_245) AT=190.025n

.meas tran vdout0_246ck370 FIND v(dout0_246) AT=190.025n

.meas tran vdout0_247ck370 FIND v(dout0_247) AT=190.025n

.meas tran vdout0_248ck370 FIND v(dout0_248) AT=190.025n

.meas tran vdout0_249ck370 FIND v(dout0_249) AT=190.025n

.meas tran vdout0_250ck370 FIND v(dout0_250) AT=190.025n

.meas tran vdout0_251ck370 FIND v(dout0_251) AT=190.025n

.meas tran vdout0_252ck370 FIND v(dout0_252) AT=190.025n

.meas tran vdout0_253ck370 FIND v(dout0_253) AT=190.025n

.meas tran vdout0_254ck370 FIND v(dout0_254) AT=190.025n

.meas tran vdout0_255ck370 FIND v(dout0_255) AT=190.025n

.meas tran vdout0_0ck380 FIND v(dout0_0) AT=195.025n

.meas tran vdout0_1ck380 FIND v(dout0_1) AT=195.025n

.meas tran vdout0_2ck380 FIND v(dout0_2) AT=195.025n

.meas tran vdout0_3ck380 FIND v(dout0_3) AT=195.025n

.meas tran vdout0_4ck380 FIND v(dout0_4) AT=195.025n

.meas tran vdout0_5ck380 FIND v(dout0_5) AT=195.025n

.meas tran vdout0_6ck380 FIND v(dout0_6) AT=195.025n

.meas tran vdout0_7ck380 FIND v(dout0_7) AT=195.025n

.meas tran vdout0_8ck380 FIND v(dout0_8) AT=195.025n

.meas tran vdout0_9ck380 FIND v(dout0_9) AT=195.025n

.meas tran vdout0_10ck380 FIND v(dout0_10) AT=195.025n

.meas tran vdout0_11ck380 FIND v(dout0_11) AT=195.025n

.meas tran vdout0_12ck380 FIND v(dout0_12) AT=195.025n

.meas tran vdout0_13ck380 FIND v(dout0_13) AT=195.025n

.meas tran vdout0_14ck380 FIND v(dout0_14) AT=195.025n

.meas tran vdout0_15ck380 FIND v(dout0_15) AT=195.025n

.meas tran vdout0_16ck380 FIND v(dout0_16) AT=195.025n

.meas tran vdout0_17ck380 FIND v(dout0_17) AT=195.025n

.meas tran vdout0_18ck380 FIND v(dout0_18) AT=195.025n

.meas tran vdout0_19ck380 FIND v(dout0_19) AT=195.025n

.meas tran vdout0_20ck380 FIND v(dout0_20) AT=195.025n

.meas tran vdout0_21ck380 FIND v(dout0_21) AT=195.025n

.meas tran vdout0_22ck380 FIND v(dout0_22) AT=195.025n

.meas tran vdout0_23ck380 FIND v(dout0_23) AT=195.025n

.meas tran vdout0_24ck380 FIND v(dout0_24) AT=195.025n

.meas tran vdout0_25ck380 FIND v(dout0_25) AT=195.025n

.meas tran vdout0_26ck380 FIND v(dout0_26) AT=195.025n

.meas tran vdout0_27ck380 FIND v(dout0_27) AT=195.025n

.meas tran vdout0_28ck380 FIND v(dout0_28) AT=195.025n

.meas tran vdout0_29ck380 FIND v(dout0_29) AT=195.025n

.meas tran vdout0_30ck380 FIND v(dout0_30) AT=195.025n

.meas tran vdout0_31ck380 FIND v(dout0_31) AT=195.025n

.meas tran vdout0_32ck380 FIND v(dout0_32) AT=195.025n

.meas tran vdout0_33ck380 FIND v(dout0_33) AT=195.025n

.meas tran vdout0_34ck380 FIND v(dout0_34) AT=195.025n

.meas tran vdout0_35ck380 FIND v(dout0_35) AT=195.025n

.meas tran vdout0_36ck380 FIND v(dout0_36) AT=195.025n

.meas tran vdout0_37ck380 FIND v(dout0_37) AT=195.025n

.meas tran vdout0_38ck380 FIND v(dout0_38) AT=195.025n

.meas tran vdout0_39ck380 FIND v(dout0_39) AT=195.025n

.meas tran vdout0_40ck380 FIND v(dout0_40) AT=195.025n

.meas tran vdout0_41ck380 FIND v(dout0_41) AT=195.025n

.meas tran vdout0_42ck380 FIND v(dout0_42) AT=195.025n

.meas tran vdout0_43ck380 FIND v(dout0_43) AT=195.025n

.meas tran vdout0_44ck380 FIND v(dout0_44) AT=195.025n

.meas tran vdout0_45ck380 FIND v(dout0_45) AT=195.025n

.meas tran vdout0_46ck380 FIND v(dout0_46) AT=195.025n

.meas tran vdout0_47ck380 FIND v(dout0_47) AT=195.025n

.meas tran vdout0_48ck380 FIND v(dout0_48) AT=195.025n

.meas tran vdout0_49ck380 FIND v(dout0_49) AT=195.025n

.meas tran vdout0_50ck380 FIND v(dout0_50) AT=195.025n

.meas tran vdout0_51ck380 FIND v(dout0_51) AT=195.025n

.meas tran vdout0_52ck380 FIND v(dout0_52) AT=195.025n

.meas tran vdout0_53ck380 FIND v(dout0_53) AT=195.025n

.meas tran vdout0_54ck380 FIND v(dout0_54) AT=195.025n

.meas tran vdout0_55ck380 FIND v(dout0_55) AT=195.025n

.meas tran vdout0_56ck380 FIND v(dout0_56) AT=195.025n

.meas tran vdout0_57ck380 FIND v(dout0_57) AT=195.025n

.meas tran vdout0_58ck380 FIND v(dout0_58) AT=195.025n

.meas tran vdout0_59ck380 FIND v(dout0_59) AT=195.025n

.meas tran vdout0_60ck380 FIND v(dout0_60) AT=195.025n

.meas tran vdout0_61ck380 FIND v(dout0_61) AT=195.025n

.meas tran vdout0_62ck380 FIND v(dout0_62) AT=195.025n

.meas tran vdout0_63ck380 FIND v(dout0_63) AT=195.025n

.meas tran vdout0_64ck380 FIND v(dout0_64) AT=195.025n

.meas tran vdout0_65ck380 FIND v(dout0_65) AT=195.025n

.meas tran vdout0_66ck380 FIND v(dout0_66) AT=195.025n

.meas tran vdout0_67ck380 FIND v(dout0_67) AT=195.025n

.meas tran vdout0_68ck380 FIND v(dout0_68) AT=195.025n

.meas tran vdout0_69ck380 FIND v(dout0_69) AT=195.025n

.meas tran vdout0_70ck380 FIND v(dout0_70) AT=195.025n

.meas tran vdout0_71ck380 FIND v(dout0_71) AT=195.025n

.meas tran vdout0_72ck380 FIND v(dout0_72) AT=195.025n

.meas tran vdout0_73ck380 FIND v(dout0_73) AT=195.025n

.meas tran vdout0_74ck380 FIND v(dout0_74) AT=195.025n

.meas tran vdout0_75ck380 FIND v(dout0_75) AT=195.025n

.meas tran vdout0_76ck380 FIND v(dout0_76) AT=195.025n

.meas tran vdout0_77ck380 FIND v(dout0_77) AT=195.025n

.meas tran vdout0_78ck380 FIND v(dout0_78) AT=195.025n

.meas tran vdout0_79ck380 FIND v(dout0_79) AT=195.025n

.meas tran vdout0_80ck380 FIND v(dout0_80) AT=195.025n

.meas tran vdout0_81ck380 FIND v(dout0_81) AT=195.025n

.meas tran vdout0_82ck380 FIND v(dout0_82) AT=195.025n

.meas tran vdout0_83ck380 FIND v(dout0_83) AT=195.025n

.meas tran vdout0_84ck380 FIND v(dout0_84) AT=195.025n

.meas tran vdout0_85ck380 FIND v(dout0_85) AT=195.025n

.meas tran vdout0_86ck380 FIND v(dout0_86) AT=195.025n

.meas tran vdout0_87ck380 FIND v(dout0_87) AT=195.025n

.meas tran vdout0_88ck380 FIND v(dout0_88) AT=195.025n

.meas tran vdout0_89ck380 FIND v(dout0_89) AT=195.025n

.meas tran vdout0_90ck380 FIND v(dout0_90) AT=195.025n

.meas tran vdout0_91ck380 FIND v(dout0_91) AT=195.025n

.meas tran vdout0_92ck380 FIND v(dout0_92) AT=195.025n

.meas tran vdout0_93ck380 FIND v(dout0_93) AT=195.025n

.meas tran vdout0_94ck380 FIND v(dout0_94) AT=195.025n

.meas tran vdout0_95ck380 FIND v(dout0_95) AT=195.025n

.meas tran vdout0_96ck380 FIND v(dout0_96) AT=195.025n

.meas tran vdout0_97ck380 FIND v(dout0_97) AT=195.025n

.meas tran vdout0_98ck380 FIND v(dout0_98) AT=195.025n

.meas tran vdout0_99ck380 FIND v(dout0_99) AT=195.025n

.meas tran vdout0_100ck380 FIND v(dout0_100) AT=195.025n

.meas tran vdout0_101ck380 FIND v(dout0_101) AT=195.025n

.meas tran vdout0_102ck380 FIND v(dout0_102) AT=195.025n

.meas tran vdout0_103ck380 FIND v(dout0_103) AT=195.025n

.meas tran vdout0_104ck380 FIND v(dout0_104) AT=195.025n

.meas tran vdout0_105ck380 FIND v(dout0_105) AT=195.025n

.meas tran vdout0_106ck380 FIND v(dout0_106) AT=195.025n

.meas tran vdout0_107ck380 FIND v(dout0_107) AT=195.025n

.meas tran vdout0_108ck380 FIND v(dout0_108) AT=195.025n

.meas tran vdout0_109ck380 FIND v(dout0_109) AT=195.025n

.meas tran vdout0_110ck380 FIND v(dout0_110) AT=195.025n

.meas tran vdout0_111ck380 FIND v(dout0_111) AT=195.025n

.meas tran vdout0_112ck380 FIND v(dout0_112) AT=195.025n

.meas tran vdout0_113ck380 FIND v(dout0_113) AT=195.025n

.meas tran vdout0_114ck380 FIND v(dout0_114) AT=195.025n

.meas tran vdout0_115ck380 FIND v(dout0_115) AT=195.025n

.meas tran vdout0_116ck380 FIND v(dout0_116) AT=195.025n

.meas tran vdout0_117ck380 FIND v(dout0_117) AT=195.025n

.meas tran vdout0_118ck380 FIND v(dout0_118) AT=195.025n

.meas tran vdout0_119ck380 FIND v(dout0_119) AT=195.025n

.meas tran vdout0_120ck380 FIND v(dout0_120) AT=195.025n

.meas tran vdout0_121ck380 FIND v(dout0_121) AT=195.025n

.meas tran vdout0_122ck380 FIND v(dout0_122) AT=195.025n

.meas tran vdout0_123ck380 FIND v(dout0_123) AT=195.025n

.meas tran vdout0_124ck380 FIND v(dout0_124) AT=195.025n

.meas tran vdout0_125ck380 FIND v(dout0_125) AT=195.025n

.meas tran vdout0_126ck380 FIND v(dout0_126) AT=195.025n

.meas tran vdout0_127ck380 FIND v(dout0_127) AT=195.025n

.meas tran vdout0_128ck380 FIND v(dout0_128) AT=195.025n

.meas tran vdout0_129ck380 FIND v(dout0_129) AT=195.025n

.meas tran vdout0_130ck380 FIND v(dout0_130) AT=195.025n

.meas tran vdout0_131ck380 FIND v(dout0_131) AT=195.025n

.meas tran vdout0_132ck380 FIND v(dout0_132) AT=195.025n

.meas tran vdout0_133ck380 FIND v(dout0_133) AT=195.025n

.meas tran vdout0_134ck380 FIND v(dout0_134) AT=195.025n

.meas tran vdout0_135ck380 FIND v(dout0_135) AT=195.025n

.meas tran vdout0_136ck380 FIND v(dout0_136) AT=195.025n

.meas tran vdout0_137ck380 FIND v(dout0_137) AT=195.025n

.meas tran vdout0_138ck380 FIND v(dout0_138) AT=195.025n

.meas tran vdout0_139ck380 FIND v(dout0_139) AT=195.025n

.meas tran vdout0_140ck380 FIND v(dout0_140) AT=195.025n

.meas tran vdout0_141ck380 FIND v(dout0_141) AT=195.025n

.meas tran vdout0_142ck380 FIND v(dout0_142) AT=195.025n

.meas tran vdout0_143ck380 FIND v(dout0_143) AT=195.025n

.meas tran vdout0_144ck380 FIND v(dout0_144) AT=195.025n

.meas tran vdout0_145ck380 FIND v(dout0_145) AT=195.025n

.meas tran vdout0_146ck380 FIND v(dout0_146) AT=195.025n

.meas tran vdout0_147ck380 FIND v(dout0_147) AT=195.025n

.meas tran vdout0_148ck380 FIND v(dout0_148) AT=195.025n

.meas tran vdout0_149ck380 FIND v(dout0_149) AT=195.025n

.meas tran vdout0_150ck380 FIND v(dout0_150) AT=195.025n

.meas tran vdout0_151ck380 FIND v(dout0_151) AT=195.025n

.meas tran vdout0_152ck380 FIND v(dout0_152) AT=195.025n

.meas tran vdout0_153ck380 FIND v(dout0_153) AT=195.025n

.meas tran vdout0_154ck380 FIND v(dout0_154) AT=195.025n

.meas tran vdout0_155ck380 FIND v(dout0_155) AT=195.025n

.meas tran vdout0_156ck380 FIND v(dout0_156) AT=195.025n

.meas tran vdout0_157ck380 FIND v(dout0_157) AT=195.025n

.meas tran vdout0_158ck380 FIND v(dout0_158) AT=195.025n

.meas tran vdout0_159ck380 FIND v(dout0_159) AT=195.025n

.meas tran vdout0_160ck380 FIND v(dout0_160) AT=195.025n

.meas tran vdout0_161ck380 FIND v(dout0_161) AT=195.025n

.meas tran vdout0_162ck380 FIND v(dout0_162) AT=195.025n

.meas tran vdout0_163ck380 FIND v(dout0_163) AT=195.025n

.meas tran vdout0_164ck380 FIND v(dout0_164) AT=195.025n

.meas tran vdout0_165ck380 FIND v(dout0_165) AT=195.025n

.meas tran vdout0_166ck380 FIND v(dout0_166) AT=195.025n

.meas tran vdout0_167ck380 FIND v(dout0_167) AT=195.025n

.meas tran vdout0_168ck380 FIND v(dout0_168) AT=195.025n

.meas tran vdout0_169ck380 FIND v(dout0_169) AT=195.025n

.meas tran vdout0_170ck380 FIND v(dout0_170) AT=195.025n

.meas tran vdout0_171ck380 FIND v(dout0_171) AT=195.025n

.meas tran vdout0_172ck380 FIND v(dout0_172) AT=195.025n

.meas tran vdout0_173ck380 FIND v(dout0_173) AT=195.025n

.meas tran vdout0_174ck380 FIND v(dout0_174) AT=195.025n

.meas tran vdout0_175ck380 FIND v(dout0_175) AT=195.025n

.meas tran vdout0_176ck380 FIND v(dout0_176) AT=195.025n

.meas tran vdout0_177ck380 FIND v(dout0_177) AT=195.025n

.meas tran vdout0_178ck380 FIND v(dout0_178) AT=195.025n

.meas tran vdout0_179ck380 FIND v(dout0_179) AT=195.025n

.meas tran vdout0_180ck380 FIND v(dout0_180) AT=195.025n

.meas tran vdout0_181ck380 FIND v(dout0_181) AT=195.025n

.meas tran vdout0_182ck380 FIND v(dout0_182) AT=195.025n

.meas tran vdout0_183ck380 FIND v(dout0_183) AT=195.025n

.meas tran vdout0_184ck380 FIND v(dout0_184) AT=195.025n

.meas tran vdout0_185ck380 FIND v(dout0_185) AT=195.025n

.meas tran vdout0_186ck380 FIND v(dout0_186) AT=195.025n

.meas tran vdout0_187ck380 FIND v(dout0_187) AT=195.025n

.meas tran vdout0_188ck380 FIND v(dout0_188) AT=195.025n

.meas tran vdout0_189ck380 FIND v(dout0_189) AT=195.025n

.meas tran vdout0_190ck380 FIND v(dout0_190) AT=195.025n

.meas tran vdout0_191ck380 FIND v(dout0_191) AT=195.025n

.meas tran vdout0_192ck380 FIND v(dout0_192) AT=195.025n

.meas tran vdout0_193ck380 FIND v(dout0_193) AT=195.025n

.meas tran vdout0_194ck380 FIND v(dout0_194) AT=195.025n

.meas tran vdout0_195ck380 FIND v(dout0_195) AT=195.025n

.meas tran vdout0_196ck380 FIND v(dout0_196) AT=195.025n

.meas tran vdout0_197ck380 FIND v(dout0_197) AT=195.025n

.meas tran vdout0_198ck380 FIND v(dout0_198) AT=195.025n

.meas tran vdout0_199ck380 FIND v(dout0_199) AT=195.025n

.meas tran vdout0_200ck380 FIND v(dout0_200) AT=195.025n

.meas tran vdout0_201ck380 FIND v(dout0_201) AT=195.025n

.meas tran vdout0_202ck380 FIND v(dout0_202) AT=195.025n

.meas tran vdout0_203ck380 FIND v(dout0_203) AT=195.025n

.meas tran vdout0_204ck380 FIND v(dout0_204) AT=195.025n

.meas tran vdout0_205ck380 FIND v(dout0_205) AT=195.025n

.meas tran vdout0_206ck380 FIND v(dout0_206) AT=195.025n

.meas tran vdout0_207ck380 FIND v(dout0_207) AT=195.025n

.meas tran vdout0_208ck380 FIND v(dout0_208) AT=195.025n

.meas tran vdout0_209ck380 FIND v(dout0_209) AT=195.025n

.meas tran vdout0_210ck380 FIND v(dout0_210) AT=195.025n

.meas tran vdout0_211ck380 FIND v(dout0_211) AT=195.025n

.meas tran vdout0_212ck380 FIND v(dout0_212) AT=195.025n

.meas tran vdout0_213ck380 FIND v(dout0_213) AT=195.025n

.meas tran vdout0_214ck380 FIND v(dout0_214) AT=195.025n

.meas tran vdout0_215ck380 FIND v(dout0_215) AT=195.025n

.meas tran vdout0_216ck380 FIND v(dout0_216) AT=195.025n

.meas tran vdout0_217ck380 FIND v(dout0_217) AT=195.025n

.meas tran vdout0_218ck380 FIND v(dout0_218) AT=195.025n

.meas tran vdout0_219ck380 FIND v(dout0_219) AT=195.025n

.meas tran vdout0_220ck380 FIND v(dout0_220) AT=195.025n

.meas tran vdout0_221ck380 FIND v(dout0_221) AT=195.025n

.meas tran vdout0_222ck380 FIND v(dout0_222) AT=195.025n

.meas tran vdout0_223ck380 FIND v(dout0_223) AT=195.025n

.meas tran vdout0_224ck380 FIND v(dout0_224) AT=195.025n

.meas tran vdout0_225ck380 FIND v(dout0_225) AT=195.025n

.meas tran vdout0_226ck380 FIND v(dout0_226) AT=195.025n

.meas tran vdout0_227ck380 FIND v(dout0_227) AT=195.025n

.meas tran vdout0_228ck380 FIND v(dout0_228) AT=195.025n

.meas tran vdout0_229ck380 FIND v(dout0_229) AT=195.025n

.meas tran vdout0_230ck380 FIND v(dout0_230) AT=195.025n

.meas tran vdout0_231ck380 FIND v(dout0_231) AT=195.025n

.meas tran vdout0_232ck380 FIND v(dout0_232) AT=195.025n

.meas tran vdout0_233ck380 FIND v(dout0_233) AT=195.025n

.meas tran vdout0_234ck380 FIND v(dout0_234) AT=195.025n

.meas tran vdout0_235ck380 FIND v(dout0_235) AT=195.025n

.meas tran vdout0_236ck380 FIND v(dout0_236) AT=195.025n

.meas tran vdout0_237ck380 FIND v(dout0_237) AT=195.025n

.meas tran vdout0_238ck380 FIND v(dout0_238) AT=195.025n

.meas tran vdout0_239ck380 FIND v(dout0_239) AT=195.025n

.meas tran vdout0_240ck380 FIND v(dout0_240) AT=195.025n

.meas tran vdout0_241ck380 FIND v(dout0_241) AT=195.025n

.meas tran vdout0_242ck380 FIND v(dout0_242) AT=195.025n

.meas tran vdout0_243ck380 FIND v(dout0_243) AT=195.025n

.meas tran vdout0_244ck380 FIND v(dout0_244) AT=195.025n

.meas tran vdout0_245ck380 FIND v(dout0_245) AT=195.025n

.meas tran vdout0_246ck380 FIND v(dout0_246) AT=195.025n

.meas tran vdout0_247ck380 FIND v(dout0_247) AT=195.025n

.meas tran vdout0_248ck380 FIND v(dout0_248) AT=195.025n

.meas tran vdout0_249ck380 FIND v(dout0_249) AT=195.025n

.meas tran vdout0_250ck380 FIND v(dout0_250) AT=195.025n

.meas tran vdout0_251ck380 FIND v(dout0_251) AT=195.025n

.meas tran vdout0_252ck380 FIND v(dout0_252) AT=195.025n

.meas tran vdout0_253ck380 FIND v(dout0_253) AT=195.025n

.meas tran vdout0_254ck380 FIND v(dout0_254) AT=195.025n

.meas tran vdout0_255ck380 FIND v(dout0_255) AT=195.025n

.meas tran vdout0_0ck410 FIND v(dout0_0) AT=210.025n

.meas tran vdout0_1ck410 FIND v(dout0_1) AT=210.025n

.meas tran vdout0_2ck410 FIND v(dout0_2) AT=210.025n

.meas tran vdout0_3ck410 FIND v(dout0_3) AT=210.025n

.meas tran vdout0_4ck410 FIND v(dout0_4) AT=210.025n

.meas tran vdout0_5ck410 FIND v(dout0_5) AT=210.025n

.meas tran vdout0_6ck410 FIND v(dout0_6) AT=210.025n

.meas tran vdout0_7ck410 FIND v(dout0_7) AT=210.025n

.meas tran vdout0_8ck410 FIND v(dout0_8) AT=210.025n

.meas tran vdout0_9ck410 FIND v(dout0_9) AT=210.025n

.meas tran vdout0_10ck410 FIND v(dout0_10) AT=210.025n

.meas tran vdout0_11ck410 FIND v(dout0_11) AT=210.025n

.meas tran vdout0_12ck410 FIND v(dout0_12) AT=210.025n

.meas tran vdout0_13ck410 FIND v(dout0_13) AT=210.025n

.meas tran vdout0_14ck410 FIND v(dout0_14) AT=210.025n

.meas tran vdout0_15ck410 FIND v(dout0_15) AT=210.025n

.meas tran vdout0_16ck410 FIND v(dout0_16) AT=210.025n

.meas tran vdout0_17ck410 FIND v(dout0_17) AT=210.025n

.meas tran vdout0_18ck410 FIND v(dout0_18) AT=210.025n

.meas tran vdout0_19ck410 FIND v(dout0_19) AT=210.025n

.meas tran vdout0_20ck410 FIND v(dout0_20) AT=210.025n

.meas tran vdout0_21ck410 FIND v(dout0_21) AT=210.025n

.meas tran vdout0_22ck410 FIND v(dout0_22) AT=210.025n

.meas tran vdout0_23ck410 FIND v(dout0_23) AT=210.025n

.meas tran vdout0_24ck410 FIND v(dout0_24) AT=210.025n

.meas tran vdout0_25ck410 FIND v(dout0_25) AT=210.025n

.meas tran vdout0_26ck410 FIND v(dout0_26) AT=210.025n

.meas tran vdout0_27ck410 FIND v(dout0_27) AT=210.025n

.meas tran vdout0_28ck410 FIND v(dout0_28) AT=210.025n

.meas tran vdout0_29ck410 FIND v(dout0_29) AT=210.025n

.meas tran vdout0_30ck410 FIND v(dout0_30) AT=210.025n

.meas tran vdout0_31ck410 FIND v(dout0_31) AT=210.025n

.meas tran vdout0_32ck410 FIND v(dout0_32) AT=210.025n

.meas tran vdout0_33ck410 FIND v(dout0_33) AT=210.025n

.meas tran vdout0_34ck410 FIND v(dout0_34) AT=210.025n

.meas tran vdout0_35ck410 FIND v(dout0_35) AT=210.025n

.meas tran vdout0_36ck410 FIND v(dout0_36) AT=210.025n

.meas tran vdout0_37ck410 FIND v(dout0_37) AT=210.025n

.meas tran vdout0_38ck410 FIND v(dout0_38) AT=210.025n

.meas tran vdout0_39ck410 FIND v(dout0_39) AT=210.025n

.meas tran vdout0_40ck410 FIND v(dout0_40) AT=210.025n

.meas tran vdout0_41ck410 FIND v(dout0_41) AT=210.025n

.meas tran vdout0_42ck410 FIND v(dout0_42) AT=210.025n

.meas tran vdout0_43ck410 FIND v(dout0_43) AT=210.025n

.meas tran vdout0_44ck410 FIND v(dout0_44) AT=210.025n

.meas tran vdout0_45ck410 FIND v(dout0_45) AT=210.025n

.meas tran vdout0_46ck410 FIND v(dout0_46) AT=210.025n

.meas tran vdout0_47ck410 FIND v(dout0_47) AT=210.025n

.meas tran vdout0_48ck410 FIND v(dout0_48) AT=210.025n

.meas tran vdout0_49ck410 FIND v(dout0_49) AT=210.025n

.meas tran vdout0_50ck410 FIND v(dout0_50) AT=210.025n

.meas tran vdout0_51ck410 FIND v(dout0_51) AT=210.025n

.meas tran vdout0_52ck410 FIND v(dout0_52) AT=210.025n

.meas tran vdout0_53ck410 FIND v(dout0_53) AT=210.025n

.meas tran vdout0_54ck410 FIND v(dout0_54) AT=210.025n

.meas tran vdout0_55ck410 FIND v(dout0_55) AT=210.025n

.meas tran vdout0_56ck410 FIND v(dout0_56) AT=210.025n

.meas tran vdout0_57ck410 FIND v(dout0_57) AT=210.025n

.meas tran vdout0_58ck410 FIND v(dout0_58) AT=210.025n

.meas tran vdout0_59ck410 FIND v(dout0_59) AT=210.025n

.meas tran vdout0_60ck410 FIND v(dout0_60) AT=210.025n

.meas tran vdout0_61ck410 FIND v(dout0_61) AT=210.025n

.meas tran vdout0_62ck410 FIND v(dout0_62) AT=210.025n

.meas tran vdout0_63ck410 FIND v(dout0_63) AT=210.025n

.meas tran vdout0_64ck410 FIND v(dout0_64) AT=210.025n

.meas tran vdout0_65ck410 FIND v(dout0_65) AT=210.025n

.meas tran vdout0_66ck410 FIND v(dout0_66) AT=210.025n

.meas tran vdout0_67ck410 FIND v(dout0_67) AT=210.025n

.meas tran vdout0_68ck410 FIND v(dout0_68) AT=210.025n

.meas tran vdout0_69ck410 FIND v(dout0_69) AT=210.025n

.meas tran vdout0_70ck410 FIND v(dout0_70) AT=210.025n

.meas tran vdout0_71ck410 FIND v(dout0_71) AT=210.025n

.meas tran vdout0_72ck410 FIND v(dout0_72) AT=210.025n

.meas tran vdout0_73ck410 FIND v(dout0_73) AT=210.025n

.meas tran vdout0_74ck410 FIND v(dout0_74) AT=210.025n

.meas tran vdout0_75ck410 FIND v(dout0_75) AT=210.025n

.meas tran vdout0_76ck410 FIND v(dout0_76) AT=210.025n

.meas tran vdout0_77ck410 FIND v(dout0_77) AT=210.025n

.meas tran vdout0_78ck410 FIND v(dout0_78) AT=210.025n

.meas tran vdout0_79ck410 FIND v(dout0_79) AT=210.025n

.meas tran vdout0_80ck410 FIND v(dout0_80) AT=210.025n

.meas tran vdout0_81ck410 FIND v(dout0_81) AT=210.025n

.meas tran vdout0_82ck410 FIND v(dout0_82) AT=210.025n

.meas tran vdout0_83ck410 FIND v(dout0_83) AT=210.025n

.meas tran vdout0_84ck410 FIND v(dout0_84) AT=210.025n

.meas tran vdout0_85ck410 FIND v(dout0_85) AT=210.025n

.meas tran vdout0_86ck410 FIND v(dout0_86) AT=210.025n

.meas tran vdout0_87ck410 FIND v(dout0_87) AT=210.025n

.meas tran vdout0_88ck410 FIND v(dout0_88) AT=210.025n

.meas tran vdout0_89ck410 FIND v(dout0_89) AT=210.025n

.meas tran vdout0_90ck410 FIND v(dout0_90) AT=210.025n

.meas tran vdout0_91ck410 FIND v(dout0_91) AT=210.025n

.meas tran vdout0_92ck410 FIND v(dout0_92) AT=210.025n

.meas tran vdout0_93ck410 FIND v(dout0_93) AT=210.025n

.meas tran vdout0_94ck410 FIND v(dout0_94) AT=210.025n

.meas tran vdout0_95ck410 FIND v(dout0_95) AT=210.025n

.meas tran vdout0_96ck410 FIND v(dout0_96) AT=210.025n

.meas tran vdout0_97ck410 FIND v(dout0_97) AT=210.025n

.meas tran vdout0_98ck410 FIND v(dout0_98) AT=210.025n

.meas tran vdout0_99ck410 FIND v(dout0_99) AT=210.025n

.meas tran vdout0_100ck410 FIND v(dout0_100) AT=210.025n

.meas tran vdout0_101ck410 FIND v(dout0_101) AT=210.025n

.meas tran vdout0_102ck410 FIND v(dout0_102) AT=210.025n

.meas tran vdout0_103ck410 FIND v(dout0_103) AT=210.025n

.meas tran vdout0_104ck410 FIND v(dout0_104) AT=210.025n

.meas tran vdout0_105ck410 FIND v(dout0_105) AT=210.025n

.meas tran vdout0_106ck410 FIND v(dout0_106) AT=210.025n

.meas tran vdout0_107ck410 FIND v(dout0_107) AT=210.025n

.meas tran vdout0_108ck410 FIND v(dout0_108) AT=210.025n

.meas tran vdout0_109ck410 FIND v(dout0_109) AT=210.025n

.meas tran vdout0_110ck410 FIND v(dout0_110) AT=210.025n

.meas tran vdout0_111ck410 FIND v(dout0_111) AT=210.025n

.meas tran vdout0_112ck410 FIND v(dout0_112) AT=210.025n

.meas tran vdout0_113ck410 FIND v(dout0_113) AT=210.025n

.meas tran vdout0_114ck410 FIND v(dout0_114) AT=210.025n

.meas tran vdout0_115ck410 FIND v(dout0_115) AT=210.025n

.meas tran vdout0_116ck410 FIND v(dout0_116) AT=210.025n

.meas tran vdout0_117ck410 FIND v(dout0_117) AT=210.025n

.meas tran vdout0_118ck410 FIND v(dout0_118) AT=210.025n

.meas tran vdout0_119ck410 FIND v(dout0_119) AT=210.025n

.meas tran vdout0_120ck410 FIND v(dout0_120) AT=210.025n

.meas tran vdout0_121ck410 FIND v(dout0_121) AT=210.025n

.meas tran vdout0_122ck410 FIND v(dout0_122) AT=210.025n

.meas tran vdout0_123ck410 FIND v(dout0_123) AT=210.025n

.meas tran vdout0_124ck410 FIND v(dout0_124) AT=210.025n

.meas tran vdout0_125ck410 FIND v(dout0_125) AT=210.025n

.meas tran vdout0_126ck410 FIND v(dout0_126) AT=210.025n

.meas tran vdout0_127ck410 FIND v(dout0_127) AT=210.025n

.meas tran vdout0_128ck410 FIND v(dout0_128) AT=210.025n

.meas tran vdout0_129ck410 FIND v(dout0_129) AT=210.025n

.meas tran vdout0_130ck410 FIND v(dout0_130) AT=210.025n

.meas tran vdout0_131ck410 FIND v(dout0_131) AT=210.025n

.meas tran vdout0_132ck410 FIND v(dout0_132) AT=210.025n

.meas tran vdout0_133ck410 FIND v(dout0_133) AT=210.025n

.meas tran vdout0_134ck410 FIND v(dout0_134) AT=210.025n

.meas tran vdout0_135ck410 FIND v(dout0_135) AT=210.025n

.meas tran vdout0_136ck410 FIND v(dout0_136) AT=210.025n

.meas tran vdout0_137ck410 FIND v(dout0_137) AT=210.025n

.meas tran vdout0_138ck410 FIND v(dout0_138) AT=210.025n

.meas tran vdout0_139ck410 FIND v(dout0_139) AT=210.025n

.meas tran vdout0_140ck410 FIND v(dout0_140) AT=210.025n

.meas tran vdout0_141ck410 FIND v(dout0_141) AT=210.025n

.meas tran vdout0_142ck410 FIND v(dout0_142) AT=210.025n

.meas tran vdout0_143ck410 FIND v(dout0_143) AT=210.025n

.meas tran vdout0_144ck410 FIND v(dout0_144) AT=210.025n

.meas tran vdout0_145ck410 FIND v(dout0_145) AT=210.025n

.meas tran vdout0_146ck410 FIND v(dout0_146) AT=210.025n

.meas tran vdout0_147ck410 FIND v(dout0_147) AT=210.025n

.meas tran vdout0_148ck410 FIND v(dout0_148) AT=210.025n

.meas tran vdout0_149ck410 FIND v(dout0_149) AT=210.025n

.meas tran vdout0_150ck410 FIND v(dout0_150) AT=210.025n

.meas tran vdout0_151ck410 FIND v(dout0_151) AT=210.025n

.meas tran vdout0_152ck410 FIND v(dout0_152) AT=210.025n

.meas tran vdout0_153ck410 FIND v(dout0_153) AT=210.025n

.meas tran vdout0_154ck410 FIND v(dout0_154) AT=210.025n

.meas tran vdout0_155ck410 FIND v(dout0_155) AT=210.025n

.meas tran vdout0_156ck410 FIND v(dout0_156) AT=210.025n

.meas tran vdout0_157ck410 FIND v(dout0_157) AT=210.025n

.meas tran vdout0_158ck410 FIND v(dout0_158) AT=210.025n

.meas tran vdout0_159ck410 FIND v(dout0_159) AT=210.025n

.meas tran vdout0_160ck410 FIND v(dout0_160) AT=210.025n

.meas tran vdout0_161ck410 FIND v(dout0_161) AT=210.025n

.meas tran vdout0_162ck410 FIND v(dout0_162) AT=210.025n

.meas tran vdout0_163ck410 FIND v(dout0_163) AT=210.025n

.meas tran vdout0_164ck410 FIND v(dout0_164) AT=210.025n

.meas tran vdout0_165ck410 FIND v(dout0_165) AT=210.025n

.meas tran vdout0_166ck410 FIND v(dout0_166) AT=210.025n

.meas tran vdout0_167ck410 FIND v(dout0_167) AT=210.025n

.meas tran vdout0_168ck410 FIND v(dout0_168) AT=210.025n

.meas tran vdout0_169ck410 FIND v(dout0_169) AT=210.025n

.meas tran vdout0_170ck410 FIND v(dout0_170) AT=210.025n

.meas tran vdout0_171ck410 FIND v(dout0_171) AT=210.025n

.meas tran vdout0_172ck410 FIND v(dout0_172) AT=210.025n

.meas tran vdout0_173ck410 FIND v(dout0_173) AT=210.025n

.meas tran vdout0_174ck410 FIND v(dout0_174) AT=210.025n

.meas tran vdout0_175ck410 FIND v(dout0_175) AT=210.025n

.meas tran vdout0_176ck410 FIND v(dout0_176) AT=210.025n

.meas tran vdout0_177ck410 FIND v(dout0_177) AT=210.025n

.meas tran vdout0_178ck410 FIND v(dout0_178) AT=210.025n

.meas tran vdout0_179ck410 FIND v(dout0_179) AT=210.025n

.meas tran vdout0_180ck410 FIND v(dout0_180) AT=210.025n

.meas tran vdout0_181ck410 FIND v(dout0_181) AT=210.025n

.meas tran vdout0_182ck410 FIND v(dout0_182) AT=210.025n

.meas tran vdout0_183ck410 FIND v(dout0_183) AT=210.025n

.meas tran vdout0_184ck410 FIND v(dout0_184) AT=210.025n

.meas tran vdout0_185ck410 FIND v(dout0_185) AT=210.025n

.meas tran vdout0_186ck410 FIND v(dout0_186) AT=210.025n

.meas tran vdout0_187ck410 FIND v(dout0_187) AT=210.025n

.meas tran vdout0_188ck410 FIND v(dout0_188) AT=210.025n

.meas tran vdout0_189ck410 FIND v(dout0_189) AT=210.025n

.meas tran vdout0_190ck410 FIND v(dout0_190) AT=210.025n

.meas tran vdout0_191ck410 FIND v(dout0_191) AT=210.025n

.meas tran vdout0_192ck410 FIND v(dout0_192) AT=210.025n

.meas tran vdout0_193ck410 FIND v(dout0_193) AT=210.025n

.meas tran vdout0_194ck410 FIND v(dout0_194) AT=210.025n

.meas tran vdout0_195ck410 FIND v(dout0_195) AT=210.025n

.meas tran vdout0_196ck410 FIND v(dout0_196) AT=210.025n

.meas tran vdout0_197ck410 FIND v(dout0_197) AT=210.025n

.meas tran vdout0_198ck410 FIND v(dout0_198) AT=210.025n

.meas tran vdout0_199ck410 FIND v(dout0_199) AT=210.025n

.meas tran vdout0_200ck410 FIND v(dout0_200) AT=210.025n

.meas tran vdout0_201ck410 FIND v(dout0_201) AT=210.025n

.meas tran vdout0_202ck410 FIND v(dout0_202) AT=210.025n

.meas tran vdout0_203ck410 FIND v(dout0_203) AT=210.025n

.meas tran vdout0_204ck410 FIND v(dout0_204) AT=210.025n

.meas tran vdout0_205ck410 FIND v(dout0_205) AT=210.025n

.meas tran vdout0_206ck410 FIND v(dout0_206) AT=210.025n

.meas tran vdout0_207ck410 FIND v(dout0_207) AT=210.025n

.meas tran vdout0_208ck410 FIND v(dout0_208) AT=210.025n

.meas tran vdout0_209ck410 FIND v(dout0_209) AT=210.025n

.meas tran vdout0_210ck410 FIND v(dout0_210) AT=210.025n

.meas tran vdout0_211ck410 FIND v(dout0_211) AT=210.025n

.meas tran vdout0_212ck410 FIND v(dout0_212) AT=210.025n

.meas tran vdout0_213ck410 FIND v(dout0_213) AT=210.025n

.meas tran vdout0_214ck410 FIND v(dout0_214) AT=210.025n

.meas tran vdout0_215ck410 FIND v(dout0_215) AT=210.025n

.meas tran vdout0_216ck410 FIND v(dout0_216) AT=210.025n

.meas tran vdout0_217ck410 FIND v(dout0_217) AT=210.025n

.meas tran vdout0_218ck410 FIND v(dout0_218) AT=210.025n

.meas tran vdout0_219ck410 FIND v(dout0_219) AT=210.025n

.meas tran vdout0_220ck410 FIND v(dout0_220) AT=210.025n

.meas tran vdout0_221ck410 FIND v(dout0_221) AT=210.025n

.meas tran vdout0_222ck410 FIND v(dout0_222) AT=210.025n

.meas tran vdout0_223ck410 FIND v(dout0_223) AT=210.025n

.meas tran vdout0_224ck410 FIND v(dout0_224) AT=210.025n

.meas tran vdout0_225ck410 FIND v(dout0_225) AT=210.025n

.meas tran vdout0_226ck410 FIND v(dout0_226) AT=210.025n

.meas tran vdout0_227ck410 FIND v(dout0_227) AT=210.025n

.meas tran vdout0_228ck410 FIND v(dout0_228) AT=210.025n

.meas tran vdout0_229ck410 FIND v(dout0_229) AT=210.025n

.meas tran vdout0_230ck410 FIND v(dout0_230) AT=210.025n

.meas tran vdout0_231ck410 FIND v(dout0_231) AT=210.025n

.meas tran vdout0_232ck410 FIND v(dout0_232) AT=210.025n

.meas tran vdout0_233ck410 FIND v(dout0_233) AT=210.025n

.meas tran vdout0_234ck410 FIND v(dout0_234) AT=210.025n

.meas tran vdout0_235ck410 FIND v(dout0_235) AT=210.025n

.meas tran vdout0_236ck410 FIND v(dout0_236) AT=210.025n

.meas tran vdout0_237ck410 FIND v(dout0_237) AT=210.025n

.meas tran vdout0_238ck410 FIND v(dout0_238) AT=210.025n

.meas tran vdout0_239ck410 FIND v(dout0_239) AT=210.025n

.meas tran vdout0_240ck410 FIND v(dout0_240) AT=210.025n

.meas tran vdout0_241ck410 FIND v(dout0_241) AT=210.025n

.meas tran vdout0_242ck410 FIND v(dout0_242) AT=210.025n

.meas tran vdout0_243ck410 FIND v(dout0_243) AT=210.025n

.meas tran vdout0_244ck410 FIND v(dout0_244) AT=210.025n

.meas tran vdout0_245ck410 FIND v(dout0_245) AT=210.025n

.meas tran vdout0_246ck410 FIND v(dout0_246) AT=210.025n

.meas tran vdout0_247ck410 FIND v(dout0_247) AT=210.025n

.meas tran vdout0_248ck410 FIND v(dout0_248) AT=210.025n

.meas tran vdout0_249ck410 FIND v(dout0_249) AT=210.025n

.meas tran vdout0_250ck410 FIND v(dout0_250) AT=210.025n

.meas tran vdout0_251ck410 FIND v(dout0_251) AT=210.025n

.meas tran vdout0_252ck410 FIND v(dout0_252) AT=210.025n

.meas tran vdout0_253ck410 FIND v(dout0_253) AT=210.025n

.meas tran vdout0_254ck410 FIND v(dout0_254) AT=210.025n

.meas tran vdout0_255ck410 FIND v(dout0_255) AT=210.025n

.meas tran vdout0_0ck440 FIND v(dout0_0) AT=225.025n

.meas tran vdout0_1ck440 FIND v(dout0_1) AT=225.025n

.meas tran vdout0_2ck440 FIND v(dout0_2) AT=225.025n

.meas tran vdout0_3ck440 FIND v(dout0_3) AT=225.025n

.meas tran vdout0_4ck440 FIND v(dout0_4) AT=225.025n

.meas tran vdout0_5ck440 FIND v(dout0_5) AT=225.025n

.meas tran vdout0_6ck440 FIND v(dout0_6) AT=225.025n

.meas tran vdout0_7ck440 FIND v(dout0_7) AT=225.025n

.meas tran vdout0_8ck440 FIND v(dout0_8) AT=225.025n

.meas tran vdout0_9ck440 FIND v(dout0_9) AT=225.025n

.meas tran vdout0_10ck440 FIND v(dout0_10) AT=225.025n

.meas tran vdout0_11ck440 FIND v(dout0_11) AT=225.025n

.meas tran vdout0_12ck440 FIND v(dout0_12) AT=225.025n

.meas tran vdout0_13ck440 FIND v(dout0_13) AT=225.025n

.meas tran vdout0_14ck440 FIND v(dout0_14) AT=225.025n

.meas tran vdout0_15ck440 FIND v(dout0_15) AT=225.025n

.meas tran vdout0_16ck440 FIND v(dout0_16) AT=225.025n

.meas tran vdout0_17ck440 FIND v(dout0_17) AT=225.025n

.meas tran vdout0_18ck440 FIND v(dout0_18) AT=225.025n

.meas tran vdout0_19ck440 FIND v(dout0_19) AT=225.025n

.meas tran vdout0_20ck440 FIND v(dout0_20) AT=225.025n

.meas tran vdout0_21ck440 FIND v(dout0_21) AT=225.025n

.meas tran vdout0_22ck440 FIND v(dout0_22) AT=225.025n

.meas tran vdout0_23ck440 FIND v(dout0_23) AT=225.025n

.meas tran vdout0_24ck440 FIND v(dout0_24) AT=225.025n

.meas tran vdout0_25ck440 FIND v(dout0_25) AT=225.025n

.meas tran vdout0_26ck440 FIND v(dout0_26) AT=225.025n

.meas tran vdout0_27ck440 FIND v(dout0_27) AT=225.025n

.meas tran vdout0_28ck440 FIND v(dout0_28) AT=225.025n

.meas tran vdout0_29ck440 FIND v(dout0_29) AT=225.025n

.meas tran vdout0_30ck440 FIND v(dout0_30) AT=225.025n

.meas tran vdout0_31ck440 FIND v(dout0_31) AT=225.025n

.meas tran vdout0_32ck440 FIND v(dout0_32) AT=225.025n

.meas tran vdout0_33ck440 FIND v(dout0_33) AT=225.025n

.meas tran vdout0_34ck440 FIND v(dout0_34) AT=225.025n

.meas tran vdout0_35ck440 FIND v(dout0_35) AT=225.025n

.meas tran vdout0_36ck440 FIND v(dout0_36) AT=225.025n

.meas tran vdout0_37ck440 FIND v(dout0_37) AT=225.025n

.meas tran vdout0_38ck440 FIND v(dout0_38) AT=225.025n

.meas tran vdout0_39ck440 FIND v(dout0_39) AT=225.025n

.meas tran vdout0_40ck440 FIND v(dout0_40) AT=225.025n

.meas tran vdout0_41ck440 FIND v(dout0_41) AT=225.025n

.meas tran vdout0_42ck440 FIND v(dout0_42) AT=225.025n

.meas tran vdout0_43ck440 FIND v(dout0_43) AT=225.025n

.meas tran vdout0_44ck440 FIND v(dout0_44) AT=225.025n

.meas tran vdout0_45ck440 FIND v(dout0_45) AT=225.025n

.meas tran vdout0_46ck440 FIND v(dout0_46) AT=225.025n

.meas tran vdout0_47ck440 FIND v(dout0_47) AT=225.025n

.meas tran vdout0_48ck440 FIND v(dout0_48) AT=225.025n

.meas tran vdout0_49ck440 FIND v(dout0_49) AT=225.025n

.meas tran vdout0_50ck440 FIND v(dout0_50) AT=225.025n

.meas tran vdout0_51ck440 FIND v(dout0_51) AT=225.025n

.meas tran vdout0_52ck440 FIND v(dout0_52) AT=225.025n

.meas tran vdout0_53ck440 FIND v(dout0_53) AT=225.025n

.meas tran vdout0_54ck440 FIND v(dout0_54) AT=225.025n

.meas tran vdout0_55ck440 FIND v(dout0_55) AT=225.025n

.meas tran vdout0_56ck440 FIND v(dout0_56) AT=225.025n

.meas tran vdout0_57ck440 FIND v(dout0_57) AT=225.025n

.meas tran vdout0_58ck440 FIND v(dout0_58) AT=225.025n

.meas tran vdout0_59ck440 FIND v(dout0_59) AT=225.025n

.meas tran vdout0_60ck440 FIND v(dout0_60) AT=225.025n

.meas tran vdout0_61ck440 FIND v(dout0_61) AT=225.025n

.meas tran vdout0_62ck440 FIND v(dout0_62) AT=225.025n

.meas tran vdout0_63ck440 FIND v(dout0_63) AT=225.025n

.meas tran vdout0_64ck440 FIND v(dout0_64) AT=225.025n

.meas tran vdout0_65ck440 FIND v(dout0_65) AT=225.025n

.meas tran vdout0_66ck440 FIND v(dout0_66) AT=225.025n

.meas tran vdout0_67ck440 FIND v(dout0_67) AT=225.025n

.meas tran vdout0_68ck440 FIND v(dout0_68) AT=225.025n

.meas tran vdout0_69ck440 FIND v(dout0_69) AT=225.025n

.meas tran vdout0_70ck440 FIND v(dout0_70) AT=225.025n

.meas tran vdout0_71ck440 FIND v(dout0_71) AT=225.025n

.meas tran vdout0_72ck440 FIND v(dout0_72) AT=225.025n

.meas tran vdout0_73ck440 FIND v(dout0_73) AT=225.025n

.meas tran vdout0_74ck440 FIND v(dout0_74) AT=225.025n

.meas tran vdout0_75ck440 FIND v(dout0_75) AT=225.025n

.meas tran vdout0_76ck440 FIND v(dout0_76) AT=225.025n

.meas tran vdout0_77ck440 FIND v(dout0_77) AT=225.025n

.meas tran vdout0_78ck440 FIND v(dout0_78) AT=225.025n

.meas tran vdout0_79ck440 FIND v(dout0_79) AT=225.025n

.meas tran vdout0_80ck440 FIND v(dout0_80) AT=225.025n

.meas tran vdout0_81ck440 FIND v(dout0_81) AT=225.025n

.meas tran vdout0_82ck440 FIND v(dout0_82) AT=225.025n

.meas tran vdout0_83ck440 FIND v(dout0_83) AT=225.025n

.meas tran vdout0_84ck440 FIND v(dout0_84) AT=225.025n

.meas tran vdout0_85ck440 FIND v(dout0_85) AT=225.025n

.meas tran vdout0_86ck440 FIND v(dout0_86) AT=225.025n

.meas tran vdout0_87ck440 FIND v(dout0_87) AT=225.025n

.meas tran vdout0_88ck440 FIND v(dout0_88) AT=225.025n

.meas tran vdout0_89ck440 FIND v(dout0_89) AT=225.025n

.meas tran vdout0_90ck440 FIND v(dout0_90) AT=225.025n

.meas tran vdout0_91ck440 FIND v(dout0_91) AT=225.025n

.meas tran vdout0_92ck440 FIND v(dout0_92) AT=225.025n

.meas tran vdout0_93ck440 FIND v(dout0_93) AT=225.025n

.meas tran vdout0_94ck440 FIND v(dout0_94) AT=225.025n

.meas tran vdout0_95ck440 FIND v(dout0_95) AT=225.025n

.meas tran vdout0_96ck440 FIND v(dout0_96) AT=225.025n

.meas tran vdout0_97ck440 FIND v(dout0_97) AT=225.025n

.meas tran vdout0_98ck440 FIND v(dout0_98) AT=225.025n

.meas tran vdout0_99ck440 FIND v(dout0_99) AT=225.025n

.meas tran vdout0_100ck440 FIND v(dout0_100) AT=225.025n

.meas tran vdout0_101ck440 FIND v(dout0_101) AT=225.025n

.meas tran vdout0_102ck440 FIND v(dout0_102) AT=225.025n

.meas tran vdout0_103ck440 FIND v(dout0_103) AT=225.025n

.meas tran vdout0_104ck440 FIND v(dout0_104) AT=225.025n

.meas tran vdout0_105ck440 FIND v(dout0_105) AT=225.025n

.meas tran vdout0_106ck440 FIND v(dout0_106) AT=225.025n

.meas tran vdout0_107ck440 FIND v(dout0_107) AT=225.025n

.meas tran vdout0_108ck440 FIND v(dout0_108) AT=225.025n

.meas tran vdout0_109ck440 FIND v(dout0_109) AT=225.025n

.meas tran vdout0_110ck440 FIND v(dout0_110) AT=225.025n

.meas tran vdout0_111ck440 FIND v(dout0_111) AT=225.025n

.meas tran vdout0_112ck440 FIND v(dout0_112) AT=225.025n

.meas tran vdout0_113ck440 FIND v(dout0_113) AT=225.025n

.meas tran vdout0_114ck440 FIND v(dout0_114) AT=225.025n

.meas tran vdout0_115ck440 FIND v(dout0_115) AT=225.025n

.meas tran vdout0_116ck440 FIND v(dout0_116) AT=225.025n

.meas tran vdout0_117ck440 FIND v(dout0_117) AT=225.025n

.meas tran vdout0_118ck440 FIND v(dout0_118) AT=225.025n

.meas tran vdout0_119ck440 FIND v(dout0_119) AT=225.025n

.meas tran vdout0_120ck440 FIND v(dout0_120) AT=225.025n

.meas tran vdout0_121ck440 FIND v(dout0_121) AT=225.025n

.meas tran vdout0_122ck440 FIND v(dout0_122) AT=225.025n

.meas tran vdout0_123ck440 FIND v(dout0_123) AT=225.025n

.meas tran vdout0_124ck440 FIND v(dout0_124) AT=225.025n

.meas tran vdout0_125ck440 FIND v(dout0_125) AT=225.025n

.meas tran vdout0_126ck440 FIND v(dout0_126) AT=225.025n

.meas tran vdout0_127ck440 FIND v(dout0_127) AT=225.025n

.meas tran vdout0_128ck440 FIND v(dout0_128) AT=225.025n

.meas tran vdout0_129ck440 FIND v(dout0_129) AT=225.025n

.meas tran vdout0_130ck440 FIND v(dout0_130) AT=225.025n

.meas tran vdout0_131ck440 FIND v(dout0_131) AT=225.025n

.meas tran vdout0_132ck440 FIND v(dout0_132) AT=225.025n

.meas tran vdout0_133ck440 FIND v(dout0_133) AT=225.025n

.meas tran vdout0_134ck440 FIND v(dout0_134) AT=225.025n

.meas tran vdout0_135ck440 FIND v(dout0_135) AT=225.025n

.meas tran vdout0_136ck440 FIND v(dout0_136) AT=225.025n

.meas tran vdout0_137ck440 FIND v(dout0_137) AT=225.025n

.meas tran vdout0_138ck440 FIND v(dout0_138) AT=225.025n

.meas tran vdout0_139ck440 FIND v(dout0_139) AT=225.025n

.meas tran vdout0_140ck440 FIND v(dout0_140) AT=225.025n

.meas tran vdout0_141ck440 FIND v(dout0_141) AT=225.025n

.meas tran vdout0_142ck440 FIND v(dout0_142) AT=225.025n

.meas tran vdout0_143ck440 FIND v(dout0_143) AT=225.025n

.meas tran vdout0_144ck440 FIND v(dout0_144) AT=225.025n

.meas tran vdout0_145ck440 FIND v(dout0_145) AT=225.025n

.meas tran vdout0_146ck440 FIND v(dout0_146) AT=225.025n

.meas tran vdout0_147ck440 FIND v(dout0_147) AT=225.025n

.meas tran vdout0_148ck440 FIND v(dout0_148) AT=225.025n

.meas tran vdout0_149ck440 FIND v(dout0_149) AT=225.025n

.meas tran vdout0_150ck440 FIND v(dout0_150) AT=225.025n

.meas tran vdout0_151ck440 FIND v(dout0_151) AT=225.025n

.meas tran vdout0_152ck440 FIND v(dout0_152) AT=225.025n

.meas tran vdout0_153ck440 FIND v(dout0_153) AT=225.025n

.meas tran vdout0_154ck440 FIND v(dout0_154) AT=225.025n

.meas tran vdout0_155ck440 FIND v(dout0_155) AT=225.025n

.meas tran vdout0_156ck440 FIND v(dout0_156) AT=225.025n

.meas tran vdout0_157ck440 FIND v(dout0_157) AT=225.025n

.meas tran vdout0_158ck440 FIND v(dout0_158) AT=225.025n

.meas tran vdout0_159ck440 FIND v(dout0_159) AT=225.025n

.meas tran vdout0_160ck440 FIND v(dout0_160) AT=225.025n

.meas tran vdout0_161ck440 FIND v(dout0_161) AT=225.025n

.meas tran vdout0_162ck440 FIND v(dout0_162) AT=225.025n

.meas tran vdout0_163ck440 FIND v(dout0_163) AT=225.025n

.meas tran vdout0_164ck440 FIND v(dout0_164) AT=225.025n

.meas tran vdout0_165ck440 FIND v(dout0_165) AT=225.025n

.meas tran vdout0_166ck440 FIND v(dout0_166) AT=225.025n

.meas tran vdout0_167ck440 FIND v(dout0_167) AT=225.025n

.meas tran vdout0_168ck440 FIND v(dout0_168) AT=225.025n

.meas tran vdout0_169ck440 FIND v(dout0_169) AT=225.025n

.meas tran vdout0_170ck440 FIND v(dout0_170) AT=225.025n

.meas tran vdout0_171ck440 FIND v(dout0_171) AT=225.025n

.meas tran vdout0_172ck440 FIND v(dout0_172) AT=225.025n

.meas tran vdout0_173ck440 FIND v(dout0_173) AT=225.025n

.meas tran vdout0_174ck440 FIND v(dout0_174) AT=225.025n

.meas tran vdout0_175ck440 FIND v(dout0_175) AT=225.025n

.meas tran vdout0_176ck440 FIND v(dout0_176) AT=225.025n

.meas tran vdout0_177ck440 FIND v(dout0_177) AT=225.025n

.meas tran vdout0_178ck440 FIND v(dout0_178) AT=225.025n

.meas tran vdout0_179ck440 FIND v(dout0_179) AT=225.025n

.meas tran vdout0_180ck440 FIND v(dout0_180) AT=225.025n

.meas tran vdout0_181ck440 FIND v(dout0_181) AT=225.025n

.meas tran vdout0_182ck440 FIND v(dout0_182) AT=225.025n

.meas tran vdout0_183ck440 FIND v(dout0_183) AT=225.025n

.meas tran vdout0_184ck440 FIND v(dout0_184) AT=225.025n

.meas tran vdout0_185ck440 FIND v(dout0_185) AT=225.025n

.meas tran vdout0_186ck440 FIND v(dout0_186) AT=225.025n

.meas tran vdout0_187ck440 FIND v(dout0_187) AT=225.025n

.meas tran vdout0_188ck440 FIND v(dout0_188) AT=225.025n

.meas tran vdout0_189ck440 FIND v(dout0_189) AT=225.025n

.meas tran vdout0_190ck440 FIND v(dout0_190) AT=225.025n

.meas tran vdout0_191ck440 FIND v(dout0_191) AT=225.025n

.meas tran vdout0_192ck440 FIND v(dout0_192) AT=225.025n

.meas tran vdout0_193ck440 FIND v(dout0_193) AT=225.025n

.meas tran vdout0_194ck440 FIND v(dout0_194) AT=225.025n

.meas tran vdout0_195ck440 FIND v(dout0_195) AT=225.025n

.meas tran vdout0_196ck440 FIND v(dout0_196) AT=225.025n

.meas tran vdout0_197ck440 FIND v(dout0_197) AT=225.025n

.meas tran vdout0_198ck440 FIND v(dout0_198) AT=225.025n

.meas tran vdout0_199ck440 FIND v(dout0_199) AT=225.025n

.meas tran vdout0_200ck440 FIND v(dout0_200) AT=225.025n

.meas tran vdout0_201ck440 FIND v(dout0_201) AT=225.025n

.meas tran vdout0_202ck440 FIND v(dout0_202) AT=225.025n

.meas tran vdout0_203ck440 FIND v(dout0_203) AT=225.025n

.meas tran vdout0_204ck440 FIND v(dout0_204) AT=225.025n

.meas tran vdout0_205ck440 FIND v(dout0_205) AT=225.025n

.meas tran vdout0_206ck440 FIND v(dout0_206) AT=225.025n

.meas tran vdout0_207ck440 FIND v(dout0_207) AT=225.025n

.meas tran vdout0_208ck440 FIND v(dout0_208) AT=225.025n

.meas tran vdout0_209ck440 FIND v(dout0_209) AT=225.025n

.meas tran vdout0_210ck440 FIND v(dout0_210) AT=225.025n

.meas tran vdout0_211ck440 FIND v(dout0_211) AT=225.025n

.meas tran vdout0_212ck440 FIND v(dout0_212) AT=225.025n

.meas tran vdout0_213ck440 FIND v(dout0_213) AT=225.025n

.meas tran vdout0_214ck440 FIND v(dout0_214) AT=225.025n

.meas tran vdout0_215ck440 FIND v(dout0_215) AT=225.025n

.meas tran vdout0_216ck440 FIND v(dout0_216) AT=225.025n

.meas tran vdout0_217ck440 FIND v(dout0_217) AT=225.025n

.meas tran vdout0_218ck440 FIND v(dout0_218) AT=225.025n

.meas tran vdout0_219ck440 FIND v(dout0_219) AT=225.025n

.meas tran vdout0_220ck440 FIND v(dout0_220) AT=225.025n

.meas tran vdout0_221ck440 FIND v(dout0_221) AT=225.025n

.meas tran vdout0_222ck440 FIND v(dout0_222) AT=225.025n

.meas tran vdout0_223ck440 FIND v(dout0_223) AT=225.025n

.meas tran vdout0_224ck440 FIND v(dout0_224) AT=225.025n

.meas tran vdout0_225ck440 FIND v(dout0_225) AT=225.025n

.meas tran vdout0_226ck440 FIND v(dout0_226) AT=225.025n

.meas tran vdout0_227ck440 FIND v(dout0_227) AT=225.025n

.meas tran vdout0_228ck440 FIND v(dout0_228) AT=225.025n

.meas tran vdout0_229ck440 FIND v(dout0_229) AT=225.025n

.meas tran vdout0_230ck440 FIND v(dout0_230) AT=225.025n

.meas tran vdout0_231ck440 FIND v(dout0_231) AT=225.025n

.meas tran vdout0_232ck440 FIND v(dout0_232) AT=225.025n

.meas tran vdout0_233ck440 FIND v(dout0_233) AT=225.025n

.meas tran vdout0_234ck440 FIND v(dout0_234) AT=225.025n

.meas tran vdout0_235ck440 FIND v(dout0_235) AT=225.025n

.meas tran vdout0_236ck440 FIND v(dout0_236) AT=225.025n

.meas tran vdout0_237ck440 FIND v(dout0_237) AT=225.025n

.meas tran vdout0_238ck440 FIND v(dout0_238) AT=225.025n

.meas tran vdout0_239ck440 FIND v(dout0_239) AT=225.025n

.meas tran vdout0_240ck440 FIND v(dout0_240) AT=225.025n

.meas tran vdout0_241ck440 FIND v(dout0_241) AT=225.025n

.meas tran vdout0_242ck440 FIND v(dout0_242) AT=225.025n

.meas tran vdout0_243ck440 FIND v(dout0_243) AT=225.025n

.meas tran vdout0_244ck440 FIND v(dout0_244) AT=225.025n

.meas tran vdout0_245ck440 FIND v(dout0_245) AT=225.025n

.meas tran vdout0_246ck440 FIND v(dout0_246) AT=225.025n

.meas tran vdout0_247ck440 FIND v(dout0_247) AT=225.025n

.meas tran vdout0_248ck440 FIND v(dout0_248) AT=225.025n

.meas tran vdout0_249ck440 FIND v(dout0_249) AT=225.025n

.meas tran vdout0_250ck440 FIND v(dout0_250) AT=225.025n

.meas tran vdout0_251ck440 FIND v(dout0_251) AT=225.025n

.meas tran vdout0_252ck440 FIND v(dout0_252) AT=225.025n

.meas tran vdout0_253ck440 FIND v(dout0_253) AT=225.025n

.meas tran vdout0_254ck440 FIND v(dout0_254) AT=225.025n

.meas tran vdout0_255ck440 FIND v(dout0_255) AT=225.025n

.meas tran vdout0_0ck470 FIND v(dout0_0) AT=240.025n

.meas tran vdout0_1ck470 FIND v(dout0_1) AT=240.025n

.meas tran vdout0_2ck470 FIND v(dout0_2) AT=240.025n

.meas tran vdout0_3ck470 FIND v(dout0_3) AT=240.025n

.meas tran vdout0_4ck470 FIND v(dout0_4) AT=240.025n

.meas tran vdout0_5ck470 FIND v(dout0_5) AT=240.025n

.meas tran vdout0_6ck470 FIND v(dout0_6) AT=240.025n

.meas tran vdout0_7ck470 FIND v(dout0_7) AT=240.025n

.meas tran vdout0_8ck470 FIND v(dout0_8) AT=240.025n

.meas tran vdout0_9ck470 FIND v(dout0_9) AT=240.025n

.meas tran vdout0_10ck470 FIND v(dout0_10) AT=240.025n

.meas tran vdout0_11ck470 FIND v(dout0_11) AT=240.025n

.meas tran vdout0_12ck470 FIND v(dout0_12) AT=240.025n

.meas tran vdout0_13ck470 FIND v(dout0_13) AT=240.025n

.meas tran vdout0_14ck470 FIND v(dout0_14) AT=240.025n

.meas tran vdout0_15ck470 FIND v(dout0_15) AT=240.025n

.meas tran vdout0_16ck470 FIND v(dout0_16) AT=240.025n

.meas tran vdout0_17ck470 FIND v(dout0_17) AT=240.025n

.meas tran vdout0_18ck470 FIND v(dout0_18) AT=240.025n

.meas tran vdout0_19ck470 FIND v(dout0_19) AT=240.025n

.meas tran vdout0_20ck470 FIND v(dout0_20) AT=240.025n

.meas tran vdout0_21ck470 FIND v(dout0_21) AT=240.025n

.meas tran vdout0_22ck470 FIND v(dout0_22) AT=240.025n

.meas tran vdout0_23ck470 FIND v(dout0_23) AT=240.025n

.meas tran vdout0_24ck470 FIND v(dout0_24) AT=240.025n

.meas tran vdout0_25ck470 FIND v(dout0_25) AT=240.025n

.meas tran vdout0_26ck470 FIND v(dout0_26) AT=240.025n

.meas tran vdout0_27ck470 FIND v(dout0_27) AT=240.025n

.meas tran vdout0_28ck470 FIND v(dout0_28) AT=240.025n

.meas tran vdout0_29ck470 FIND v(dout0_29) AT=240.025n

.meas tran vdout0_30ck470 FIND v(dout0_30) AT=240.025n

.meas tran vdout0_31ck470 FIND v(dout0_31) AT=240.025n

.meas tran vdout0_32ck470 FIND v(dout0_32) AT=240.025n

.meas tran vdout0_33ck470 FIND v(dout0_33) AT=240.025n

.meas tran vdout0_34ck470 FIND v(dout0_34) AT=240.025n

.meas tran vdout0_35ck470 FIND v(dout0_35) AT=240.025n

.meas tran vdout0_36ck470 FIND v(dout0_36) AT=240.025n

.meas tran vdout0_37ck470 FIND v(dout0_37) AT=240.025n

.meas tran vdout0_38ck470 FIND v(dout0_38) AT=240.025n

.meas tran vdout0_39ck470 FIND v(dout0_39) AT=240.025n

.meas tran vdout0_40ck470 FIND v(dout0_40) AT=240.025n

.meas tran vdout0_41ck470 FIND v(dout0_41) AT=240.025n

.meas tran vdout0_42ck470 FIND v(dout0_42) AT=240.025n

.meas tran vdout0_43ck470 FIND v(dout0_43) AT=240.025n

.meas tran vdout0_44ck470 FIND v(dout0_44) AT=240.025n

.meas tran vdout0_45ck470 FIND v(dout0_45) AT=240.025n

.meas tran vdout0_46ck470 FIND v(dout0_46) AT=240.025n

.meas tran vdout0_47ck470 FIND v(dout0_47) AT=240.025n

.meas tran vdout0_48ck470 FIND v(dout0_48) AT=240.025n

.meas tran vdout0_49ck470 FIND v(dout0_49) AT=240.025n

.meas tran vdout0_50ck470 FIND v(dout0_50) AT=240.025n

.meas tran vdout0_51ck470 FIND v(dout0_51) AT=240.025n

.meas tran vdout0_52ck470 FIND v(dout0_52) AT=240.025n

.meas tran vdout0_53ck470 FIND v(dout0_53) AT=240.025n

.meas tran vdout0_54ck470 FIND v(dout0_54) AT=240.025n

.meas tran vdout0_55ck470 FIND v(dout0_55) AT=240.025n

.meas tran vdout0_56ck470 FIND v(dout0_56) AT=240.025n

.meas tran vdout0_57ck470 FIND v(dout0_57) AT=240.025n

.meas tran vdout0_58ck470 FIND v(dout0_58) AT=240.025n

.meas tran vdout0_59ck470 FIND v(dout0_59) AT=240.025n

.meas tran vdout0_60ck470 FIND v(dout0_60) AT=240.025n

.meas tran vdout0_61ck470 FIND v(dout0_61) AT=240.025n

.meas tran vdout0_62ck470 FIND v(dout0_62) AT=240.025n

.meas tran vdout0_63ck470 FIND v(dout0_63) AT=240.025n

.meas tran vdout0_64ck470 FIND v(dout0_64) AT=240.025n

.meas tran vdout0_65ck470 FIND v(dout0_65) AT=240.025n

.meas tran vdout0_66ck470 FIND v(dout0_66) AT=240.025n

.meas tran vdout0_67ck470 FIND v(dout0_67) AT=240.025n

.meas tran vdout0_68ck470 FIND v(dout0_68) AT=240.025n

.meas tran vdout0_69ck470 FIND v(dout0_69) AT=240.025n

.meas tran vdout0_70ck470 FIND v(dout0_70) AT=240.025n

.meas tran vdout0_71ck470 FIND v(dout0_71) AT=240.025n

.meas tran vdout0_72ck470 FIND v(dout0_72) AT=240.025n

.meas tran vdout0_73ck470 FIND v(dout0_73) AT=240.025n

.meas tran vdout0_74ck470 FIND v(dout0_74) AT=240.025n

.meas tran vdout0_75ck470 FIND v(dout0_75) AT=240.025n

.meas tran vdout0_76ck470 FIND v(dout0_76) AT=240.025n

.meas tran vdout0_77ck470 FIND v(dout0_77) AT=240.025n

.meas tran vdout0_78ck470 FIND v(dout0_78) AT=240.025n

.meas tran vdout0_79ck470 FIND v(dout0_79) AT=240.025n

.meas tran vdout0_80ck470 FIND v(dout0_80) AT=240.025n

.meas tran vdout0_81ck470 FIND v(dout0_81) AT=240.025n

.meas tran vdout0_82ck470 FIND v(dout0_82) AT=240.025n

.meas tran vdout0_83ck470 FIND v(dout0_83) AT=240.025n

.meas tran vdout0_84ck470 FIND v(dout0_84) AT=240.025n

.meas tran vdout0_85ck470 FIND v(dout0_85) AT=240.025n

.meas tran vdout0_86ck470 FIND v(dout0_86) AT=240.025n

.meas tran vdout0_87ck470 FIND v(dout0_87) AT=240.025n

.meas tran vdout0_88ck470 FIND v(dout0_88) AT=240.025n

.meas tran vdout0_89ck470 FIND v(dout0_89) AT=240.025n

.meas tran vdout0_90ck470 FIND v(dout0_90) AT=240.025n

.meas tran vdout0_91ck470 FIND v(dout0_91) AT=240.025n

.meas tran vdout0_92ck470 FIND v(dout0_92) AT=240.025n

.meas tran vdout0_93ck470 FIND v(dout0_93) AT=240.025n

.meas tran vdout0_94ck470 FIND v(dout0_94) AT=240.025n

.meas tran vdout0_95ck470 FIND v(dout0_95) AT=240.025n

.meas tran vdout0_96ck470 FIND v(dout0_96) AT=240.025n

.meas tran vdout0_97ck470 FIND v(dout0_97) AT=240.025n

.meas tran vdout0_98ck470 FIND v(dout0_98) AT=240.025n

.meas tran vdout0_99ck470 FIND v(dout0_99) AT=240.025n

.meas tran vdout0_100ck470 FIND v(dout0_100) AT=240.025n

.meas tran vdout0_101ck470 FIND v(dout0_101) AT=240.025n

.meas tran vdout0_102ck470 FIND v(dout0_102) AT=240.025n

.meas tran vdout0_103ck470 FIND v(dout0_103) AT=240.025n

.meas tran vdout0_104ck470 FIND v(dout0_104) AT=240.025n

.meas tran vdout0_105ck470 FIND v(dout0_105) AT=240.025n

.meas tran vdout0_106ck470 FIND v(dout0_106) AT=240.025n

.meas tran vdout0_107ck470 FIND v(dout0_107) AT=240.025n

.meas tran vdout0_108ck470 FIND v(dout0_108) AT=240.025n

.meas tran vdout0_109ck470 FIND v(dout0_109) AT=240.025n

.meas tran vdout0_110ck470 FIND v(dout0_110) AT=240.025n

.meas tran vdout0_111ck470 FIND v(dout0_111) AT=240.025n

.meas tran vdout0_112ck470 FIND v(dout0_112) AT=240.025n

.meas tran vdout0_113ck470 FIND v(dout0_113) AT=240.025n

.meas tran vdout0_114ck470 FIND v(dout0_114) AT=240.025n

.meas tran vdout0_115ck470 FIND v(dout0_115) AT=240.025n

.meas tran vdout0_116ck470 FIND v(dout0_116) AT=240.025n

.meas tran vdout0_117ck470 FIND v(dout0_117) AT=240.025n

.meas tran vdout0_118ck470 FIND v(dout0_118) AT=240.025n

.meas tran vdout0_119ck470 FIND v(dout0_119) AT=240.025n

.meas tran vdout0_120ck470 FIND v(dout0_120) AT=240.025n

.meas tran vdout0_121ck470 FIND v(dout0_121) AT=240.025n

.meas tran vdout0_122ck470 FIND v(dout0_122) AT=240.025n

.meas tran vdout0_123ck470 FIND v(dout0_123) AT=240.025n

.meas tran vdout0_124ck470 FIND v(dout0_124) AT=240.025n

.meas tran vdout0_125ck470 FIND v(dout0_125) AT=240.025n

.meas tran vdout0_126ck470 FIND v(dout0_126) AT=240.025n

.meas tran vdout0_127ck470 FIND v(dout0_127) AT=240.025n

.meas tran vdout0_128ck470 FIND v(dout0_128) AT=240.025n

.meas tran vdout0_129ck470 FIND v(dout0_129) AT=240.025n

.meas tran vdout0_130ck470 FIND v(dout0_130) AT=240.025n

.meas tran vdout0_131ck470 FIND v(dout0_131) AT=240.025n

.meas tran vdout0_132ck470 FIND v(dout0_132) AT=240.025n

.meas tran vdout0_133ck470 FIND v(dout0_133) AT=240.025n

.meas tran vdout0_134ck470 FIND v(dout0_134) AT=240.025n

.meas tran vdout0_135ck470 FIND v(dout0_135) AT=240.025n

.meas tran vdout0_136ck470 FIND v(dout0_136) AT=240.025n

.meas tran vdout0_137ck470 FIND v(dout0_137) AT=240.025n

.meas tran vdout0_138ck470 FIND v(dout0_138) AT=240.025n

.meas tran vdout0_139ck470 FIND v(dout0_139) AT=240.025n

.meas tran vdout0_140ck470 FIND v(dout0_140) AT=240.025n

.meas tran vdout0_141ck470 FIND v(dout0_141) AT=240.025n

.meas tran vdout0_142ck470 FIND v(dout0_142) AT=240.025n

.meas tran vdout0_143ck470 FIND v(dout0_143) AT=240.025n

.meas tran vdout0_144ck470 FIND v(dout0_144) AT=240.025n

.meas tran vdout0_145ck470 FIND v(dout0_145) AT=240.025n

.meas tran vdout0_146ck470 FIND v(dout0_146) AT=240.025n

.meas tran vdout0_147ck470 FIND v(dout0_147) AT=240.025n

.meas tran vdout0_148ck470 FIND v(dout0_148) AT=240.025n

.meas tran vdout0_149ck470 FIND v(dout0_149) AT=240.025n

.meas tran vdout0_150ck470 FIND v(dout0_150) AT=240.025n

.meas tran vdout0_151ck470 FIND v(dout0_151) AT=240.025n

.meas tran vdout0_152ck470 FIND v(dout0_152) AT=240.025n

.meas tran vdout0_153ck470 FIND v(dout0_153) AT=240.025n

.meas tran vdout0_154ck470 FIND v(dout0_154) AT=240.025n

.meas tran vdout0_155ck470 FIND v(dout0_155) AT=240.025n

.meas tran vdout0_156ck470 FIND v(dout0_156) AT=240.025n

.meas tran vdout0_157ck470 FIND v(dout0_157) AT=240.025n

.meas tran vdout0_158ck470 FIND v(dout0_158) AT=240.025n

.meas tran vdout0_159ck470 FIND v(dout0_159) AT=240.025n

.meas tran vdout0_160ck470 FIND v(dout0_160) AT=240.025n

.meas tran vdout0_161ck470 FIND v(dout0_161) AT=240.025n

.meas tran vdout0_162ck470 FIND v(dout0_162) AT=240.025n

.meas tran vdout0_163ck470 FIND v(dout0_163) AT=240.025n

.meas tran vdout0_164ck470 FIND v(dout0_164) AT=240.025n

.meas tran vdout0_165ck470 FIND v(dout0_165) AT=240.025n

.meas tran vdout0_166ck470 FIND v(dout0_166) AT=240.025n

.meas tran vdout0_167ck470 FIND v(dout0_167) AT=240.025n

.meas tran vdout0_168ck470 FIND v(dout0_168) AT=240.025n

.meas tran vdout0_169ck470 FIND v(dout0_169) AT=240.025n

.meas tran vdout0_170ck470 FIND v(dout0_170) AT=240.025n

.meas tran vdout0_171ck470 FIND v(dout0_171) AT=240.025n

.meas tran vdout0_172ck470 FIND v(dout0_172) AT=240.025n

.meas tran vdout0_173ck470 FIND v(dout0_173) AT=240.025n

.meas tran vdout0_174ck470 FIND v(dout0_174) AT=240.025n

.meas tran vdout0_175ck470 FIND v(dout0_175) AT=240.025n

.meas tran vdout0_176ck470 FIND v(dout0_176) AT=240.025n

.meas tran vdout0_177ck470 FIND v(dout0_177) AT=240.025n

.meas tran vdout0_178ck470 FIND v(dout0_178) AT=240.025n

.meas tran vdout0_179ck470 FIND v(dout0_179) AT=240.025n

.meas tran vdout0_180ck470 FIND v(dout0_180) AT=240.025n

.meas tran vdout0_181ck470 FIND v(dout0_181) AT=240.025n

.meas tran vdout0_182ck470 FIND v(dout0_182) AT=240.025n

.meas tran vdout0_183ck470 FIND v(dout0_183) AT=240.025n

.meas tran vdout0_184ck470 FIND v(dout0_184) AT=240.025n

.meas tran vdout0_185ck470 FIND v(dout0_185) AT=240.025n

.meas tran vdout0_186ck470 FIND v(dout0_186) AT=240.025n

.meas tran vdout0_187ck470 FIND v(dout0_187) AT=240.025n

.meas tran vdout0_188ck470 FIND v(dout0_188) AT=240.025n

.meas tran vdout0_189ck470 FIND v(dout0_189) AT=240.025n

.meas tran vdout0_190ck470 FIND v(dout0_190) AT=240.025n

.meas tran vdout0_191ck470 FIND v(dout0_191) AT=240.025n

.meas tran vdout0_192ck470 FIND v(dout0_192) AT=240.025n

.meas tran vdout0_193ck470 FIND v(dout0_193) AT=240.025n

.meas tran vdout0_194ck470 FIND v(dout0_194) AT=240.025n

.meas tran vdout0_195ck470 FIND v(dout0_195) AT=240.025n

.meas tran vdout0_196ck470 FIND v(dout0_196) AT=240.025n

.meas tran vdout0_197ck470 FIND v(dout0_197) AT=240.025n

.meas tran vdout0_198ck470 FIND v(dout0_198) AT=240.025n

.meas tran vdout0_199ck470 FIND v(dout0_199) AT=240.025n

.meas tran vdout0_200ck470 FIND v(dout0_200) AT=240.025n

.meas tran vdout0_201ck470 FIND v(dout0_201) AT=240.025n

.meas tran vdout0_202ck470 FIND v(dout0_202) AT=240.025n

.meas tran vdout0_203ck470 FIND v(dout0_203) AT=240.025n

.meas tran vdout0_204ck470 FIND v(dout0_204) AT=240.025n

.meas tran vdout0_205ck470 FIND v(dout0_205) AT=240.025n

.meas tran vdout0_206ck470 FIND v(dout0_206) AT=240.025n

.meas tran vdout0_207ck470 FIND v(dout0_207) AT=240.025n

.meas tran vdout0_208ck470 FIND v(dout0_208) AT=240.025n

.meas tran vdout0_209ck470 FIND v(dout0_209) AT=240.025n

.meas tran vdout0_210ck470 FIND v(dout0_210) AT=240.025n

.meas tran vdout0_211ck470 FIND v(dout0_211) AT=240.025n

.meas tran vdout0_212ck470 FIND v(dout0_212) AT=240.025n

.meas tran vdout0_213ck470 FIND v(dout0_213) AT=240.025n

.meas tran vdout0_214ck470 FIND v(dout0_214) AT=240.025n

.meas tran vdout0_215ck470 FIND v(dout0_215) AT=240.025n

.meas tran vdout0_216ck470 FIND v(dout0_216) AT=240.025n

.meas tran vdout0_217ck470 FIND v(dout0_217) AT=240.025n

.meas tran vdout0_218ck470 FIND v(dout0_218) AT=240.025n

.meas tran vdout0_219ck470 FIND v(dout0_219) AT=240.025n

.meas tran vdout0_220ck470 FIND v(dout0_220) AT=240.025n

.meas tran vdout0_221ck470 FIND v(dout0_221) AT=240.025n

.meas tran vdout0_222ck470 FIND v(dout0_222) AT=240.025n

.meas tran vdout0_223ck470 FIND v(dout0_223) AT=240.025n

.meas tran vdout0_224ck470 FIND v(dout0_224) AT=240.025n

.meas tran vdout0_225ck470 FIND v(dout0_225) AT=240.025n

.meas tran vdout0_226ck470 FIND v(dout0_226) AT=240.025n

.meas tran vdout0_227ck470 FIND v(dout0_227) AT=240.025n

.meas tran vdout0_228ck470 FIND v(dout0_228) AT=240.025n

.meas tran vdout0_229ck470 FIND v(dout0_229) AT=240.025n

.meas tran vdout0_230ck470 FIND v(dout0_230) AT=240.025n

.meas tran vdout0_231ck470 FIND v(dout0_231) AT=240.025n

.meas tran vdout0_232ck470 FIND v(dout0_232) AT=240.025n

.meas tran vdout0_233ck470 FIND v(dout0_233) AT=240.025n

.meas tran vdout0_234ck470 FIND v(dout0_234) AT=240.025n

.meas tran vdout0_235ck470 FIND v(dout0_235) AT=240.025n

.meas tran vdout0_236ck470 FIND v(dout0_236) AT=240.025n

.meas tran vdout0_237ck470 FIND v(dout0_237) AT=240.025n

.meas tran vdout0_238ck470 FIND v(dout0_238) AT=240.025n

.meas tran vdout0_239ck470 FIND v(dout0_239) AT=240.025n

.meas tran vdout0_240ck470 FIND v(dout0_240) AT=240.025n

.meas tran vdout0_241ck470 FIND v(dout0_241) AT=240.025n

.meas tran vdout0_242ck470 FIND v(dout0_242) AT=240.025n

.meas tran vdout0_243ck470 FIND v(dout0_243) AT=240.025n

.meas tran vdout0_244ck470 FIND v(dout0_244) AT=240.025n

.meas tran vdout0_245ck470 FIND v(dout0_245) AT=240.025n

.meas tran vdout0_246ck470 FIND v(dout0_246) AT=240.025n

.meas tran vdout0_247ck470 FIND v(dout0_247) AT=240.025n

.meas tran vdout0_248ck470 FIND v(dout0_248) AT=240.025n

.meas tran vdout0_249ck470 FIND v(dout0_249) AT=240.025n

.meas tran vdout0_250ck470 FIND v(dout0_250) AT=240.025n

.meas tran vdout0_251ck470 FIND v(dout0_251) AT=240.025n

.meas tran vdout0_252ck470 FIND v(dout0_252) AT=240.025n

.meas tran vdout0_253ck470 FIND v(dout0_253) AT=240.025n

.meas tran vdout0_254ck470 FIND v(dout0_254) AT=240.025n

.meas tran vdout0_255ck470 FIND v(dout0_255) AT=240.025n

.meas tran vdout0_0ck590 FIND v(dout0_0) AT=300.025n

.meas tran vdout0_1ck590 FIND v(dout0_1) AT=300.025n

.meas tran vdout0_2ck590 FIND v(dout0_2) AT=300.025n

.meas tran vdout0_3ck590 FIND v(dout0_3) AT=300.025n

.meas tran vdout0_4ck590 FIND v(dout0_4) AT=300.025n

.meas tran vdout0_5ck590 FIND v(dout0_5) AT=300.025n

.meas tran vdout0_6ck590 FIND v(dout0_6) AT=300.025n

.meas tran vdout0_7ck590 FIND v(dout0_7) AT=300.025n

.meas tran vdout0_8ck590 FIND v(dout0_8) AT=300.025n

.meas tran vdout0_9ck590 FIND v(dout0_9) AT=300.025n

.meas tran vdout0_10ck590 FIND v(dout0_10) AT=300.025n

.meas tran vdout0_11ck590 FIND v(dout0_11) AT=300.025n

.meas tran vdout0_12ck590 FIND v(dout0_12) AT=300.025n

.meas tran vdout0_13ck590 FIND v(dout0_13) AT=300.025n

.meas tran vdout0_14ck590 FIND v(dout0_14) AT=300.025n

.meas tran vdout0_15ck590 FIND v(dout0_15) AT=300.025n

.meas tran vdout0_16ck590 FIND v(dout0_16) AT=300.025n

.meas tran vdout0_17ck590 FIND v(dout0_17) AT=300.025n

.meas tran vdout0_18ck590 FIND v(dout0_18) AT=300.025n

.meas tran vdout0_19ck590 FIND v(dout0_19) AT=300.025n

.meas tran vdout0_20ck590 FIND v(dout0_20) AT=300.025n

.meas tran vdout0_21ck590 FIND v(dout0_21) AT=300.025n

.meas tran vdout0_22ck590 FIND v(dout0_22) AT=300.025n

.meas tran vdout0_23ck590 FIND v(dout0_23) AT=300.025n

.meas tran vdout0_24ck590 FIND v(dout0_24) AT=300.025n

.meas tran vdout0_25ck590 FIND v(dout0_25) AT=300.025n

.meas tran vdout0_26ck590 FIND v(dout0_26) AT=300.025n

.meas tran vdout0_27ck590 FIND v(dout0_27) AT=300.025n

.meas tran vdout0_28ck590 FIND v(dout0_28) AT=300.025n

.meas tran vdout0_29ck590 FIND v(dout0_29) AT=300.025n

.meas tran vdout0_30ck590 FIND v(dout0_30) AT=300.025n

.meas tran vdout0_31ck590 FIND v(dout0_31) AT=300.025n

.meas tran vdout0_32ck590 FIND v(dout0_32) AT=300.025n

.meas tran vdout0_33ck590 FIND v(dout0_33) AT=300.025n

.meas tran vdout0_34ck590 FIND v(dout0_34) AT=300.025n

.meas tran vdout0_35ck590 FIND v(dout0_35) AT=300.025n

.meas tran vdout0_36ck590 FIND v(dout0_36) AT=300.025n

.meas tran vdout0_37ck590 FIND v(dout0_37) AT=300.025n

.meas tran vdout0_38ck590 FIND v(dout0_38) AT=300.025n

.meas tran vdout0_39ck590 FIND v(dout0_39) AT=300.025n

.meas tran vdout0_40ck590 FIND v(dout0_40) AT=300.025n

.meas tran vdout0_41ck590 FIND v(dout0_41) AT=300.025n

.meas tran vdout0_42ck590 FIND v(dout0_42) AT=300.025n

.meas tran vdout0_43ck590 FIND v(dout0_43) AT=300.025n

.meas tran vdout0_44ck590 FIND v(dout0_44) AT=300.025n

.meas tran vdout0_45ck590 FIND v(dout0_45) AT=300.025n

.meas tran vdout0_46ck590 FIND v(dout0_46) AT=300.025n

.meas tran vdout0_47ck590 FIND v(dout0_47) AT=300.025n

.meas tran vdout0_48ck590 FIND v(dout0_48) AT=300.025n

.meas tran vdout0_49ck590 FIND v(dout0_49) AT=300.025n

.meas tran vdout0_50ck590 FIND v(dout0_50) AT=300.025n

.meas tran vdout0_51ck590 FIND v(dout0_51) AT=300.025n

.meas tran vdout0_52ck590 FIND v(dout0_52) AT=300.025n

.meas tran vdout0_53ck590 FIND v(dout0_53) AT=300.025n

.meas tran vdout0_54ck590 FIND v(dout0_54) AT=300.025n

.meas tran vdout0_55ck590 FIND v(dout0_55) AT=300.025n

.meas tran vdout0_56ck590 FIND v(dout0_56) AT=300.025n

.meas tran vdout0_57ck590 FIND v(dout0_57) AT=300.025n

.meas tran vdout0_58ck590 FIND v(dout0_58) AT=300.025n

.meas tran vdout0_59ck590 FIND v(dout0_59) AT=300.025n

.meas tran vdout0_60ck590 FIND v(dout0_60) AT=300.025n

.meas tran vdout0_61ck590 FIND v(dout0_61) AT=300.025n

.meas tran vdout0_62ck590 FIND v(dout0_62) AT=300.025n

.meas tran vdout0_63ck590 FIND v(dout0_63) AT=300.025n

.meas tran vdout0_64ck590 FIND v(dout0_64) AT=300.025n

.meas tran vdout0_65ck590 FIND v(dout0_65) AT=300.025n

.meas tran vdout0_66ck590 FIND v(dout0_66) AT=300.025n

.meas tran vdout0_67ck590 FIND v(dout0_67) AT=300.025n

.meas tran vdout0_68ck590 FIND v(dout0_68) AT=300.025n

.meas tran vdout0_69ck590 FIND v(dout0_69) AT=300.025n

.meas tran vdout0_70ck590 FIND v(dout0_70) AT=300.025n

.meas tran vdout0_71ck590 FIND v(dout0_71) AT=300.025n

.meas tran vdout0_72ck590 FIND v(dout0_72) AT=300.025n

.meas tran vdout0_73ck590 FIND v(dout0_73) AT=300.025n

.meas tran vdout0_74ck590 FIND v(dout0_74) AT=300.025n

.meas tran vdout0_75ck590 FIND v(dout0_75) AT=300.025n

.meas tran vdout0_76ck590 FIND v(dout0_76) AT=300.025n

.meas tran vdout0_77ck590 FIND v(dout0_77) AT=300.025n

.meas tran vdout0_78ck590 FIND v(dout0_78) AT=300.025n

.meas tran vdout0_79ck590 FIND v(dout0_79) AT=300.025n

.meas tran vdout0_80ck590 FIND v(dout0_80) AT=300.025n

.meas tran vdout0_81ck590 FIND v(dout0_81) AT=300.025n

.meas tran vdout0_82ck590 FIND v(dout0_82) AT=300.025n

.meas tran vdout0_83ck590 FIND v(dout0_83) AT=300.025n

.meas tran vdout0_84ck590 FIND v(dout0_84) AT=300.025n

.meas tran vdout0_85ck590 FIND v(dout0_85) AT=300.025n

.meas tran vdout0_86ck590 FIND v(dout0_86) AT=300.025n

.meas tran vdout0_87ck590 FIND v(dout0_87) AT=300.025n

.meas tran vdout0_88ck590 FIND v(dout0_88) AT=300.025n

.meas tran vdout0_89ck590 FIND v(dout0_89) AT=300.025n

.meas tran vdout0_90ck590 FIND v(dout0_90) AT=300.025n

.meas tran vdout0_91ck590 FIND v(dout0_91) AT=300.025n

.meas tran vdout0_92ck590 FIND v(dout0_92) AT=300.025n

.meas tran vdout0_93ck590 FIND v(dout0_93) AT=300.025n

.meas tran vdout0_94ck590 FIND v(dout0_94) AT=300.025n

.meas tran vdout0_95ck590 FIND v(dout0_95) AT=300.025n

.meas tran vdout0_96ck590 FIND v(dout0_96) AT=300.025n

.meas tran vdout0_97ck590 FIND v(dout0_97) AT=300.025n

.meas tran vdout0_98ck590 FIND v(dout0_98) AT=300.025n

.meas tran vdout0_99ck590 FIND v(dout0_99) AT=300.025n

.meas tran vdout0_100ck590 FIND v(dout0_100) AT=300.025n

.meas tran vdout0_101ck590 FIND v(dout0_101) AT=300.025n

.meas tran vdout0_102ck590 FIND v(dout0_102) AT=300.025n

.meas tran vdout0_103ck590 FIND v(dout0_103) AT=300.025n

.meas tran vdout0_104ck590 FIND v(dout0_104) AT=300.025n

.meas tran vdout0_105ck590 FIND v(dout0_105) AT=300.025n

.meas tran vdout0_106ck590 FIND v(dout0_106) AT=300.025n

.meas tran vdout0_107ck590 FIND v(dout0_107) AT=300.025n

.meas tran vdout0_108ck590 FIND v(dout0_108) AT=300.025n

.meas tran vdout0_109ck590 FIND v(dout0_109) AT=300.025n

.meas tran vdout0_110ck590 FIND v(dout0_110) AT=300.025n

.meas tran vdout0_111ck590 FIND v(dout0_111) AT=300.025n

.meas tran vdout0_112ck590 FIND v(dout0_112) AT=300.025n

.meas tran vdout0_113ck590 FIND v(dout0_113) AT=300.025n

.meas tran vdout0_114ck590 FIND v(dout0_114) AT=300.025n

.meas tran vdout0_115ck590 FIND v(dout0_115) AT=300.025n

.meas tran vdout0_116ck590 FIND v(dout0_116) AT=300.025n

.meas tran vdout0_117ck590 FIND v(dout0_117) AT=300.025n

.meas tran vdout0_118ck590 FIND v(dout0_118) AT=300.025n

.meas tran vdout0_119ck590 FIND v(dout0_119) AT=300.025n

.meas tran vdout0_120ck590 FIND v(dout0_120) AT=300.025n

.meas tran vdout0_121ck590 FIND v(dout0_121) AT=300.025n

.meas tran vdout0_122ck590 FIND v(dout0_122) AT=300.025n

.meas tran vdout0_123ck590 FIND v(dout0_123) AT=300.025n

.meas tran vdout0_124ck590 FIND v(dout0_124) AT=300.025n

.meas tran vdout0_125ck590 FIND v(dout0_125) AT=300.025n

.meas tran vdout0_126ck590 FIND v(dout0_126) AT=300.025n

.meas tran vdout0_127ck590 FIND v(dout0_127) AT=300.025n

.meas tran vdout0_128ck590 FIND v(dout0_128) AT=300.025n

.meas tran vdout0_129ck590 FIND v(dout0_129) AT=300.025n

.meas tran vdout0_130ck590 FIND v(dout0_130) AT=300.025n

.meas tran vdout0_131ck590 FIND v(dout0_131) AT=300.025n

.meas tran vdout0_132ck590 FIND v(dout0_132) AT=300.025n

.meas tran vdout0_133ck590 FIND v(dout0_133) AT=300.025n

.meas tran vdout0_134ck590 FIND v(dout0_134) AT=300.025n

.meas tran vdout0_135ck590 FIND v(dout0_135) AT=300.025n

.meas tran vdout0_136ck590 FIND v(dout0_136) AT=300.025n

.meas tran vdout0_137ck590 FIND v(dout0_137) AT=300.025n

.meas tran vdout0_138ck590 FIND v(dout0_138) AT=300.025n

.meas tran vdout0_139ck590 FIND v(dout0_139) AT=300.025n

.meas tran vdout0_140ck590 FIND v(dout0_140) AT=300.025n

.meas tran vdout0_141ck590 FIND v(dout0_141) AT=300.025n

.meas tran vdout0_142ck590 FIND v(dout0_142) AT=300.025n

.meas tran vdout0_143ck590 FIND v(dout0_143) AT=300.025n

.meas tran vdout0_144ck590 FIND v(dout0_144) AT=300.025n

.meas tran vdout0_145ck590 FIND v(dout0_145) AT=300.025n

.meas tran vdout0_146ck590 FIND v(dout0_146) AT=300.025n

.meas tran vdout0_147ck590 FIND v(dout0_147) AT=300.025n

.meas tran vdout0_148ck590 FIND v(dout0_148) AT=300.025n

.meas tran vdout0_149ck590 FIND v(dout0_149) AT=300.025n

.meas tran vdout0_150ck590 FIND v(dout0_150) AT=300.025n

.meas tran vdout0_151ck590 FIND v(dout0_151) AT=300.025n

.meas tran vdout0_152ck590 FIND v(dout0_152) AT=300.025n

.meas tran vdout0_153ck590 FIND v(dout0_153) AT=300.025n

.meas tran vdout0_154ck590 FIND v(dout0_154) AT=300.025n

.meas tran vdout0_155ck590 FIND v(dout0_155) AT=300.025n

.meas tran vdout0_156ck590 FIND v(dout0_156) AT=300.025n

.meas tran vdout0_157ck590 FIND v(dout0_157) AT=300.025n

.meas tran vdout0_158ck590 FIND v(dout0_158) AT=300.025n

.meas tran vdout0_159ck590 FIND v(dout0_159) AT=300.025n

.meas tran vdout0_160ck590 FIND v(dout0_160) AT=300.025n

.meas tran vdout0_161ck590 FIND v(dout0_161) AT=300.025n

.meas tran vdout0_162ck590 FIND v(dout0_162) AT=300.025n

.meas tran vdout0_163ck590 FIND v(dout0_163) AT=300.025n

.meas tran vdout0_164ck590 FIND v(dout0_164) AT=300.025n

.meas tran vdout0_165ck590 FIND v(dout0_165) AT=300.025n

.meas tran vdout0_166ck590 FIND v(dout0_166) AT=300.025n

.meas tran vdout0_167ck590 FIND v(dout0_167) AT=300.025n

.meas tran vdout0_168ck590 FIND v(dout0_168) AT=300.025n

.meas tran vdout0_169ck590 FIND v(dout0_169) AT=300.025n

.meas tran vdout0_170ck590 FIND v(dout0_170) AT=300.025n

.meas tran vdout0_171ck590 FIND v(dout0_171) AT=300.025n

.meas tran vdout0_172ck590 FIND v(dout0_172) AT=300.025n

.meas tran vdout0_173ck590 FIND v(dout0_173) AT=300.025n

.meas tran vdout0_174ck590 FIND v(dout0_174) AT=300.025n

.meas tran vdout0_175ck590 FIND v(dout0_175) AT=300.025n

.meas tran vdout0_176ck590 FIND v(dout0_176) AT=300.025n

.meas tran vdout0_177ck590 FIND v(dout0_177) AT=300.025n

.meas tran vdout0_178ck590 FIND v(dout0_178) AT=300.025n

.meas tran vdout0_179ck590 FIND v(dout0_179) AT=300.025n

.meas tran vdout0_180ck590 FIND v(dout0_180) AT=300.025n

.meas tran vdout0_181ck590 FIND v(dout0_181) AT=300.025n

.meas tran vdout0_182ck590 FIND v(dout0_182) AT=300.025n

.meas tran vdout0_183ck590 FIND v(dout0_183) AT=300.025n

.meas tran vdout0_184ck590 FIND v(dout0_184) AT=300.025n

.meas tran vdout0_185ck590 FIND v(dout0_185) AT=300.025n

.meas tran vdout0_186ck590 FIND v(dout0_186) AT=300.025n

.meas tran vdout0_187ck590 FIND v(dout0_187) AT=300.025n

.meas tran vdout0_188ck590 FIND v(dout0_188) AT=300.025n

.meas tran vdout0_189ck590 FIND v(dout0_189) AT=300.025n

.meas tran vdout0_190ck590 FIND v(dout0_190) AT=300.025n

.meas tran vdout0_191ck590 FIND v(dout0_191) AT=300.025n

.meas tran vdout0_192ck590 FIND v(dout0_192) AT=300.025n

.meas tran vdout0_193ck590 FIND v(dout0_193) AT=300.025n

.meas tran vdout0_194ck590 FIND v(dout0_194) AT=300.025n

.meas tran vdout0_195ck590 FIND v(dout0_195) AT=300.025n

.meas tran vdout0_196ck590 FIND v(dout0_196) AT=300.025n

.meas tran vdout0_197ck590 FIND v(dout0_197) AT=300.025n

.meas tran vdout0_198ck590 FIND v(dout0_198) AT=300.025n

.meas tran vdout0_199ck590 FIND v(dout0_199) AT=300.025n

.meas tran vdout0_200ck590 FIND v(dout0_200) AT=300.025n

.meas tran vdout0_201ck590 FIND v(dout0_201) AT=300.025n

.meas tran vdout0_202ck590 FIND v(dout0_202) AT=300.025n

.meas tran vdout0_203ck590 FIND v(dout0_203) AT=300.025n

.meas tran vdout0_204ck590 FIND v(dout0_204) AT=300.025n

.meas tran vdout0_205ck590 FIND v(dout0_205) AT=300.025n

.meas tran vdout0_206ck590 FIND v(dout0_206) AT=300.025n

.meas tran vdout0_207ck590 FIND v(dout0_207) AT=300.025n

.meas tran vdout0_208ck590 FIND v(dout0_208) AT=300.025n

.meas tran vdout0_209ck590 FIND v(dout0_209) AT=300.025n

.meas tran vdout0_210ck590 FIND v(dout0_210) AT=300.025n

.meas tran vdout0_211ck590 FIND v(dout0_211) AT=300.025n

.meas tran vdout0_212ck590 FIND v(dout0_212) AT=300.025n

.meas tran vdout0_213ck590 FIND v(dout0_213) AT=300.025n

.meas tran vdout0_214ck590 FIND v(dout0_214) AT=300.025n

.meas tran vdout0_215ck590 FIND v(dout0_215) AT=300.025n

.meas tran vdout0_216ck590 FIND v(dout0_216) AT=300.025n

.meas tran vdout0_217ck590 FIND v(dout0_217) AT=300.025n

.meas tran vdout0_218ck590 FIND v(dout0_218) AT=300.025n

.meas tran vdout0_219ck590 FIND v(dout0_219) AT=300.025n

.meas tran vdout0_220ck590 FIND v(dout0_220) AT=300.025n

.meas tran vdout0_221ck590 FIND v(dout0_221) AT=300.025n

.meas tran vdout0_222ck590 FIND v(dout0_222) AT=300.025n

.meas tran vdout0_223ck590 FIND v(dout0_223) AT=300.025n

.meas tran vdout0_224ck590 FIND v(dout0_224) AT=300.025n

.meas tran vdout0_225ck590 FIND v(dout0_225) AT=300.025n

.meas tran vdout0_226ck590 FIND v(dout0_226) AT=300.025n

.meas tran vdout0_227ck590 FIND v(dout0_227) AT=300.025n

.meas tran vdout0_228ck590 FIND v(dout0_228) AT=300.025n

.meas tran vdout0_229ck590 FIND v(dout0_229) AT=300.025n

.meas tran vdout0_230ck590 FIND v(dout0_230) AT=300.025n

.meas tran vdout0_231ck590 FIND v(dout0_231) AT=300.025n

.meas tran vdout0_232ck590 FIND v(dout0_232) AT=300.025n

.meas tran vdout0_233ck590 FIND v(dout0_233) AT=300.025n

.meas tran vdout0_234ck590 FIND v(dout0_234) AT=300.025n

.meas tran vdout0_235ck590 FIND v(dout0_235) AT=300.025n

.meas tran vdout0_236ck590 FIND v(dout0_236) AT=300.025n

.meas tran vdout0_237ck590 FIND v(dout0_237) AT=300.025n

.meas tran vdout0_238ck590 FIND v(dout0_238) AT=300.025n

.meas tran vdout0_239ck590 FIND v(dout0_239) AT=300.025n

.meas tran vdout0_240ck590 FIND v(dout0_240) AT=300.025n

.meas tran vdout0_241ck590 FIND v(dout0_241) AT=300.025n

.meas tran vdout0_242ck590 FIND v(dout0_242) AT=300.025n

.meas tran vdout0_243ck590 FIND v(dout0_243) AT=300.025n

.meas tran vdout0_244ck590 FIND v(dout0_244) AT=300.025n

.meas tran vdout0_245ck590 FIND v(dout0_245) AT=300.025n

.meas tran vdout0_246ck590 FIND v(dout0_246) AT=300.025n

.meas tran vdout0_247ck590 FIND v(dout0_247) AT=300.025n

.meas tran vdout0_248ck590 FIND v(dout0_248) AT=300.025n

.meas tran vdout0_249ck590 FIND v(dout0_249) AT=300.025n

.meas tran vdout0_250ck590 FIND v(dout0_250) AT=300.025n

.meas tran vdout0_251ck590 FIND v(dout0_251) AT=300.025n

.meas tran vdout0_252ck590 FIND v(dout0_252) AT=300.025n

.meas tran vdout0_253ck590 FIND v(dout0_253) AT=300.025n

.meas tran vdout0_254ck590 FIND v(dout0_254) AT=300.025n

.meas tran vdout0_255ck590 FIND v(dout0_255) AT=300.025n

.meas tran vdout0_0ck610 FIND v(dout0_0) AT=310.025n

.meas tran vdout0_1ck610 FIND v(dout0_1) AT=310.025n

.meas tran vdout0_2ck610 FIND v(dout0_2) AT=310.025n

.meas tran vdout0_3ck610 FIND v(dout0_3) AT=310.025n

.meas tran vdout0_4ck610 FIND v(dout0_4) AT=310.025n

.meas tran vdout0_5ck610 FIND v(dout0_5) AT=310.025n

.meas tran vdout0_6ck610 FIND v(dout0_6) AT=310.025n

.meas tran vdout0_7ck610 FIND v(dout0_7) AT=310.025n

.meas tran vdout0_8ck610 FIND v(dout0_8) AT=310.025n

.meas tran vdout0_9ck610 FIND v(dout0_9) AT=310.025n

.meas tran vdout0_10ck610 FIND v(dout0_10) AT=310.025n

.meas tran vdout0_11ck610 FIND v(dout0_11) AT=310.025n

.meas tran vdout0_12ck610 FIND v(dout0_12) AT=310.025n

.meas tran vdout0_13ck610 FIND v(dout0_13) AT=310.025n

.meas tran vdout0_14ck610 FIND v(dout0_14) AT=310.025n

.meas tran vdout0_15ck610 FIND v(dout0_15) AT=310.025n

.meas tran vdout0_16ck610 FIND v(dout0_16) AT=310.025n

.meas tran vdout0_17ck610 FIND v(dout0_17) AT=310.025n

.meas tran vdout0_18ck610 FIND v(dout0_18) AT=310.025n

.meas tran vdout0_19ck610 FIND v(dout0_19) AT=310.025n

.meas tran vdout0_20ck610 FIND v(dout0_20) AT=310.025n

.meas tran vdout0_21ck610 FIND v(dout0_21) AT=310.025n

.meas tran vdout0_22ck610 FIND v(dout0_22) AT=310.025n

.meas tran vdout0_23ck610 FIND v(dout0_23) AT=310.025n

.meas tran vdout0_24ck610 FIND v(dout0_24) AT=310.025n

.meas tran vdout0_25ck610 FIND v(dout0_25) AT=310.025n

.meas tran vdout0_26ck610 FIND v(dout0_26) AT=310.025n

.meas tran vdout0_27ck610 FIND v(dout0_27) AT=310.025n

.meas tran vdout0_28ck610 FIND v(dout0_28) AT=310.025n

.meas tran vdout0_29ck610 FIND v(dout0_29) AT=310.025n

.meas tran vdout0_30ck610 FIND v(dout0_30) AT=310.025n

.meas tran vdout0_31ck610 FIND v(dout0_31) AT=310.025n

.meas tran vdout0_32ck610 FIND v(dout0_32) AT=310.025n

.meas tran vdout0_33ck610 FIND v(dout0_33) AT=310.025n

.meas tran vdout0_34ck610 FIND v(dout0_34) AT=310.025n

.meas tran vdout0_35ck610 FIND v(dout0_35) AT=310.025n

.meas tran vdout0_36ck610 FIND v(dout0_36) AT=310.025n

.meas tran vdout0_37ck610 FIND v(dout0_37) AT=310.025n

.meas tran vdout0_38ck610 FIND v(dout0_38) AT=310.025n

.meas tran vdout0_39ck610 FIND v(dout0_39) AT=310.025n

.meas tran vdout0_40ck610 FIND v(dout0_40) AT=310.025n

.meas tran vdout0_41ck610 FIND v(dout0_41) AT=310.025n

.meas tran vdout0_42ck610 FIND v(dout0_42) AT=310.025n

.meas tran vdout0_43ck610 FIND v(dout0_43) AT=310.025n

.meas tran vdout0_44ck610 FIND v(dout0_44) AT=310.025n

.meas tran vdout0_45ck610 FIND v(dout0_45) AT=310.025n

.meas tran vdout0_46ck610 FIND v(dout0_46) AT=310.025n

.meas tran vdout0_47ck610 FIND v(dout0_47) AT=310.025n

.meas tran vdout0_48ck610 FIND v(dout0_48) AT=310.025n

.meas tran vdout0_49ck610 FIND v(dout0_49) AT=310.025n

.meas tran vdout0_50ck610 FIND v(dout0_50) AT=310.025n

.meas tran vdout0_51ck610 FIND v(dout0_51) AT=310.025n

.meas tran vdout0_52ck610 FIND v(dout0_52) AT=310.025n

.meas tran vdout0_53ck610 FIND v(dout0_53) AT=310.025n

.meas tran vdout0_54ck610 FIND v(dout0_54) AT=310.025n

.meas tran vdout0_55ck610 FIND v(dout0_55) AT=310.025n

.meas tran vdout0_56ck610 FIND v(dout0_56) AT=310.025n

.meas tran vdout0_57ck610 FIND v(dout0_57) AT=310.025n

.meas tran vdout0_58ck610 FIND v(dout0_58) AT=310.025n

.meas tran vdout0_59ck610 FIND v(dout0_59) AT=310.025n

.meas tran vdout0_60ck610 FIND v(dout0_60) AT=310.025n

.meas tran vdout0_61ck610 FIND v(dout0_61) AT=310.025n

.meas tran vdout0_62ck610 FIND v(dout0_62) AT=310.025n

.meas tran vdout0_63ck610 FIND v(dout0_63) AT=310.025n

.meas tran vdout0_64ck610 FIND v(dout0_64) AT=310.025n

.meas tran vdout0_65ck610 FIND v(dout0_65) AT=310.025n

.meas tran vdout0_66ck610 FIND v(dout0_66) AT=310.025n

.meas tran vdout0_67ck610 FIND v(dout0_67) AT=310.025n

.meas tran vdout0_68ck610 FIND v(dout0_68) AT=310.025n

.meas tran vdout0_69ck610 FIND v(dout0_69) AT=310.025n

.meas tran vdout0_70ck610 FIND v(dout0_70) AT=310.025n

.meas tran vdout0_71ck610 FIND v(dout0_71) AT=310.025n

.meas tran vdout0_72ck610 FIND v(dout0_72) AT=310.025n

.meas tran vdout0_73ck610 FIND v(dout0_73) AT=310.025n

.meas tran vdout0_74ck610 FIND v(dout0_74) AT=310.025n

.meas tran vdout0_75ck610 FIND v(dout0_75) AT=310.025n

.meas tran vdout0_76ck610 FIND v(dout0_76) AT=310.025n

.meas tran vdout0_77ck610 FIND v(dout0_77) AT=310.025n

.meas tran vdout0_78ck610 FIND v(dout0_78) AT=310.025n

.meas tran vdout0_79ck610 FIND v(dout0_79) AT=310.025n

.meas tran vdout0_80ck610 FIND v(dout0_80) AT=310.025n

.meas tran vdout0_81ck610 FIND v(dout0_81) AT=310.025n

.meas tran vdout0_82ck610 FIND v(dout0_82) AT=310.025n

.meas tran vdout0_83ck610 FIND v(dout0_83) AT=310.025n

.meas tran vdout0_84ck610 FIND v(dout0_84) AT=310.025n

.meas tran vdout0_85ck610 FIND v(dout0_85) AT=310.025n

.meas tran vdout0_86ck610 FIND v(dout0_86) AT=310.025n

.meas tran vdout0_87ck610 FIND v(dout0_87) AT=310.025n

.meas tran vdout0_88ck610 FIND v(dout0_88) AT=310.025n

.meas tran vdout0_89ck610 FIND v(dout0_89) AT=310.025n

.meas tran vdout0_90ck610 FIND v(dout0_90) AT=310.025n

.meas tran vdout0_91ck610 FIND v(dout0_91) AT=310.025n

.meas tran vdout0_92ck610 FIND v(dout0_92) AT=310.025n

.meas tran vdout0_93ck610 FIND v(dout0_93) AT=310.025n

.meas tran vdout0_94ck610 FIND v(dout0_94) AT=310.025n

.meas tran vdout0_95ck610 FIND v(dout0_95) AT=310.025n

.meas tran vdout0_96ck610 FIND v(dout0_96) AT=310.025n

.meas tran vdout0_97ck610 FIND v(dout0_97) AT=310.025n

.meas tran vdout0_98ck610 FIND v(dout0_98) AT=310.025n

.meas tran vdout0_99ck610 FIND v(dout0_99) AT=310.025n

.meas tran vdout0_100ck610 FIND v(dout0_100) AT=310.025n

.meas tran vdout0_101ck610 FIND v(dout0_101) AT=310.025n

.meas tran vdout0_102ck610 FIND v(dout0_102) AT=310.025n

.meas tran vdout0_103ck610 FIND v(dout0_103) AT=310.025n

.meas tran vdout0_104ck610 FIND v(dout0_104) AT=310.025n

.meas tran vdout0_105ck610 FIND v(dout0_105) AT=310.025n

.meas tran vdout0_106ck610 FIND v(dout0_106) AT=310.025n

.meas tran vdout0_107ck610 FIND v(dout0_107) AT=310.025n

.meas tran vdout0_108ck610 FIND v(dout0_108) AT=310.025n

.meas tran vdout0_109ck610 FIND v(dout0_109) AT=310.025n

.meas tran vdout0_110ck610 FIND v(dout0_110) AT=310.025n

.meas tran vdout0_111ck610 FIND v(dout0_111) AT=310.025n

.meas tran vdout0_112ck610 FIND v(dout0_112) AT=310.025n

.meas tran vdout0_113ck610 FIND v(dout0_113) AT=310.025n

.meas tran vdout0_114ck610 FIND v(dout0_114) AT=310.025n

.meas tran vdout0_115ck610 FIND v(dout0_115) AT=310.025n

.meas tran vdout0_116ck610 FIND v(dout0_116) AT=310.025n

.meas tran vdout0_117ck610 FIND v(dout0_117) AT=310.025n

.meas tran vdout0_118ck610 FIND v(dout0_118) AT=310.025n

.meas tran vdout0_119ck610 FIND v(dout0_119) AT=310.025n

.meas tran vdout0_120ck610 FIND v(dout0_120) AT=310.025n

.meas tran vdout0_121ck610 FIND v(dout0_121) AT=310.025n

.meas tran vdout0_122ck610 FIND v(dout0_122) AT=310.025n

.meas tran vdout0_123ck610 FIND v(dout0_123) AT=310.025n

.meas tran vdout0_124ck610 FIND v(dout0_124) AT=310.025n

.meas tran vdout0_125ck610 FIND v(dout0_125) AT=310.025n

.meas tran vdout0_126ck610 FIND v(dout0_126) AT=310.025n

.meas tran vdout0_127ck610 FIND v(dout0_127) AT=310.025n

.meas tran vdout0_128ck610 FIND v(dout0_128) AT=310.025n

.meas tran vdout0_129ck610 FIND v(dout0_129) AT=310.025n

.meas tran vdout0_130ck610 FIND v(dout0_130) AT=310.025n

.meas tran vdout0_131ck610 FIND v(dout0_131) AT=310.025n

.meas tran vdout0_132ck610 FIND v(dout0_132) AT=310.025n

.meas tran vdout0_133ck610 FIND v(dout0_133) AT=310.025n

.meas tran vdout0_134ck610 FIND v(dout0_134) AT=310.025n

.meas tran vdout0_135ck610 FIND v(dout0_135) AT=310.025n

.meas tran vdout0_136ck610 FIND v(dout0_136) AT=310.025n

.meas tran vdout0_137ck610 FIND v(dout0_137) AT=310.025n

.meas tran vdout0_138ck610 FIND v(dout0_138) AT=310.025n

.meas tran vdout0_139ck610 FIND v(dout0_139) AT=310.025n

.meas tran vdout0_140ck610 FIND v(dout0_140) AT=310.025n

.meas tran vdout0_141ck610 FIND v(dout0_141) AT=310.025n

.meas tran vdout0_142ck610 FIND v(dout0_142) AT=310.025n

.meas tran vdout0_143ck610 FIND v(dout0_143) AT=310.025n

.meas tran vdout0_144ck610 FIND v(dout0_144) AT=310.025n

.meas tran vdout0_145ck610 FIND v(dout0_145) AT=310.025n

.meas tran vdout0_146ck610 FIND v(dout0_146) AT=310.025n

.meas tran vdout0_147ck610 FIND v(dout0_147) AT=310.025n

.meas tran vdout0_148ck610 FIND v(dout0_148) AT=310.025n

.meas tran vdout0_149ck610 FIND v(dout0_149) AT=310.025n

.meas tran vdout0_150ck610 FIND v(dout0_150) AT=310.025n

.meas tran vdout0_151ck610 FIND v(dout0_151) AT=310.025n

.meas tran vdout0_152ck610 FIND v(dout0_152) AT=310.025n

.meas tran vdout0_153ck610 FIND v(dout0_153) AT=310.025n

.meas tran vdout0_154ck610 FIND v(dout0_154) AT=310.025n

.meas tran vdout0_155ck610 FIND v(dout0_155) AT=310.025n

.meas tran vdout0_156ck610 FIND v(dout0_156) AT=310.025n

.meas tran vdout0_157ck610 FIND v(dout0_157) AT=310.025n

.meas tran vdout0_158ck610 FIND v(dout0_158) AT=310.025n

.meas tran vdout0_159ck610 FIND v(dout0_159) AT=310.025n

.meas tran vdout0_160ck610 FIND v(dout0_160) AT=310.025n

.meas tran vdout0_161ck610 FIND v(dout0_161) AT=310.025n

.meas tran vdout0_162ck610 FIND v(dout0_162) AT=310.025n

.meas tran vdout0_163ck610 FIND v(dout0_163) AT=310.025n

.meas tran vdout0_164ck610 FIND v(dout0_164) AT=310.025n

.meas tran vdout0_165ck610 FIND v(dout0_165) AT=310.025n

.meas tran vdout0_166ck610 FIND v(dout0_166) AT=310.025n

.meas tran vdout0_167ck610 FIND v(dout0_167) AT=310.025n

.meas tran vdout0_168ck610 FIND v(dout0_168) AT=310.025n

.meas tran vdout0_169ck610 FIND v(dout0_169) AT=310.025n

.meas tran vdout0_170ck610 FIND v(dout0_170) AT=310.025n

.meas tran vdout0_171ck610 FIND v(dout0_171) AT=310.025n

.meas tran vdout0_172ck610 FIND v(dout0_172) AT=310.025n

.meas tran vdout0_173ck610 FIND v(dout0_173) AT=310.025n

.meas tran vdout0_174ck610 FIND v(dout0_174) AT=310.025n

.meas tran vdout0_175ck610 FIND v(dout0_175) AT=310.025n

.meas tran vdout0_176ck610 FIND v(dout0_176) AT=310.025n

.meas tran vdout0_177ck610 FIND v(dout0_177) AT=310.025n

.meas tran vdout0_178ck610 FIND v(dout0_178) AT=310.025n

.meas tran vdout0_179ck610 FIND v(dout0_179) AT=310.025n

.meas tran vdout0_180ck610 FIND v(dout0_180) AT=310.025n

.meas tran vdout0_181ck610 FIND v(dout0_181) AT=310.025n

.meas tran vdout0_182ck610 FIND v(dout0_182) AT=310.025n

.meas tran vdout0_183ck610 FIND v(dout0_183) AT=310.025n

.meas tran vdout0_184ck610 FIND v(dout0_184) AT=310.025n

.meas tran vdout0_185ck610 FIND v(dout0_185) AT=310.025n

.meas tran vdout0_186ck610 FIND v(dout0_186) AT=310.025n

.meas tran vdout0_187ck610 FIND v(dout0_187) AT=310.025n

.meas tran vdout0_188ck610 FIND v(dout0_188) AT=310.025n

.meas tran vdout0_189ck610 FIND v(dout0_189) AT=310.025n

.meas tran vdout0_190ck610 FIND v(dout0_190) AT=310.025n

.meas tran vdout0_191ck610 FIND v(dout0_191) AT=310.025n

.meas tran vdout0_192ck610 FIND v(dout0_192) AT=310.025n

.meas tran vdout0_193ck610 FIND v(dout0_193) AT=310.025n

.meas tran vdout0_194ck610 FIND v(dout0_194) AT=310.025n

.meas tran vdout0_195ck610 FIND v(dout0_195) AT=310.025n

.meas tran vdout0_196ck610 FIND v(dout0_196) AT=310.025n

.meas tran vdout0_197ck610 FIND v(dout0_197) AT=310.025n

.meas tran vdout0_198ck610 FIND v(dout0_198) AT=310.025n

.meas tran vdout0_199ck610 FIND v(dout0_199) AT=310.025n

.meas tran vdout0_200ck610 FIND v(dout0_200) AT=310.025n

.meas tran vdout0_201ck610 FIND v(dout0_201) AT=310.025n

.meas tran vdout0_202ck610 FIND v(dout0_202) AT=310.025n

.meas tran vdout0_203ck610 FIND v(dout0_203) AT=310.025n

.meas tran vdout0_204ck610 FIND v(dout0_204) AT=310.025n

.meas tran vdout0_205ck610 FIND v(dout0_205) AT=310.025n

.meas tran vdout0_206ck610 FIND v(dout0_206) AT=310.025n

.meas tran vdout0_207ck610 FIND v(dout0_207) AT=310.025n

.meas tran vdout0_208ck610 FIND v(dout0_208) AT=310.025n

.meas tran vdout0_209ck610 FIND v(dout0_209) AT=310.025n

.meas tran vdout0_210ck610 FIND v(dout0_210) AT=310.025n

.meas tran vdout0_211ck610 FIND v(dout0_211) AT=310.025n

.meas tran vdout0_212ck610 FIND v(dout0_212) AT=310.025n

.meas tran vdout0_213ck610 FIND v(dout0_213) AT=310.025n

.meas tran vdout0_214ck610 FIND v(dout0_214) AT=310.025n

.meas tran vdout0_215ck610 FIND v(dout0_215) AT=310.025n

.meas tran vdout0_216ck610 FIND v(dout0_216) AT=310.025n

.meas tran vdout0_217ck610 FIND v(dout0_217) AT=310.025n

.meas tran vdout0_218ck610 FIND v(dout0_218) AT=310.025n

.meas tran vdout0_219ck610 FIND v(dout0_219) AT=310.025n

.meas tran vdout0_220ck610 FIND v(dout0_220) AT=310.025n

.meas tran vdout0_221ck610 FIND v(dout0_221) AT=310.025n

.meas tran vdout0_222ck610 FIND v(dout0_222) AT=310.025n

.meas tran vdout0_223ck610 FIND v(dout0_223) AT=310.025n

.meas tran vdout0_224ck610 FIND v(dout0_224) AT=310.025n

.meas tran vdout0_225ck610 FIND v(dout0_225) AT=310.025n

.meas tran vdout0_226ck610 FIND v(dout0_226) AT=310.025n

.meas tran vdout0_227ck610 FIND v(dout0_227) AT=310.025n

.meas tran vdout0_228ck610 FIND v(dout0_228) AT=310.025n

.meas tran vdout0_229ck610 FIND v(dout0_229) AT=310.025n

.meas tran vdout0_230ck610 FIND v(dout0_230) AT=310.025n

.meas tran vdout0_231ck610 FIND v(dout0_231) AT=310.025n

.meas tran vdout0_232ck610 FIND v(dout0_232) AT=310.025n

.meas tran vdout0_233ck610 FIND v(dout0_233) AT=310.025n

.meas tran vdout0_234ck610 FIND v(dout0_234) AT=310.025n

.meas tran vdout0_235ck610 FIND v(dout0_235) AT=310.025n

.meas tran vdout0_236ck610 FIND v(dout0_236) AT=310.025n

.meas tran vdout0_237ck610 FIND v(dout0_237) AT=310.025n

.meas tran vdout0_238ck610 FIND v(dout0_238) AT=310.025n

.meas tran vdout0_239ck610 FIND v(dout0_239) AT=310.025n

.meas tran vdout0_240ck610 FIND v(dout0_240) AT=310.025n

.meas tran vdout0_241ck610 FIND v(dout0_241) AT=310.025n

.meas tran vdout0_242ck610 FIND v(dout0_242) AT=310.025n

.meas tran vdout0_243ck610 FIND v(dout0_243) AT=310.025n

.meas tran vdout0_244ck610 FIND v(dout0_244) AT=310.025n

.meas tran vdout0_245ck610 FIND v(dout0_245) AT=310.025n

.meas tran vdout0_246ck610 FIND v(dout0_246) AT=310.025n

.meas tran vdout0_247ck610 FIND v(dout0_247) AT=310.025n

.meas tran vdout0_248ck610 FIND v(dout0_248) AT=310.025n

.meas tran vdout0_249ck610 FIND v(dout0_249) AT=310.025n

.meas tran vdout0_250ck610 FIND v(dout0_250) AT=310.025n

.meas tran vdout0_251ck610 FIND v(dout0_251) AT=310.025n

.meas tran vdout0_252ck610 FIND v(dout0_252) AT=310.025n

.meas tran vdout0_253ck610 FIND v(dout0_253) AT=310.025n

.meas tran vdout0_254ck610 FIND v(dout0_254) AT=310.025n

.meas tran vdout0_255ck610 FIND v(dout0_255) AT=310.025n

.meas tran vdout0_0ck620 FIND v(dout0_0) AT=315.025n

.meas tran vdout0_1ck620 FIND v(dout0_1) AT=315.025n

.meas tran vdout0_2ck620 FIND v(dout0_2) AT=315.025n

.meas tran vdout0_3ck620 FIND v(dout0_3) AT=315.025n

.meas tran vdout0_4ck620 FIND v(dout0_4) AT=315.025n

.meas tran vdout0_5ck620 FIND v(dout0_5) AT=315.025n

.meas tran vdout0_6ck620 FIND v(dout0_6) AT=315.025n

.meas tran vdout0_7ck620 FIND v(dout0_7) AT=315.025n

.meas tran vdout0_8ck620 FIND v(dout0_8) AT=315.025n

.meas tran vdout0_9ck620 FIND v(dout0_9) AT=315.025n

.meas tran vdout0_10ck620 FIND v(dout0_10) AT=315.025n

.meas tran vdout0_11ck620 FIND v(dout0_11) AT=315.025n

.meas tran vdout0_12ck620 FIND v(dout0_12) AT=315.025n

.meas tran vdout0_13ck620 FIND v(dout0_13) AT=315.025n

.meas tran vdout0_14ck620 FIND v(dout0_14) AT=315.025n

.meas tran vdout0_15ck620 FIND v(dout0_15) AT=315.025n

.meas tran vdout0_16ck620 FIND v(dout0_16) AT=315.025n

.meas tran vdout0_17ck620 FIND v(dout0_17) AT=315.025n

.meas tran vdout0_18ck620 FIND v(dout0_18) AT=315.025n

.meas tran vdout0_19ck620 FIND v(dout0_19) AT=315.025n

.meas tran vdout0_20ck620 FIND v(dout0_20) AT=315.025n

.meas tran vdout0_21ck620 FIND v(dout0_21) AT=315.025n

.meas tran vdout0_22ck620 FIND v(dout0_22) AT=315.025n

.meas tran vdout0_23ck620 FIND v(dout0_23) AT=315.025n

.meas tran vdout0_24ck620 FIND v(dout0_24) AT=315.025n

.meas tran vdout0_25ck620 FIND v(dout0_25) AT=315.025n

.meas tran vdout0_26ck620 FIND v(dout0_26) AT=315.025n

.meas tran vdout0_27ck620 FIND v(dout0_27) AT=315.025n

.meas tran vdout0_28ck620 FIND v(dout0_28) AT=315.025n

.meas tran vdout0_29ck620 FIND v(dout0_29) AT=315.025n

.meas tran vdout0_30ck620 FIND v(dout0_30) AT=315.025n

.meas tran vdout0_31ck620 FIND v(dout0_31) AT=315.025n

.meas tran vdout0_32ck620 FIND v(dout0_32) AT=315.025n

.meas tran vdout0_33ck620 FIND v(dout0_33) AT=315.025n

.meas tran vdout0_34ck620 FIND v(dout0_34) AT=315.025n

.meas tran vdout0_35ck620 FIND v(dout0_35) AT=315.025n

.meas tran vdout0_36ck620 FIND v(dout0_36) AT=315.025n

.meas tran vdout0_37ck620 FIND v(dout0_37) AT=315.025n

.meas tran vdout0_38ck620 FIND v(dout0_38) AT=315.025n

.meas tran vdout0_39ck620 FIND v(dout0_39) AT=315.025n

.meas tran vdout0_40ck620 FIND v(dout0_40) AT=315.025n

.meas tran vdout0_41ck620 FIND v(dout0_41) AT=315.025n

.meas tran vdout0_42ck620 FIND v(dout0_42) AT=315.025n

.meas tran vdout0_43ck620 FIND v(dout0_43) AT=315.025n

.meas tran vdout0_44ck620 FIND v(dout0_44) AT=315.025n

.meas tran vdout0_45ck620 FIND v(dout0_45) AT=315.025n

.meas tran vdout0_46ck620 FIND v(dout0_46) AT=315.025n

.meas tran vdout0_47ck620 FIND v(dout0_47) AT=315.025n

.meas tran vdout0_48ck620 FIND v(dout0_48) AT=315.025n

.meas tran vdout0_49ck620 FIND v(dout0_49) AT=315.025n

.meas tran vdout0_50ck620 FIND v(dout0_50) AT=315.025n

.meas tran vdout0_51ck620 FIND v(dout0_51) AT=315.025n

.meas tran vdout0_52ck620 FIND v(dout0_52) AT=315.025n

.meas tran vdout0_53ck620 FIND v(dout0_53) AT=315.025n

.meas tran vdout0_54ck620 FIND v(dout0_54) AT=315.025n

.meas tran vdout0_55ck620 FIND v(dout0_55) AT=315.025n

.meas tran vdout0_56ck620 FIND v(dout0_56) AT=315.025n

.meas tran vdout0_57ck620 FIND v(dout0_57) AT=315.025n

.meas tran vdout0_58ck620 FIND v(dout0_58) AT=315.025n

.meas tran vdout0_59ck620 FIND v(dout0_59) AT=315.025n

.meas tran vdout0_60ck620 FIND v(dout0_60) AT=315.025n

.meas tran vdout0_61ck620 FIND v(dout0_61) AT=315.025n

.meas tran vdout0_62ck620 FIND v(dout0_62) AT=315.025n

.meas tran vdout0_63ck620 FIND v(dout0_63) AT=315.025n

.meas tran vdout0_64ck620 FIND v(dout0_64) AT=315.025n

.meas tran vdout0_65ck620 FIND v(dout0_65) AT=315.025n

.meas tran vdout0_66ck620 FIND v(dout0_66) AT=315.025n

.meas tran vdout0_67ck620 FIND v(dout0_67) AT=315.025n

.meas tran vdout0_68ck620 FIND v(dout0_68) AT=315.025n

.meas tran vdout0_69ck620 FIND v(dout0_69) AT=315.025n

.meas tran vdout0_70ck620 FIND v(dout0_70) AT=315.025n

.meas tran vdout0_71ck620 FIND v(dout0_71) AT=315.025n

.meas tran vdout0_72ck620 FIND v(dout0_72) AT=315.025n

.meas tran vdout0_73ck620 FIND v(dout0_73) AT=315.025n

.meas tran vdout0_74ck620 FIND v(dout0_74) AT=315.025n

.meas tran vdout0_75ck620 FIND v(dout0_75) AT=315.025n

.meas tran vdout0_76ck620 FIND v(dout0_76) AT=315.025n

.meas tran vdout0_77ck620 FIND v(dout0_77) AT=315.025n

.meas tran vdout0_78ck620 FIND v(dout0_78) AT=315.025n

.meas tran vdout0_79ck620 FIND v(dout0_79) AT=315.025n

.meas tran vdout0_80ck620 FIND v(dout0_80) AT=315.025n

.meas tran vdout0_81ck620 FIND v(dout0_81) AT=315.025n

.meas tran vdout0_82ck620 FIND v(dout0_82) AT=315.025n

.meas tran vdout0_83ck620 FIND v(dout0_83) AT=315.025n

.meas tran vdout0_84ck620 FIND v(dout0_84) AT=315.025n

.meas tran vdout0_85ck620 FIND v(dout0_85) AT=315.025n

.meas tran vdout0_86ck620 FIND v(dout0_86) AT=315.025n

.meas tran vdout0_87ck620 FIND v(dout0_87) AT=315.025n

.meas tran vdout0_88ck620 FIND v(dout0_88) AT=315.025n

.meas tran vdout0_89ck620 FIND v(dout0_89) AT=315.025n

.meas tran vdout0_90ck620 FIND v(dout0_90) AT=315.025n

.meas tran vdout0_91ck620 FIND v(dout0_91) AT=315.025n

.meas tran vdout0_92ck620 FIND v(dout0_92) AT=315.025n

.meas tran vdout0_93ck620 FIND v(dout0_93) AT=315.025n

.meas tran vdout0_94ck620 FIND v(dout0_94) AT=315.025n

.meas tran vdout0_95ck620 FIND v(dout0_95) AT=315.025n

.meas tran vdout0_96ck620 FIND v(dout0_96) AT=315.025n

.meas tran vdout0_97ck620 FIND v(dout0_97) AT=315.025n

.meas tran vdout0_98ck620 FIND v(dout0_98) AT=315.025n

.meas tran vdout0_99ck620 FIND v(dout0_99) AT=315.025n

.meas tran vdout0_100ck620 FIND v(dout0_100) AT=315.025n

.meas tran vdout0_101ck620 FIND v(dout0_101) AT=315.025n

.meas tran vdout0_102ck620 FIND v(dout0_102) AT=315.025n

.meas tran vdout0_103ck620 FIND v(dout0_103) AT=315.025n

.meas tran vdout0_104ck620 FIND v(dout0_104) AT=315.025n

.meas tran vdout0_105ck620 FIND v(dout0_105) AT=315.025n

.meas tran vdout0_106ck620 FIND v(dout0_106) AT=315.025n

.meas tran vdout0_107ck620 FIND v(dout0_107) AT=315.025n

.meas tran vdout0_108ck620 FIND v(dout0_108) AT=315.025n

.meas tran vdout0_109ck620 FIND v(dout0_109) AT=315.025n

.meas tran vdout0_110ck620 FIND v(dout0_110) AT=315.025n

.meas tran vdout0_111ck620 FIND v(dout0_111) AT=315.025n

.meas tran vdout0_112ck620 FIND v(dout0_112) AT=315.025n

.meas tran vdout0_113ck620 FIND v(dout0_113) AT=315.025n

.meas tran vdout0_114ck620 FIND v(dout0_114) AT=315.025n

.meas tran vdout0_115ck620 FIND v(dout0_115) AT=315.025n

.meas tran vdout0_116ck620 FIND v(dout0_116) AT=315.025n

.meas tran vdout0_117ck620 FIND v(dout0_117) AT=315.025n

.meas tran vdout0_118ck620 FIND v(dout0_118) AT=315.025n

.meas tran vdout0_119ck620 FIND v(dout0_119) AT=315.025n

.meas tran vdout0_120ck620 FIND v(dout0_120) AT=315.025n

.meas tran vdout0_121ck620 FIND v(dout0_121) AT=315.025n

.meas tran vdout0_122ck620 FIND v(dout0_122) AT=315.025n

.meas tran vdout0_123ck620 FIND v(dout0_123) AT=315.025n

.meas tran vdout0_124ck620 FIND v(dout0_124) AT=315.025n

.meas tran vdout0_125ck620 FIND v(dout0_125) AT=315.025n

.meas tran vdout0_126ck620 FIND v(dout0_126) AT=315.025n

.meas tran vdout0_127ck620 FIND v(dout0_127) AT=315.025n

.meas tran vdout0_128ck620 FIND v(dout0_128) AT=315.025n

.meas tran vdout0_129ck620 FIND v(dout0_129) AT=315.025n

.meas tran vdout0_130ck620 FIND v(dout0_130) AT=315.025n

.meas tran vdout0_131ck620 FIND v(dout0_131) AT=315.025n

.meas tran vdout0_132ck620 FIND v(dout0_132) AT=315.025n

.meas tran vdout0_133ck620 FIND v(dout0_133) AT=315.025n

.meas tran vdout0_134ck620 FIND v(dout0_134) AT=315.025n

.meas tran vdout0_135ck620 FIND v(dout0_135) AT=315.025n

.meas tran vdout0_136ck620 FIND v(dout0_136) AT=315.025n

.meas tran vdout0_137ck620 FIND v(dout0_137) AT=315.025n

.meas tran vdout0_138ck620 FIND v(dout0_138) AT=315.025n

.meas tran vdout0_139ck620 FIND v(dout0_139) AT=315.025n

.meas tran vdout0_140ck620 FIND v(dout0_140) AT=315.025n

.meas tran vdout0_141ck620 FIND v(dout0_141) AT=315.025n

.meas tran vdout0_142ck620 FIND v(dout0_142) AT=315.025n

.meas tran vdout0_143ck620 FIND v(dout0_143) AT=315.025n

.meas tran vdout0_144ck620 FIND v(dout0_144) AT=315.025n

.meas tran vdout0_145ck620 FIND v(dout0_145) AT=315.025n

.meas tran vdout0_146ck620 FIND v(dout0_146) AT=315.025n

.meas tran vdout0_147ck620 FIND v(dout0_147) AT=315.025n

.meas tran vdout0_148ck620 FIND v(dout0_148) AT=315.025n

.meas tran vdout0_149ck620 FIND v(dout0_149) AT=315.025n

.meas tran vdout0_150ck620 FIND v(dout0_150) AT=315.025n

.meas tran vdout0_151ck620 FIND v(dout0_151) AT=315.025n

.meas tran vdout0_152ck620 FIND v(dout0_152) AT=315.025n

.meas tran vdout0_153ck620 FIND v(dout0_153) AT=315.025n

.meas tran vdout0_154ck620 FIND v(dout0_154) AT=315.025n

.meas tran vdout0_155ck620 FIND v(dout0_155) AT=315.025n

.meas tran vdout0_156ck620 FIND v(dout0_156) AT=315.025n

.meas tran vdout0_157ck620 FIND v(dout0_157) AT=315.025n

.meas tran vdout0_158ck620 FIND v(dout0_158) AT=315.025n

.meas tran vdout0_159ck620 FIND v(dout0_159) AT=315.025n

.meas tran vdout0_160ck620 FIND v(dout0_160) AT=315.025n

.meas tran vdout0_161ck620 FIND v(dout0_161) AT=315.025n

.meas tran vdout0_162ck620 FIND v(dout0_162) AT=315.025n

.meas tran vdout0_163ck620 FIND v(dout0_163) AT=315.025n

.meas tran vdout0_164ck620 FIND v(dout0_164) AT=315.025n

.meas tran vdout0_165ck620 FIND v(dout0_165) AT=315.025n

.meas tran vdout0_166ck620 FIND v(dout0_166) AT=315.025n

.meas tran vdout0_167ck620 FIND v(dout0_167) AT=315.025n

.meas tran vdout0_168ck620 FIND v(dout0_168) AT=315.025n

.meas tran vdout0_169ck620 FIND v(dout0_169) AT=315.025n

.meas tran vdout0_170ck620 FIND v(dout0_170) AT=315.025n

.meas tran vdout0_171ck620 FIND v(dout0_171) AT=315.025n

.meas tran vdout0_172ck620 FIND v(dout0_172) AT=315.025n

.meas tran vdout0_173ck620 FIND v(dout0_173) AT=315.025n

.meas tran vdout0_174ck620 FIND v(dout0_174) AT=315.025n

.meas tran vdout0_175ck620 FIND v(dout0_175) AT=315.025n

.meas tran vdout0_176ck620 FIND v(dout0_176) AT=315.025n

.meas tran vdout0_177ck620 FIND v(dout0_177) AT=315.025n

.meas tran vdout0_178ck620 FIND v(dout0_178) AT=315.025n

.meas tran vdout0_179ck620 FIND v(dout0_179) AT=315.025n

.meas tran vdout0_180ck620 FIND v(dout0_180) AT=315.025n

.meas tran vdout0_181ck620 FIND v(dout0_181) AT=315.025n

.meas tran vdout0_182ck620 FIND v(dout0_182) AT=315.025n

.meas tran vdout0_183ck620 FIND v(dout0_183) AT=315.025n

.meas tran vdout0_184ck620 FIND v(dout0_184) AT=315.025n

.meas tran vdout0_185ck620 FIND v(dout0_185) AT=315.025n

.meas tran vdout0_186ck620 FIND v(dout0_186) AT=315.025n

.meas tran vdout0_187ck620 FIND v(dout0_187) AT=315.025n

.meas tran vdout0_188ck620 FIND v(dout0_188) AT=315.025n

.meas tran vdout0_189ck620 FIND v(dout0_189) AT=315.025n

.meas tran vdout0_190ck620 FIND v(dout0_190) AT=315.025n

.meas tran vdout0_191ck620 FIND v(dout0_191) AT=315.025n

.meas tran vdout0_192ck620 FIND v(dout0_192) AT=315.025n

.meas tran vdout0_193ck620 FIND v(dout0_193) AT=315.025n

.meas tran vdout0_194ck620 FIND v(dout0_194) AT=315.025n

.meas tran vdout0_195ck620 FIND v(dout0_195) AT=315.025n

.meas tran vdout0_196ck620 FIND v(dout0_196) AT=315.025n

.meas tran vdout0_197ck620 FIND v(dout0_197) AT=315.025n

.meas tran vdout0_198ck620 FIND v(dout0_198) AT=315.025n

.meas tran vdout0_199ck620 FIND v(dout0_199) AT=315.025n

.meas tran vdout0_200ck620 FIND v(dout0_200) AT=315.025n

.meas tran vdout0_201ck620 FIND v(dout0_201) AT=315.025n

.meas tran vdout0_202ck620 FIND v(dout0_202) AT=315.025n

.meas tran vdout0_203ck620 FIND v(dout0_203) AT=315.025n

.meas tran vdout0_204ck620 FIND v(dout0_204) AT=315.025n

.meas tran vdout0_205ck620 FIND v(dout0_205) AT=315.025n

.meas tran vdout0_206ck620 FIND v(dout0_206) AT=315.025n

.meas tran vdout0_207ck620 FIND v(dout0_207) AT=315.025n

.meas tran vdout0_208ck620 FIND v(dout0_208) AT=315.025n

.meas tran vdout0_209ck620 FIND v(dout0_209) AT=315.025n

.meas tran vdout0_210ck620 FIND v(dout0_210) AT=315.025n

.meas tran vdout0_211ck620 FIND v(dout0_211) AT=315.025n

.meas tran vdout0_212ck620 FIND v(dout0_212) AT=315.025n

.meas tran vdout0_213ck620 FIND v(dout0_213) AT=315.025n

.meas tran vdout0_214ck620 FIND v(dout0_214) AT=315.025n

.meas tran vdout0_215ck620 FIND v(dout0_215) AT=315.025n

.meas tran vdout0_216ck620 FIND v(dout0_216) AT=315.025n

.meas tran vdout0_217ck620 FIND v(dout0_217) AT=315.025n

.meas tran vdout0_218ck620 FIND v(dout0_218) AT=315.025n

.meas tran vdout0_219ck620 FIND v(dout0_219) AT=315.025n

.meas tran vdout0_220ck620 FIND v(dout0_220) AT=315.025n

.meas tran vdout0_221ck620 FIND v(dout0_221) AT=315.025n

.meas tran vdout0_222ck620 FIND v(dout0_222) AT=315.025n

.meas tran vdout0_223ck620 FIND v(dout0_223) AT=315.025n

.meas tran vdout0_224ck620 FIND v(dout0_224) AT=315.025n

.meas tran vdout0_225ck620 FIND v(dout0_225) AT=315.025n

.meas tran vdout0_226ck620 FIND v(dout0_226) AT=315.025n

.meas tran vdout0_227ck620 FIND v(dout0_227) AT=315.025n

.meas tran vdout0_228ck620 FIND v(dout0_228) AT=315.025n

.meas tran vdout0_229ck620 FIND v(dout0_229) AT=315.025n

.meas tran vdout0_230ck620 FIND v(dout0_230) AT=315.025n

.meas tran vdout0_231ck620 FIND v(dout0_231) AT=315.025n

.meas tran vdout0_232ck620 FIND v(dout0_232) AT=315.025n

.meas tran vdout0_233ck620 FIND v(dout0_233) AT=315.025n

.meas tran vdout0_234ck620 FIND v(dout0_234) AT=315.025n

.meas tran vdout0_235ck620 FIND v(dout0_235) AT=315.025n

.meas tran vdout0_236ck620 FIND v(dout0_236) AT=315.025n

.meas tran vdout0_237ck620 FIND v(dout0_237) AT=315.025n

.meas tran vdout0_238ck620 FIND v(dout0_238) AT=315.025n

.meas tran vdout0_239ck620 FIND v(dout0_239) AT=315.025n

.meas tran vdout0_240ck620 FIND v(dout0_240) AT=315.025n

.meas tran vdout0_241ck620 FIND v(dout0_241) AT=315.025n

.meas tran vdout0_242ck620 FIND v(dout0_242) AT=315.025n

.meas tran vdout0_243ck620 FIND v(dout0_243) AT=315.025n

.meas tran vdout0_244ck620 FIND v(dout0_244) AT=315.025n

.meas tran vdout0_245ck620 FIND v(dout0_245) AT=315.025n

.meas tran vdout0_246ck620 FIND v(dout0_246) AT=315.025n

.meas tran vdout0_247ck620 FIND v(dout0_247) AT=315.025n

.meas tran vdout0_248ck620 FIND v(dout0_248) AT=315.025n

.meas tran vdout0_249ck620 FIND v(dout0_249) AT=315.025n

.meas tran vdout0_250ck620 FIND v(dout0_250) AT=315.025n

.meas tran vdout0_251ck620 FIND v(dout0_251) AT=315.025n

.meas tran vdout0_252ck620 FIND v(dout0_252) AT=315.025n

.meas tran vdout0_253ck620 FIND v(dout0_253) AT=315.025n

.meas tran vdout0_254ck620 FIND v(dout0_254) AT=315.025n

.meas tran vdout0_255ck620 FIND v(dout0_255) AT=315.025n

.meas tran vdout0_0ck640 FIND v(dout0_0) AT=325.025n

.meas tran vdout0_1ck640 FIND v(dout0_1) AT=325.025n

.meas tran vdout0_2ck640 FIND v(dout0_2) AT=325.025n

.meas tran vdout0_3ck640 FIND v(dout0_3) AT=325.025n

.meas tran vdout0_4ck640 FIND v(dout0_4) AT=325.025n

.meas tran vdout0_5ck640 FIND v(dout0_5) AT=325.025n

.meas tran vdout0_6ck640 FIND v(dout0_6) AT=325.025n

.meas tran vdout0_7ck640 FIND v(dout0_7) AT=325.025n

.meas tran vdout0_8ck640 FIND v(dout0_8) AT=325.025n

.meas tran vdout0_9ck640 FIND v(dout0_9) AT=325.025n

.meas tran vdout0_10ck640 FIND v(dout0_10) AT=325.025n

.meas tran vdout0_11ck640 FIND v(dout0_11) AT=325.025n

.meas tran vdout0_12ck640 FIND v(dout0_12) AT=325.025n

.meas tran vdout0_13ck640 FIND v(dout0_13) AT=325.025n

.meas tran vdout0_14ck640 FIND v(dout0_14) AT=325.025n

.meas tran vdout0_15ck640 FIND v(dout0_15) AT=325.025n

.meas tran vdout0_16ck640 FIND v(dout0_16) AT=325.025n

.meas tran vdout0_17ck640 FIND v(dout0_17) AT=325.025n

.meas tran vdout0_18ck640 FIND v(dout0_18) AT=325.025n

.meas tran vdout0_19ck640 FIND v(dout0_19) AT=325.025n

.meas tran vdout0_20ck640 FIND v(dout0_20) AT=325.025n

.meas tran vdout0_21ck640 FIND v(dout0_21) AT=325.025n

.meas tran vdout0_22ck640 FIND v(dout0_22) AT=325.025n

.meas tran vdout0_23ck640 FIND v(dout0_23) AT=325.025n

.meas tran vdout0_24ck640 FIND v(dout0_24) AT=325.025n

.meas tran vdout0_25ck640 FIND v(dout0_25) AT=325.025n

.meas tran vdout0_26ck640 FIND v(dout0_26) AT=325.025n

.meas tran vdout0_27ck640 FIND v(dout0_27) AT=325.025n

.meas tran vdout0_28ck640 FIND v(dout0_28) AT=325.025n

.meas tran vdout0_29ck640 FIND v(dout0_29) AT=325.025n

.meas tran vdout0_30ck640 FIND v(dout0_30) AT=325.025n

.meas tran vdout0_31ck640 FIND v(dout0_31) AT=325.025n

.meas tran vdout0_32ck640 FIND v(dout0_32) AT=325.025n

.meas tran vdout0_33ck640 FIND v(dout0_33) AT=325.025n

.meas tran vdout0_34ck640 FIND v(dout0_34) AT=325.025n

.meas tran vdout0_35ck640 FIND v(dout0_35) AT=325.025n

.meas tran vdout0_36ck640 FIND v(dout0_36) AT=325.025n

.meas tran vdout0_37ck640 FIND v(dout0_37) AT=325.025n

.meas tran vdout0_38ck640 FIND v(dout0_38) AT=325.025n

.meas tran vdout0_39ck640 FIND v(dout0_39) AT=325.025n

.meas tran vdout0_40ck640 FIND v(dout0_40) AT=325.025n

.meas tran vdout0_41ck640 FIND v(dout0_41) AT=325.025n

.meas tran vdout0_42ck640 FIND v(dout0_42) AT=325.025n

.meas tran vdout0_43ck640 FIND v(dout0_43) AT=325.025n

.meas tran vdout0_44ck640 FIND v(dout0_44) AT=325.025n

.meas tran vdout0_45ck640 FIND v(dout0_45) AT=325.025n

.meas tran vdout0_46ck640 FIND v(dout0_46) AT=325.025n

.meas tran vdout0_47ck640 FIND v(dout0_47) AT=325.025n

.meas tran vdout0_48ck640 FIND v(dout0_48) AT=325.025n

.meas tran vdout0_49ck640 FIND v(dout0_49) AT=325.025n

.meas tran vdout0_50ck640 FIND v(dout0_50) AT=325.025n

.meas tran vdout0_51ck640 FIND v(dout0_51) AT=325.025n

.meas tran vdout0_52ck640 FIND v(dout0_52) AT=325.025n

.meas tran vdout0_53ck640 FIND v(dout0_53) AT=325.025n

.meas tran vdout0_54ck640 FIND v(dout0_54) AT=325.025n

.meas tran vdout0_55ck640 FIND v(dout0_55) AT=325.025n

.meas tran vdout0_56ck640 FIND v(dout0_56) AT=325.025n

.meas tran vdout0_57ck640 FIND v(dout0_57) AT=325.025n

.meas tran vdout0_58ck640 FIND v(dout0_58) AT=325.025n

.meas tran vdout0_59ck640 FIND v(dout0_59) AT=325.025n

.meas tran vdout0_60ck640 FIND v(dout0_60) AT=325.025n

.meas tran vdout0_61ck640 FIND v(dout0_61) AT=325.025n

.meas tran vdout0_62ck640 FIND v(dout0_62) AT=325.025n

.meas tran vdout0_63ck640 FIND v(dout0_63) AT=325.025n

.meas tran vdout0_64ck640 FIND v(dout0_64) AT=325.025n

.meas tran vdout0_65ck640 FIND v(dout0_65) AT=325.025n

.meas tran vdout0_66ck640 FIND v(dout0_66) AT=325.025n

.meas tran vdout0_67ck640 FIND v(dout0_67) AT=325.025n

.meas tran vdout0_68ck640 FIND v(dout0_68) AT=325.025n

.meas tran vdout0_69ck640 FIND v(dout0_69) AT=325.025n

.meas tran vdout0_70ck640 FIND v(dout0_70) AT=325.025n

.meas tran vdout0_71ck640 FIND v(dout0_71) AT=325.025n

.meas tran vdout0_72ck640 FIND v(dout0_72) AT=325.025n

.meas tran vdout0_73ck640 FIND v(dout0_73) AT=325.025n

.meas tran vdout0_74ck640 FIND v(dout0_74) AT=325.025n

.meas tran vdout0_75ck640 FIND v(dout0_75) AT=325.025n

.meas tran vdout0_76ck640 FIND v(dout0_76) AT=325.025n

.meas tran vdout0_77ck640 FIND v(dout0_77) AT=325.025n

.meas tran vdout0_78ck640 FIND v(dout0_78) AT=325.025n

.meas tran vdout0_79ck640 FIND v(dout0_79) AT=325.025n

.meas tran vdout0_80ck640 FIND v(dout0_80) AT=325.025n

.meas tran vdout0_81ck640 FIND v(dout0_81) AT=325.025n

.meas tran vdout0_82ck640 FIND v(dout0_82) AT=325.025n

.meas tran vdout0_83ck640 FIND v(dout0_83) AT=325.025n

.meas tran vdout0_84ck640 FIND v(dout0_84) AT=325.025n

.meas tran vdout0_85ck640 FIND v(dout0_85) AT=325.025n

.meas tran vdout0_86ck640 FIND v(dout0_86) AT=325.025n

.meas tran vdout0_87ck640 FIND v(dout0_87) AT=325.025n

.meas tran vdout0_88ck640 FIND v(dout0_88) AT=325.025n

.meas tran vdout0_89ck640 FIND v(dout0_89) AT=325.025n

.meas tran vdout0_90ck640 FIND v(dout0_90) AT=325.025n

.meas tran vdout0_91ck640 FIND v(dout0_91) AT=325.025n

.meas tran vdout0_92ck640 FIND v(dout0_92) AT=325.025n

.meas tran vdout0_93ck640 FIND v(dout0_93) AT=325.025n

.meas tran vdout0_94ck640 FIND v(dout0_94) AT=325.025n

.meas tran vdout0_95ck640 FIND v(dout0_95) AT=325.025n

.meas tran vdout0_96ck640 FIND v(dout0_96) AT=325.025n

.meas tran vdout0_97ck640 FIND v(dout0_97) AT=325.025n

.meas tran vdout0_98ck640 FIND v(dout0_98) AT=325.025n

.meas tran vdout0_99ck640 FIND v(dout0_99) AT=325.025n

.meas tran vdout0_100ck640 FIND v(dout0_100) AT=325.025n

.meas tran vdout0_101ck640 FIND v(dout0_101) AT=325.025n

.meas tran vdout0_102ck640 FIND v(dout0_102) AT=325.025n

.meas tran vdout0_103ck640 FIND v(dout0_103) AT=325.025n

.meas tran vdout0_104ck640 FIND v(dout0_104) AT=325.025n

.meas tran vdout0_105ck640 FIND v(dout0_105) AT=325.025n

.meas tran vdout0_106ck640 FIND v(dout0_106) AT=325.025n

.meas tran vdout0_107ck640 FIND v(dout0_107) AT=325.025n

.meas tran vdout0_108ck640 FIND v(dout0_108) AT=325.025n

.meas tran vdout0_109ck640 FIND v(dout0_109) AT=325.025n

.meas tran vdout0_110ck640 FIND v(dout0_110) AT=325.025n

.meas tran vdout0_111ck640 FIND v(dout0_111) AT=325.025n

.meas tran vdout0_112ck640 FIND v(dout0_112) AT=325.025n

.meas tran vdout0_113ck640 FIND v(dout0_113) AT=325.025n

.meas tran vdout0_114ck640 FIND v(dout0_114) AT=325.025n

.meas tran vdout0_115ck640 FIND v(dout0_115) AT=325.025n

.meas tran vdout0_116ck640 FIND v(dout0_116) AT=325.025n

.meas tran vdout0_117ck640 FIND v(dout0_117) AT=325.025n

.meas tran vdout0_118ck640 FIND v(dout0_118) AT=325.025n

.meas tran vdout0_119ck640 FIND v(dout0_119) AT=325.025n

.meas tran vdout0_120ck640 FIND v(dout0_120) AT=325.025n

.meas tran vdout0_121ck640 FIND v(dout0_121) AT=325.025n

.meas tran vdout0_122ck640 FIND v(dout0_122) AT=325.025n

.meas tran vdout0_123ck640 FIND v(dout0_123) AT=325.025n

.meas tran vdout0_124ck640 FIND v(dout0_124) AT=325.025n

.meas tran vdout0_125ck640 FIND v(dout0_125) AT=325.025n

.meas tran vdout0_126ck640 FIND v(dout0_126) AT=325.025n

.meas tran vdout0_127ck640 FIND v(dout0_127) AT=325.025n

.meas tran vdout0_128ck640 FIND v(dout0_128) AT=325.025n

.meas tran vdout0_129ck640 FIND v(dout0_129) AT=325.025n

.meas tran vdout0_130ck640 FIND v(dout0_130) AT=325.025n

.meas tran vdout0_131ck640 FIND v(dout0_131) AT=325.025n

.meas tran vdout0_132ck640 FIND v(dout0_132) AT=325.025n

.meas tran vdout0_133ck640 FIND v(dout0_133) AT=325.025n

.meas tran vdout0_134ck640 FIND v(dout0_134) AT=325.025n

.meas tran vdout0_135ck640 FIND v(dout0_135) AT=325.025n

.meas tran vdout0_136ck640 FIND v(dout0_136) AT=325.025n

.meas tran vdout0_137ck640 FIND v(dout0_137) AT=325.025n

.meas tran vdout0_138ck640 FIND v(dout0_138) AT=325.025n

.meas tran vdout0_139ck640 FIND v(dout0_139) AT=325.025n

.meas tran vdout0_140ck640 FIND v(dout0_140) AT=325.025n

.meas tran vdout0_141ck640 FIND v(dout0_141) AT=325.025n

.meas tran vdout0_142ck640 FIND v(dout0_142) AT=325.025n

.meas tran vdout0_143ck640 FIND v(dout0_143) AT=325.025n

.meas tran vdout0_144ck640 FIND v(dout0_144) AT=325.025n

.meas tran vdout0_145ck640 FIND v(dout0_145) AT=325.025n

.meas tran vdout0_146ck640 FIND v(dout0_146) AT=325.025n

.meas tran vdout0_147ck640 FIND v(dout0_147) AT=325.025n

.meas tran vdout0_148ck640 FIND v(dout0_148) AT=325.025n

.meas tran vdout0_149ck640 FIND v(dout0_149) AT=325.025n

.meas tran vdout0_150ck640 FIND v(dout0_150) AT=325.025n

.meas tran vdout0_151ck640 FIND v(dout0_151) AT=325.025n

.meas tran vdout0_152ck640 FIND v(dout0_152) AT=325.025n

.meas tran vdout0_153ck640 FIND v(dout0_153) AT=325.025n

.meas tran vdout0_154ck640 FIND v(dout0_154) AT=325.025n

.meas tran vdout0_155ck640 FIND v(dout0_155) AT=325.025n

.meas tran vdout0_156ck640 FIND v(dout0_156) AT=325.025n

.meas tran vdout0_157ck640 FIND v(dout0_157) AT=325.025n

.meas tran vdout0_158ck640 FIND v(dout0_158) AT=325.025n

.meas tran vdout0_159ck640 FIND v(dout0_159) AT=325.025n

.meas tran vdout0_160ck640 FIND v(dout0_160) AT=325.025n

.meas tran vdout0_161ck640 FIND v(dout0_161) AT=325.025n

.meas tran vdout0_162ck640 FIND v(dout0_162) AT=325.025n

.meas tran vdout0_163ck640 FIND v(dout0_163) AT=325.025n

.meas tran vdout0_164ck640 FIND v(dout0_164) AT=325.025n

.meas tran vdout0_165ck640 FIND v(dout0_165) AT=325.025n

.meas tran vdout0_166ck640 FIND v(dout0_166) AT=325.025n

.meas tran vdout0_167ck640 FIND v(dout0_167) AT=325.025n

.meas tran vdout0_168ck640 FIND v(dout0_168) AT=325.025n

.meas tran vdout0_169ck640 FIND v(dout0_169) AT=325.025n

.meas tran vdout0_170ck640 FIND v(dout0_170) AT=325.025n

.meas tran vdout0_171ck640 FIND v(dout0_171) AT=325.025n

.meas tran vdout0_172ck640 FIND v(dout0_172) AT=325.025n

.meas tran vdout0_173ck640 FIND v(dout0_173) AT=325.025n

.meas tran vdout0_174ck640 FIND v(dout0_174) AT=325.025n

.meas tran vdout0_175ck640 FIND v(dout0_175) AT=325.025n

.meas tran vdout0_176ck640 FIND v(dout0_176) AT=325.025n

.meas tran vdout0_177ck640 FIND v(dout0_177) AT=325.025n

.meas tran vdout0_178ck640 FIND v(dout0_178) AT=325.025n

.meas tran vdout0_179ck640 FIND v(dout0_179) AT=325.025n

.meas tran vdout0_180ck640 FIND v(dout0_180) AT=325.025n

.meas tran vdout0_181ck640 FIND v(dout0_181) AT=325.025n

.meas tran vdout0_182ck640 FIND v(dout0_182) AT=325.025n

.meas tran vdout0_183ck640 FIND v(dout0_183) AT=325.025n

.meas tran vdout0_184ck640 FIND v(dout0_184) AT=325.025n

.meas tran vdout0_185ck640 FIND v(dout0_185) AT=325.025n

.meas tran vdout0_186ck640 FIND v(dout0_186) AT=325.025n

.meas tran vdout0_187ck640 FIND v(dout0_187) AT=325.025n

.meas tran vdout0_188ck640 FIND v(dout0_188) AT=325.025n

.meas tran vdout0_189ck640 FIND v(dout0_189) AT=325.025n

.meas tran vdout0_190ck640 FIND v(dout0_190) AT=325.025n

.meas tran vdout0_191ck640 FIND v(dout0_191) AT=325.025n

.meas tran vdout0_192ck640 FIND v(dout0_192) AT=325.025n

.meas tran vdout0_193ck640 FIND v(dout0_193) AT=325.025n

.meas tran vdout0_194ck640 FIND v(dout0_194) AT=325.025n

.meas tran vdout0_195ck640 FIND v(dout0_195) AT=325.025n

.meas tran vdout0_196ck640 FIND v(dout0_196) AT=325.025n

.meas tran vdout0_197ck640 FIND v(dout0_197) AT=325.025n

.meas tran vdout0_198ck640 FIND v(dout0_198) AT=325.025n

.meas tran vdout0_199ck640 FIND v(dout0_199) AT=325.025n

.meas tran vdout0_200ck640 FIND v(dout0_200) AT=325.025n

.meas tran vdout0_201ck640 FIND v(dout0_201) AT=325.025n

.meas tran vdout0_202ck640 FIND v(dout0_202) AT=325.025n

.meas tran vdout0_203ck640 FIND v(dout0_203) AT=325.025n

.meas tran vdout0_204ck640 FIND v(dout0_204) AT=325.025n

.meas tran vdout0_205ck640 FIND v(dout0_205) AT=325.025n

.meas tran vdout0_206ck640 FIND v(dout0_206) AT=325.025n

.meas tran vdout0_207ck640 FIND v(dout0_207) AT=325.025n

.meas tran vdout0_208ck640 FIND v(dout0_208) AT=325.025n

.meas tran vdout0_209ck640 FIND v(dout0_209) AT=325.025n

.meas tran vdout0_210ck640 FIND v(dout0_210) AT=325.025n

.meas tran vdout0_211ck640 FIND v(dout0_211) AT=325.025n

.meas tran vdout0_212ck640 FIND v(dout0_212) AT=325.025n

.meas tran vdout0_213ck640 FIND v(dout0_213) AT=325.025n

.meas tran vdout0_214ck640 FIND v(dout0_214) AT=325.025n

.meas tran vdout0_215ck640 FIND v(dout0_215) AT=325.025n

.meas tran vdout0_216ck640 FIND v(dout0_216) AT=325.025n

.meas tran vdout0_217ck640 FIND v(dout0_217) AT=325.025n

.meas tran vdout0_218ck640 FIND v(dout0_218) AT=325.025n

.meas tran vdout0_219ck640 FIND v(dout0_219) AT=325.025n

.meas tran vdout0_220ck640 FIND v(dout0_220) AT=325.025n

.meas tran vdout0_221ck640 FIND v(dout0_221) AT=325.025n

.meas tran vdout0_222ck640 FIND v(dout0_222) AT=325.025n

.meas tran vdout0_223ck640 FIND v(dout0_223) AT=325.025n

.meas tran vdout0_224ck640 FIND v(dout0_224) AT=325.025n

.meas tran vdout0_225ck640 FIND v(dout0_225) AT=325.025n

.meas tran vdout0_226ck640 FIND v(dout0_226) AT=325.025n

.meas tran vdout0_227ck640 FIND v(dout0_227) AT=325.025n

.meas tran vdout0_228ck640 FIND v(dout0_228) AT=325.025n

.meas tran vdout0_229ck640 FIND v(dout0_229) AT=325.025n

.meas tran vdout0_230ck640 FIND v(dout0_230) AT=325.025n

.meas tran vdout0_231ck640 FIND v(dout0_231) AT=325.025n

.meas tran vdout0_232ck640 FIND v(dout0_232) AT=325.025n

.meas tran vdout0_233ck640 FIND v(dout0_233) AT=325.025n

.meas tran vdout0_234ck640 FIND v(dout0_234) AT=325.025n

.meas tran vdout0_235ck640 FIND v(dout0_235) AT=325.025n

.meas tran vdout0_236ck640 FIND v(dout0_236) AT=325.025n

.meas tran vdout0_237ck640 FIND v(dout0_237) AT=325.025n

.meas tran vdout0_238ck640 FIND v(dout0_238) AT=325.025n

.meas tran vdout0_239ck640 FIND v(dout0_239) AT=325.025n

.meas tran vdout0_240ck640 FIND v(dout0_240) AT=325.025n

.meas tran vdout0_241ck640 FIND v(dout0_241) AT=325.025n

.meas tran vdout0_242ck640 FIND v(dout0_242) AT=325.025n

.meas tran vdout0_243ck640 FIND v(dout0_243) AT=325.025n

.meas tran vdout0_244ck640 FIND v(dout0_244) AT=325.025n

.meas tran vdout0_245ck640 FIND v(dout0_245) AT=325.025n

.meas tran vdout0_246ck640 FIND v(dout0_246) AT=325.025n

.meas tran vdout0_247ck640 FIND v(dout0_247) AT=325.025n

.meas tran vdout0_248ck640 FIND v(dout0_248) AT=325.025n

.meas tran vdout0_249ck640 FIND v(dout0_249) AT=325.025n

.meas tran vdout0_250ck640 FIND v(dout0_250) AT=325.025n

.meas tran vdout0_251ck640 FIND v(dout0_251) AT=325.025n

.meas tran vdout0_252ck640 FIND v(dout0_252) AT=325.025n

.meas tran vdout0_253ck640 FIND v(dout0_253) AT=325.025n

.meas tran vdout0_254ck640 FIND v(dout0_254) AT=325.025n

.meas tran vdout0_255ck640 FIND v(dout0_255) AT=325.025n

.meas tran vdout0_0ck670 FIND v(dout0_0) AT=340.025n

.meas tran vdout0_1ck670 FIND v(dout0_1) AT=340.025n

.meas tran vdout0_2ck670 FIND v(dout0_2) AT=340.025n

.meas tran vdout0_3ck670 FIND v(dout0_3) AT=340.025n

.meas tran vdout0_4ck670 FIND v(dout0_4) AT=340.025n

.meas tran vdout0_5ck670 FIND v(dout0_5) AT=340.025n

.meas tran vdout0_6ck670 FIND v(dout0_6) AT=340.025n

.meas tran vdout0_7ck670 FIND v(dout0_7) AT=340.025n

.meas tran vdout0_8ck670 FIND v(dout0_8) AT=340.025n

.meas tran vdout0_9ck670 FIND v(dout0_9) AT=340.025n

.meas tran vdout0_10ck670 FIND v(dout0_10) AT=340.025n

.meas tran vdout0_11ck670 FIND v(dout0_11) AT=340.025n

.meas tran vdout0_12ck670 FIND v(dout0_12) AT=340.025n

.meas tran vdout0_13ck670 FIND v(dout0_13) AT=340.025n

.meas tran vdout0_14ck670 FIND v(dout0_14) AT=340.025n

.meas tran vdout0_15ck670 FIND v(dout0_15) AT=340.025n

.meas tran vdout0_16ck670 FIND v(dout0_16) AT=340.025n

.meas tran vdout0_17ck670 FIND v(dout0_17) AT=340.025n

.meas tran vdout0_18ck670 FIND v(dout0_18) AT=340.025n

.meas tran vdout0_19ck670 FIND v(dout0_19) AT=340.025n

.meas tran vdout0_20ck670 FIND v(dout0_20) AT=340.025n

.meas tran vdout0_21ck670 FIND v(dout0_21) AT=340.025n

.meas tran vdout0_22ck670 FIND v(dout0_22) AT=340.025n

.meas tran vdout0_23ck670 FIND v(dout0_23) AT=340.025n

.meas tran vdout0_24ck670 FIND v(dout0_24) AT=340.025n

.meas tran vdout0_25ck670 FIND v(dout0_25) AT=340.025n

.meas tran vdout0_26ck670 FIND v(dout0_26) AT=340.025n

.meas tran vdout0_27ck670 FIND v(dout0_27) AT=340.025n

.meas tran vdout0_28ck670 FIND v(dout0_28) AT=340.025n

.meas tran vdout0_29ck670 FIND v(dout0_29) AT=340.025n

.meas tran vdout0_30ck670 FIND v(dout0_30) AT=340.025n

.meas tran vdout0_31ck670 FIND v(dout0_31) AT=340.025n

.meas tran vdout0_32ck670 FIND v(dout0_32) AT=340.025n

.meas tran vdout0_33ck670 FIND v(dout0_33) AT=340.025n

.meas tran vdout0_34ck670 FIND v(dout0_34) AT=340.025n

.meas tran vdout0_35ck670 FIND v(dout0_35) AT=340.025n

.meas tran vdout0_36ck670 FIND v(dout0_36) AT=340.025n

.meas tran vdout0_37ck670 FIND v(dout0_37) AT=340.025n

.meas tran vdout0_38ck670 FIND v(dout0_38) AT=340.025n

.meas tran vdout0_39ck670 FIND v(dout0_39) AT=340.025n

.meas tran vdout0_40ck670 FIND v(dout0_40) AT=340.025n

.meas tran vdout0_41ck670 FIND v(dout0_41) AT=340.025n

.meas tran vdout0_42ck670 FIND v(dout0_42) AT=340.025n

.meas tran vdout0_43ck670 FIND v(dout0_43) AT=340.025n

.meas tran vdout0_44ck670 FIND v(dout0_44) AT=340.025n

.meas tran vdout0_45ck670 FIND v(dout0_45) AT=340.025n

.meas tran vdout0_46ck670 FIND v(dout0_46) AT=340.025n

.meas tran vdout0_47ck670 FIND v(dout0_47) AT=340.025n

.meas tran vdout0_48ck670 FIND v(dout0_48) AT=340.025n

.meas tran vdout0_49ck670 FIND v(dout0_49) AT=340.025n

.meas tran vdout0_50ck670 FIND v(dout0_50) AT=340.025n

.meas tran vdout0_51ck670 FIND v(dout0_51) AT=340.025n

.meas tran vdout0_52ck670 FIND v(dout0_52) AT=340.025n

.meas tran vdout0_53ck670 FIND v(dout0_53) AT=340.025n

.meas tran vdout0_54ck670 FIND v(dout0_54) AT=340.025n

.meas tran vdout0_55ck670 FIND v(dout0_55) AT=340.025n

.meas tran vdout0_56ck670 FIND v(dout0_56) AT=340.025n

.meas tran vdout0_57ck670 FIND v(dout0_57) AT=340.025n

.meas tran vdout0_58ck670 FIND v(dout0_58) AT=340.025n

.meas tran vdout0_59ck670 FIND v(dout0_59) AT=340.025n

.meas tran vdout0_60ck670 FIND v(dout0_60) AT=340.025n

.meas tran vdout0_61ck670 FIND v(dout0_61) AT=340.025n

.meas tran vdout0_62ck670 FIND v(dout0_62) AT=340.025n

.meas tran vdout0_63ck670 FIND v(dout0_63) AT=340.025n

.meas tran vdout0_64ck670 FIND v(dout0_64) AT=340.025n

.meas tran vdout0_65ck670 FIND v(dout0_65) AT=340.025n

.meas tran vdout0_66ck670 FIND v(dout0_66) AT=340.025n

.meas tran vdout0_67ck670 FIND v(dout0_67) AT=340.025n

.meas tran vdout0_68ck670 FIND v(dout0_68) AT=340.025n

.meas tran vdout0_69ck670 FIND v(dout0_69) AT=340.025n

.meas tran vdout0_70ck670 FIND v(dout0_70) AT=340.025n

.meas tran vdout0_71ck670 FIND v(dout0_71) AT=340.025n

.meas tran vdout0_72ck670 FIND v(dout0_72) AT=340.025n

.meas tran vdout0_73ck670 FIND v(dout0_73) AT=340.025n

.meas tran vdout0_74ck670 FIND v(dout0_74) AT=340.025n

.meas tran vdout0_75ck670 FIND v(dout0_75) AT=340.025n

.meas tran vdout0_76ck670 FIND v(dout0_76) AT=340.025n

.meas tran vdout0_77ck670 FIND v(dout0_77) AT=340.025n

.meas tran vdout0_78ck670 FIND v(dout0_78) AT=340.025n

.meas tran vdout0_79ck670 FIND v(dout0_79) AT=340.025n

.meas tran vdout0_80ck670 FIND v(dout0_80) AT=340.025n

.meas tran vdout0_81ck670 FIND v(dout0_81) AT=340.025n

.meas tran vdout0_82ck670 FIND v(dout0_82) AT=340.025n

.meas tran vdout0_83ck670 FIND v(dout0_83) AT=340.025n

.meas tran vdout0_84ck670 FIND v(dout0_84) AT=340.025n

.meas tran vdout0_85ck670 FIND v(dout0_85) AT=340.025n

.meas tran vdout0_86ck670 FIND v(dout0_86) AT=340.025n

.meas tran vdout0_87ck670 FIND v(dout0_87) AT=340.025n

.meas tran vdout0_88ck670 FIND v(dout0_88) AT=340.025n

.meas tran vdout0_89ck670 FIND v(dout0_89) AT=340.025n

.meas tran vdout0_90ck670 FIND v(dout0_90) AT=340.025n

.meas tran vdout0_91ck670 FIND v(dout0_91) AT=340.025n

.meas tran vdout0_92ck670 FIND v(dout0_92) AT=340.025n

.meas tran vdout0_93ck670 FIND v(dout0_93) AT=340.025n

.meas tran vdout0_94ck670 FIND v(dout0_94) AT=340.025n

.meas tran vdout0_95ck670 FIND v(dout0_95) AT=340.025n

.meas tran vdout0_96ck670 FIND v(dout0_96) AT=340.025n

.meas tran vdout0_97ck670 FIND v(dout0_97) AT=340.025n

.meas tran vdout0_98ck670 FIND v(dout0_98) AT=340.025n

.meas tran vdout0_99ck670 FIND v(dout0_99) AT=340.025n

.meas tran vdout0_100ck670 FIND v(dout0_100) AT=340.025n

.meas tran vdout0_101ck670 FIND v(dout0_101) AT=340.025n

.meas tran vdout0_102ck670 FIND v(dout0_102) AT=340.025n

.meas tran vdout0_103ck670 FIND v(dout0_103) AT=340.025n

.meas tran vdout0_104ck670 FIND v(dout0_104) AT=340.025n

.meas tran vdout0_105ck670 FIND v(dout0_105) AT=340.025n

.meas tran vdout0_106ck670 FIND v(dout0_106) AT=340.025n

.meas tran vdout0_107ck670 FIND v(dout0_107) AT=340.025n

.meas tran vdout0_108ck670 FIND v(dout0_108) AT=340.025n

.meas tran vdout0_109ck670 FIND v(dout0_109) AT=340.025n

.meas tran vdout0_110ck670 FIND v(dout0_110) AT=340.025n

.meas tran vdout0_111ck670 FIND v(dout0_111) AT=340.025n

.meas tran vdout0_112ck670 FIND v(dout0_112) AT=340.025n

.meas tran vdout0_113ck670 FIND v(dout0_113) AT=340.025n

.meas tran vdout0_114ck670 FIND v(dout0_114) AT=340.025n

.meas tran vdout0_115ck670 FIND v(dout0_115) AT=340.025n

.meas tran vdout0_116ck670 FIND v(dout0_116) AT=340.025n

.meas tran vdout0_117ck670 FIND v(dout0_117) AT=340.025n

.meas tran vdout0_118ck670 FIND v(dout0_118) AT=340.025n

.meas tran vdout0_119ck670 FIND v(dout0_119) AT=340.025n

.meas tran vdout0_120ck670 FIND v(dout0_120) AT=340.025n

.meas tran vdout0_121ck670 FIND v(dout0_121) AT=340.025n

.meas tran vdout0_122ck670 FIND v(dout0_122) AT=340.025n

.meas tran vdout0_123ck670 FIND v(dout0_123) AT=340.025n

.meas tran vdout0_124ck670 FIND v(dout0_124) AT=340.025n

.meas tran vdout0_125ck670 FIND v(dout0_125) AT=340.025n

.meas tran vdout0_126ck670 FIND v(dout0_126) AT=340.025n

.meas tran vdout0_127ck670 FIND v(dout0_127) AT=340.025n

.meas tran vdout0_128ck670 FIND v(dout0_128) AT=340.025n

.meas tran vdout0_129ck670 FIND v(dout0_129) AT=340.025n

.meas tran vdout0_130ck670 FIND v(dout0_130) AT=340.025n

.meas tran vdout0_131ck670 FIND v(dout0_131) AT=340.025n

.meas tran vdout0_132ck670 FIND v(dout0_132) AT=340.025n

.meas tran vdout0_133ck670 FIND v(dout0_133) AT=340.025n

.meas tran vdout0_134ck670 FIND v(dout0_134) AT=340.025n

.meas tran vdout0_135ck670 FIND v(dout0_135) AT=340.025n

.meas tran vdout0_136ck670 FIND v(dout0_136) AT=340.025n

.meas tran vdout0_137ck670 FIND v(dout0_137) AT=340.025n

.meas tran vdout0_138ck670 FIND v(dout0_138) AT=340.025n

.meas tran vdout0_139ck670 FIND v(dout0_139) AT=340.025n

.meas tran vdout0_140ck670 FIND v(dout0_140) AT=340.025n

.meas tran vdout0_141ck670 FIND v(dout0_141) AT=340.025n

.meas tran vdout0_142ck670 FIND v(dout0_142) AT=340.025n

.meas tran vdout0_143ck670 FIND v(dout0_143) AT=340.025n

.meas tran vdout0_144ck670 FIND v(dout0_144) AT=340.025n

.meas tran vdout0_145ck670 FIND v(dout0_145) AT=340.025n

.meas tran vdout0_146ck670 FIND v(dout0_146) AT=340.025n

.meas tran vdout0_147ck670 FIND v(dout0_147) AT=340.025n

.meas tran vdout0_148ck670 FIND v(dout0_148) AT=340.025n

.meas tran vdout0_149ck670 FIND v(dout0_149) AT=340.025n

.meas tran vdout0_150ck670 FIND v(dout0_150) AT=340.025n

.meas tran vdout0_151ck670 FIND v(dout0_151) AT=340.025n

.meas tran vdout0_152ck670 FIND v(dout0_152) AT=340.025n

.meas tran vdout0_153ck670 FIND v(dout0_153) AT=340.025n

.meas tran vdout0_154ck670 FIND v(dout0_154) AT=340.025n

.meas tran vdout0_155ck670 FIND v(dout0_155) AT=340.025n

.meas tran vdout0_156ck670 FIND v(dout0_156) AT=340.025n

.meas tran vdout0_157ck670 FIND v(dout0_157) AT=340.025n

.meas tran vdout0_158ck670 FIND v(dout0_158) AT=340.025n

.meas tran vdout0_159ck670 FIND v(dout0_159) AT=340.025n

.meas tran vdout0_160ck670 FIND v(dout0_160) AT=340.025n

.meas tran vdout0_161ck670 FIND v(dout0_161) AT=340.025n

.meas tran vdout0_162ck670 FIND v(dout0_162) AT=340.025n

.meas tran vdout0_163ck670 FIND v(dout0_163) AT=340.025n

.meas tran vdout0_164ck670 FIND v(dout0_164) AT=340.025n

.meas tran vdout0_165ck670 FIND v(dout0_165) AT=340.025n

.meas tran vdout0_166ck670 FIND v(dout0_166) AT=340.025n

.meas tran vdout0_167ck670 FIND v(dout0_167) AT=340.025n

.meas tran vdout0_168ck670 FIND v(dout0_168) AT=340.025n

.meas tran vdout0_169ck670 FIND v(dout0_169) AT=340.025n

.meas tran vdout0_170ck670 FIND v(dout0_170) AT=340.025n

.meas tran vdout0_171ck670 FIND v(dout0_171) AT=340.025n

.meas tran vdout0_172ck670 FIND v(dout0_172) AT=340.025n

.meas tran vdout0_173ck670 FIND v(dout0_173) AT=340.025n

.meas tran vdout0_174ck670 FIND v(dout0_174) AT=340.025n

.meas tran vdout0_175ck670 FIND v(dout0_175) AT=340.025n

.meas tran vdout0_176ck670 FIND v(dout0_176) AT=340.025n

.meas tran vdout0_177ck670 FIND v(dout0_177) AT=340.025n

.meas tran vdout0_178ck670 FIND v(dout0_178) AT=340.025n

.meas tran vdout0_179ck670 FIND v(dout0_179) AT=340.025n

.meas tran vdout0_180ck670 FIND v(dout0_180) AT=340.025n

.meas tran vdout0_181ck670 FIND v(dout0_181) AT=340.025n

.meas tran vdout0_182ck670 FIND v(dout0_182) AT=340.025n

.meas tran vdout0_183ck670 FIND v(dout0_183) AT=340.025n

.meas tran vdout0_184ck670 FIND v(dout0_184) AT=340.025n

.meas tran vdout0_185ck670 FIND v(dout0_185) AT=340.025n

.meas tran vdout0_186ck670 FIND v(dout0_186) AT=340.025n

.meas tran vdout0_187ck670 FIND v(dout0_187) AT=340.025n

.meas tran vdout0_188ck670 FIND v(dout0_188) AT=340.025n

.meas tran vdout0_189ck670 FIND v(dout0_189) AT=340.025n

.meas tran vdout0_190ck670 FIND v(dout0_190) AT=340.025n

.meas tran vdout0_191ck670 FIND v(dout0_191) AT=340.025n

.meas tran vdout0_192ck670 FIND v(dout0_192) AT=340.025n

.meas tran vdout0_193ck670 FIND v(dout0_193) AT=340.025n

.meas tran vdout0_194ck670 FIND v(dout0_194) AT=340.025n

.meas tran vdout0_195ck670 FIND v(dout0_195) AT=340.025n

.meas tran vdout0_196ck670 FIND v(dout0_196) AT=340.025n

.meas tran vdout0_197ck670 FIND v(dout0_197) AT=340.025n

.meas tran vdout0_198ck670 FIND v(dout0_198) AT=340.025n

.meas tran vdout0_199ck670 FIND v(dout0_199) AT=340.025n

.meas tran vdout0_200ck670 FIND v(dout0_200) AT=340.025n

.meas tran vdout0_201ck670 FIND v(dout0_201) AT=340.025n

.meas tran vdout0_202ck670 FIND v(dout0_202) AT=340.025n

.meas tran vdout0_203ck670 FIND v(dout0_203) AT=340.025n

.meas tran vdout0_204ck670 FIND v(dout0_204) AT=340.025n

.meas tran vdout0_205ck670 FIND v(dout0_205) AT=340.025n

.meas tran vdout0_206ck670 FIND v(dout0_206) AT=340.025n

.meas tran vdout0_207ck670 FIND v(dout0_207) AT=340.025n

.meas tran vdout0_208ck670 FIND v(dout0_208) AT=340.025n

.meas tran vdout0_209ck670 FIND v(dout0_209) AT=340.025n

.meas tran vdout0_210ck670 FIND v(dout0_210) AT=340.025n

.meas tran vdout0_211ck670 FIND v(dout0_211) AT=340.025n

.meas tran vdout0_212ck670 FIND v(dout0_212) AT=340.025n

.meas tran vdout0_213ck670 FIND v(dout0_213) AT=340.025n

.meas tran vdout0_214ck670 FIND v(dout0_214) AT=340.025n

.meas tran vdout0_215ck670 FIND v(dout0_215) AT=340.025n

.meas tran vdout0_216ck670 FIND v(dout0_216) AT=340.025n

.meas tran vdout0_217ck670 FIND v(dout0_217) AT=340.025n

.meas tran vdout0_218ck670 FIND v(dout0_218) AT=340.025n

.meas tran vdout0_219ck670 FIND v(dout0_219) AT=340.025n

.meas tran vdout0_220ck670 FIND v(dout0_220) AT=340.025n

.meas tran vdout0_221ck670 FIND v(dout0_221) AT=340.025n

.meas tran vdout0_222ck670 FIND v(dout0_222) AT=340.025n

.meas tran vdout0_223ck670 FIND v(dout0_223) AT=340.025n

.meas tran vdout0_224ck670 FIND v(dout0_224) AT=340.025n

.meas tran vdout0_225ck670 FIND v(dout0_225) AT=340.025n

.meas tran vdout0_226ck670 FIND v(dout0_226) AT=340.025n

.meas tran vdout0_227ck670 FIND v(dout0_227) AT=340.025n

.meas tran vdout0_228ck670 FIND v(dout0_228) AT=340.025n

.meas tran vdout0_229ck670 FIND v(dout0_229) AT=340.025n

.meas tran vdout0_230ck670 FIND v(dout0_230) AT=340.025n

.meas tran vdout0_231ck670 FIND v(dout0_231) AT=340.025n

.meas tran vdout0_232ck670 FIND v(dout0_232) AT=340.025n

.meas tran vdout0_233ck670 FIND v(dout0_233) AT=340.025n

.meas tran vdout0_234ck670 FIND v(dout0_234) AT=340.025n

.meas tran vdout0_235ck670 FIND v(dout0_235) AT=340.025n

.meas tran vdout0_236ck670 FIND v(dout0_236) AT=340.025n

.meas tran vdout0_237ck670 FIND v(dout0_237) AT=340.025n

.meas tran vdout0_238ck670 FIND v(dout0_238) AT=340.025n

.meas tran vdout0_239ck670 FIND v(dout0_239) AT=340.025n

.meas tran vdout0_240ck670 FIND v(dout0_240) AT=340.025n

.meas tran vdout0_241ck670 FIND v(dout0_241) AT=340.025n

.meas tran vdout0_242ck670 FIND v(dout0_242) AT=340.025n

.meas tran vdout0_243ck670 FIND v(dout0_243) AT=340.025n

.meas tran vdout0_244ck670 FIND v(dout0_244) AT=340.025n

.meas tran vdout0_245ck670 FIND v(dout0_245) AT=340.025n

.meas tran vdout0_246ck670 FIND v(dout0_246) AT=340.025n

.meas tran vdout0_247ck670 FIND v(dout0_247) AT=340.025n

.meas tran vdout0_248ck670 FIND v(dout0_248) AT=340.025n

.meas tran vdout0_249ck670 FIND v(dout0_249) AT=340.025n

.meas tran vdout0_250ck670 FIND v(dout0_250) AT=340.025n

.meas tran vdout0_251ck670 FIND v(dout0_251) AT=340.025n

.meas tran vdout0_252ck670 FIND v(dout0_252) AT=340.025n

.meas tran vdout0_253ck670 FIND v(dout0_253) AT=340.025n

.meas tran vdout0_254ck670 FIND v(dout0_254) AT=340.025n

.meas tran vdout0_255ck670 FIND v(dout0_255) AT=340.025n

.meas tran vdout0_0ck680 FIND v(dout0_0) AT=345.025n

.meas tran vdout0_1ck680 FIND v(dout0_1) AT=345.025n

.meas tran vdout0_2ck680 FIND v(dout0_2) AT=345.025n

.meas tran vdout0_3ck680 FIND v(dout0_3) AT=345.025n

.meas tran vdout0_4ck680 FIND v(dout0_4) AT=345.025n

.meas tran vdout0_5ck680 FIND v(dout0_5) AT=345.025n

.meas tran vdout0_6ck680 FIND v(dout0_6) AT=345.025n

.meas tran vdout0_7ck680 FIND v(dout0_7) AT=345.025n

.meas tran vdout0_8ck680 FIND v(dout0_8) AT=345.025n

.meas tran vdout0_9ck680 FIND v(dout0_9) AT=345.025n

.meas tran vdout0_10ck680 FIND v(dout0_10) AT=345.025n

.meas tran vdout0_11ck680 FIND v(dout0_11) AT=345.025n

.meas tran vdout0_12ck680 FIND v(dout0_12) AT=345.025n

.meas tran vdout0_13ck680 FIND v(dout0_13) AT=345.025n

.meas tran vdout0_14ck680 FIND v(dout0_14) AT=345.025n

.meas tran vdout0_15ck680 FIND v(dout0_15) AT=345.025n

.meas tran vdout0_16ck680 FIND v(dout0_16) AT=345.025n

.meas tran vdout0_17ck680 FIND v(dout0_17) AT=345.025n

.meas tran vdout0_18ck680 FIND v(dout0_18) AT=345.025n

.meas tran vdout0_19ck680 FIND v(dout0_19) AT=345.025n

.meas tran vdout0_20ck680 FIND v(dout0_20) AT=345.025n

.meas tran vdout0_21ck680 FIND v(dout0_21) AT=345.025n

.meas tran vdout0_22ck680 FIND v(dout0_22) AT=345.025n

.meas tran vdout0_23ck680 FIND v(dout0_23) AT=345.025n

.meas tran vdout0_24ck680 FIND v(dout0_24) AT=345.025n

.meas tran vdout0_25ck680 FIND v(dout0_25) AT=345.025n

.meas tran vdout0_26ck680 FIND v(dout0_26) AT=345.025n

.meas tran vdout0_27ck680 FIND v(dout0_27) AT=345.025n

.meas tran vdout0_28ck680 FIND v(dout0_28) AT=345.025n

.meas tran vdout0_29ck680 FIND v(dout0_29) AT=345.025n

.meas tran vdout0_30ck680 FIND v(dout0_30) AT=345.025n

.meas tran vdout0_31ck680 FIND v(dout0_31) AT=345.025n

.meas tran vdout0_32ck680 FIND v(dout0_32) AT=345.025n

.meas tran vdout0_33ck680 FIND v(dout0_33) AT=345.025n

.meas tran vdout0_34ck680 FIND v(dout0_34) AT=345.025n

.meas tran vdout0_35ck680 FIND v(dout0_35) AT=345.025n

.meas tran vdout0_36ck680 FIND v(dout0_36) AT=345.025n

.meas tran vdout0_37ck680 FIND v(dout0_37) AT=345.025n

.meas tran vdout0_38ck680 FIND v(dout0_38) AT=345.025n

.meas tran vdout0_39ck680 FIND v(dout0_39) AT=345.025n

.meas tran vdout0_40ck680 FIND v(dout0_40) AT=345.025n

.meas tran vdout0_41ck680 FIND v(dout0_41) AT=345.025n

.meas tran vdout0_42ck680 FIND v(dout0_42) AT=345.025n

.meas tran vdout0_43ck680 FIND v(dout0_43) AT=345.025n

.meas tran vdout0_44ck680 FIND v(dout0_44) AT=345.025n

.meas tran vdout0_45ck680 FIND v(dout0_45) AT=345.025n

.meas tran vdout0_46ck680 FIND v(dout0_46) AT=345.025n

.meas tran vdout0_47ck680 FIND v(dout0_47) AT=345.025n

.meas tran vdout0_48ck680 FIND v(dout0_48) AT=345.025n

.meas tran vdout0_49ck680 FIND v(dout0_49) AT=345.025n

.meas tran vdout0_50ck680 FIND v(dout0_50) AT=345.025n

.meas tran vdout0_51ck680 FIND v(dout0_51) AT=345.025n

.meas tran vdout0_52ck680 FIND v(dout0_52) AT=345.025n

.meas tran vdout0_53ck680 FIND v(dout0_53) AT=345.025n

.meas tran vdout0_54ck680 FIND v(dout0_54) AT=345.025n

.meas tran vdout0_55ck680 FIND v(dout0_55) AT=345.025n

.meas tran vdout0_56ck680 FIND v(dout0_56) AT=345.025n

.meas tran vdout0_57ck680 FIND v(dout0_57) AT=345.025n

.meas tran vdout0_58ck680 FIND v(dout0_58) AT=345.025n

.meas tran vdout0_59ck680 FIND v(dout0_59) AT=345.025n

.meas tran vdout0_60ck680 FIND v(dout0_60) AT=345.025n

.meas tran vdout0_61ck680 FIND v(dout0_61) AT=345.025n

.meas tran vdout0_62ck680 FIND v(dout0_62) AT=345.025n

.meas tran vdout0_63ck680 FIND v(dout0_63) AT=345.025n

.meas tran vdout0_64ck680 FIND v(dout0_64) AT=345.025n

.meas tran vdout0_65ck680 FIND v(dout0_65) AT=345.025n

.meas tran vdout0_66ck680 FIND v(dout0_66) AT=345.025n

.meas tran vdout0_67ck680 FIND v(dout0_67) AT=345.025n

.meas tran vdout0_68ck680 FIND v(dout0_68) AT=345.025n

.meas tran vdout0_69ck680 FIND v(dout0_69) AT=345.025n

.meas tran vdout0_70ck680 FIND v(dout0_70) AT=345.025n

.meas tran vdout0_71ck680 FIND v(dout0_71) AT=345.025n

.meas tran vdout0_72ck680 FIND v(dout0_72) AT=345.025n

.meas tran vdout0_73ck680 FIND v(dout0_73) AT=345.025n

.meas tran vdout0_74ck680 FIND v(dout0_74) AT=345.025n

.meas tran vdout0_75ck680 FIND v(dout0_75) AT=345.025n

.meas tran vdout0_76ck680 FIND v(dout0_76) AT=345.025n

.meas tran vdout0_77ck680 FIND v(dout0_77) AT=345.025n

.meas tran vdout0_78ck680 FIND v(dout0_78) AT=345.025n

.meas tran vdout0_79ck680 FIND v(dout0_79) AT=345.025n

.meas tran vdout0_80ck680 FIND v(dout0_80) AT=345.025n

.meas tran vdout0_81ck680 FIND v(dout0_81) AT=345.025n

.meas tran vdout0_82ck680 FIND v(dout0_82) AT=345.025n

.meas tran vdout0_83ck680 FIND v(dout0_83) AT=345.025n

.meas tran vdout0_84ck680 FIND v(dout0_84) AT=345.025n

.meas tran vdout0_85ck680 FIND v(dout0_85) AT=345.025n

.meas tran vdout0_86ck680 FIND v(dout0_86) AT=345.025n

.meas tran vdout0_87ck680 FIND v(dout0_87) AT=345.025n

.meas tran vdout0_88ck680 FIND v(dout0_88) AT=345.025n

.meas tran vdout0_89ck680 FIND v(dout0_89) AT=345.025n

.meas tran vdout0_90ck680 FIND v(dout0_90) AT=345.025n

.meas tran vdout0_91ck680 FIND v(dout0_91) AT=345.025n

.meas tran vdout0_92ck680 FIND v(dout0_92) AT=345.025n

.meas tran vdout0_93ck680 FIND v(dout0_93) AT=345.025n

.meas tran vdout0_94ck680 FIND v(dout0_94) AT=345.025n

.meas tran vdout0_95ck680 FIND v(dout0_95) AT=345.025n

.meas tran vdout0_96ck680 FIND v(dout0_96) AT=345.025n

.meas tran vdout0_97ck680 FIND v(dout0_97) AT=345.025n

.meas tran vdout0_98ck680 FIND v(dout0_98) AT=345.025n

.meas tran vdout0_99ck680 FIND v(dout0_99) AT=345.025n

.meas tran vdout0_100ck680 FIND v(dout0_100) AT=345.025n

.meas tran vdout0_101ck680 FIND v(dout0_101) AT=345.025n

.meas tran vdout0_102ck680 FIND v(dout0_102) AT=345.025n

.meas tran vdout0_103ck680 FIND v(dout0_103) AT=345.025n

.meas tran vdout0_104ck680 FIND v(dout0_104) AT=345.025n

.meas tran vdout0_105ck680 FIND v(dout0_105) AT=345.025n

.meas tran vdout0_106ck680 FIND v(dout0_106) AT=345.025n

.meas tran vdout0_107ck680 FIND v(dout0_107) AT=345.025n

.meas tran vdout0_108ck680 FIND v(dout0_108) AT=345.025n

.meas tran vdout0_109ck680 FIND v(dout0_109) AT=345.025n

.meas tran vdout0_110ck680 FIND v(dout0_110) AT=345.025n

.meas tran vdout0_111ck680 FIND v(dout0_111) AT=345.025n

.meas tran vdout0_112ck680 FIND v(dout0_112) AT=345.025n

.meas tran vdout0_113ck680 FIND v(dout0_113) AT=345.025n

.meas tran vdout0_114ck680 FIND v(dout0_114) AT=345.025n

.meas tran vdout0_115ck680 FIND v(dout0_115) AT=345.025n

.meas tran vdout0_116ck680 FIND v(dout0_116) AT=345.025n

.meas tran vdout0_117ck680 FIND v(dout0_117) AT=345.025n

.meas tran vdout0_118ck680 FIND v(dout0_118) AT=345.025n

.meas tran vdout0_119ck680 FIND v(dout0_119) AT=345.025n

.meas tran vdout0_120ck680 FIND v(dout0_120) AT=345.025n

.meas tran vdout0_121ck680 FIND v(dout0_121) AT=345.025n

.meas tran vdout0_122ck680 FIND v(dout0_122) AT=345.025n

.meas tran vdout0_123ck680 FIND v(dout0_123) AT=345.025n

.meas tran vdout0_124ck680 FIND v(dout0_124) AT=345.025n

.meas tran vdout0_125ck680 FIND v(dout0_125) AT=345.025n

.meas tran vdout0_126ck680 FIND v(dout0_126) AT=345.025n

.meas tran vdout0_127ck680 FIND v(dout0_127) AT=345.025n

.meas tran vdout0_128ck680 FIND v(dout0_128) AT=345.025n

.meas tran vdout0_129ck680 FIND v(dout0_129) AT=345.025n

.meas tran vdout0_130ck680 FIND v(dout0_130) AT=345.025n

.meas tran vdout0_131ck680 FIND v(dout0_131) AT=345.025n

.meas tran vdout0_132ck680 FIND v(dout0_132) AT=345.025n

.meas tran vdout0_133ck680 FIND v(dout0_133) AT=345.025n

.meas tran vdout0_134ck680 FIND v(dout0_134) AT=345.025n

.meas tran vdout0_135ck680 FIND v(dout0_135) AT=345.025n

.meas tran vdout0_136ck680 FIND v(dout0_136) AT=345.025n

.meas tran vdout0_137ck680 FIND v(dout0_137) AT=345.025n

.meas tran vdout0_138ck680 FIND v(dout0_138) AT=345.025n

.meas tran vdout0_139ck680 FIND v(dout0_139) AT=345.025n

.meas tran vdout0_140ck680 FIND v(dout0_140) AT=345.025n

.meas tran vdout0_141ck680 FIND v(dout0_141) AT=345.025n

.meas tran vdout0_142ck680 FIND v(dout0_142) AT=345.025n

.meas tran vdout0_143ck680 FIND v(dout0_143) AT=345.025n

.meas tran vdout0_144ck680 FIND v(dout0_144) AT=345.025n

.meas tran vdout0_145ck680 FIND v(dout0_145) AT=345.025n

.meas tran vdout0_146ck680 FIND v(dout0_146) AT=345.025n

.meas tran vdout0_147ck680 FIND v(dout0_147) AT=345.025n

.meas tran vdout0_148ck680 FIND v(dout0_148) AT=345.025n

.meas tran vdout0_149ck680 FIND v(dout0_149) AT=345.025n

.meas tran vdout0_150ck680 FIND v(dout0_150) AT=345.025n

.meas tran vdout0_151ck680 FIND v(dout0_151) AT=345.025n

.meas tran vdout0_152ck680 FIND v(dout0_152) AT=345.025n

.meas tran vdout0_153ck680 FIND v(dout0_153) AT=345.025n

.meas tran vdout0_154ck680 FIND v(dout0_154) AT=345.025n

.meas tran vdout0_155ck680 FIND v(dout0_155) AT=345.025n

.meas tran vdout0_156ck680 FIND v(dout0_156) AT=345.025n

.meas tran vdout0_157ck680 FIND v(dout0_157) AT=345.025n

.meas tran vdout0_158ck680 FIND v(dout0_158) AT=345.025n

.meas tran vdout0_159ck680 FIND v(dout0_159) AT=345.025n

.meas tran vdout0_160ck680 FIND v(dout0_160) AT=345.025n

.meas tran vdout0_161ck680 FIND v(dout0_161) AT=345.025n

.meas tran vdout0_162ck680 FIND v(dout0_162) AT=345.025n

.meas tran vdout0_163ck680 FIND v(dout0_163) AT=345.025n

.meas tran vdout0_164ck680 FIND v(dout0_164) AT=345.025n

.meas tran vdout0_165ck680 FIND v(dout0_165) AT=345.025n

.meas tran vdout0_166ck680 FIND v(dout0_166) AT=345.025n

.meas tran vdout0_167ck680 FIND v(dout0_167) AT=345.025n

.meas tran vdout0_168ck680 FIND v(dout0_168) AT=345.025n

.meas tran vdout0_169ck680 FIND v(dout0_169) AT=345.025n

.meas tran vdout0_170ck680 FIND v(dout0_170) AT=345.025n

.meas tran vdout0_171ck680 FIND v(dout0_171) AT=345.025n

.meas tran vdout0_172ck680 FIND v(dout0_172) AT=345.025n

.meas tran vdout0_173ck680 FIND v(dout0_173) AT=345.025n

.meas tran vdout0_174ck680 FIND v(dout0_174) AT=345.025n

.meas tran vdout0_175ck680 FIND v(dout0_175) AT=345.025n

.meas tran vdout0_176ck680 FIND v(dout0_176) AT=345.025n

.meas tran vdout0_177ck680 FIND v(dout0_177) AT=345.025n

.meas tran vdout0_178ck680 FIND v(dout0_178) AT=345.025n

.meas tran vdout0_179ck680 FIND v(dout0_179) AT=345.025n

.meas tran vdout0_180ck680 FIND v(dout0_180) AT=345.025n

.meas tran vdout0_181ck680 FIND v(dout0_181) AT=345.025n

.meas tran vdout0_182ck680 FIND v(dout0_182) AT=345.025n

.meas tran vdout0_183ck680 FIND v(dout0_183) AT=345.025n

.meas tran vdout0_184ck680 FIND v(dout0_184) AT=345.025n

.meas tran vdout0_185ck680 FIND v(dout0_185) AT=345.025n

.meas tran vdout0_186ck680 FIND v(dout0_186) AT=345.025n

.meas tran vdout0_187ck680 FIND v(dout0_187) AT=345.025n

.meas tran vdout0_188ck680 FIND v(dout0_188) AT=345.025n

.meas tran vdout0_189ck680 FIND v(dout0_189) AT=345.025n

.meas tran vdout0_190ck680 FIND v(dout0_190) AT=345.025n

.meas tran vdout0_191ck680 FIND v(dout0_191) AT=345.025n

.meas tran vdout0_192ck680 FIND v(dout0_192) AT=345.025n

.meas tran vdout0_193ck680 FIND v(dout0_193) AT=345.025n

.meas tran vdout0_194ck680 FIND v(dout0_194) AT=345.025n

.meas tran vdout0_195ck680 FIND v(dout0_195) AT=345.025n

.meas tran vdout0_196ck680 FIND v(dout0_196) AT=345.025n

.meas tran vdout0_197ck680 FIND v(dout0_197) AT=345.025n

.meas tran vdout0_198ck680 FIND v(dout0_198) AT=345.025n

.meas tran vdout0_199ck680 FIND v(dout0_199) AT=345.025n

.meas tran vdout0_200ck680 FIND v(dout0_200) AT=345.025n

.meas tran vdout0_201ck680 FIND v(dout0_201) AT=345.025n

.meas tran vdout0_202ck680 FIND v(dout0_202) AT=345.025n

.meas tran vdout0_203ck680 FIND v(dout0_203) AT=345.025n

.meas tran vdout0_204ck680 FIND v(dout0_204) AT=345.025n

.meas tran vdout0_205ck680 FIND v(dout0_205) AT=345.025n

.meas tran vdout0_206ck680 FIND v(dout0_206) AT=345.025n

.meas tran vdout0_207ck680 FIND v(dout0_207) AT=345.025n

.meas tran vdout0_208ck680 FIND v(dout0_208) AT=345.025n

.meas tran vdout0_209ck680 FIND v(dout0_209) AT=345.025n

.meas tran vdout0_210ck680 FIND v(dout0_210) AT=345.025n

.meas tran vdout0_211ck680 FIND v(dout0_211) AT=345.025n

.meas tran vdout0_212ck680 FIND v(dout0_212) AT=345.025n

.meas tran vdout0_213ck680 FIND v(dout0_213) AT=345.025n

.meas tran vdout0_214ck680 FIND v(dout0_214) AT=345.025n

.meas tran vdout0_215ck680 FIND v(dout0_215) AT=345.025n

.meas tran vdout0_216ck680 FIND v(dout0_216) AT=345.025n

.meas tran vdout0_217ck680 FIND v(dout0_217) AT=345.025n

.meas tran vdout0_218ck680 FIND v(dout0_218) AT=345.025n

.meas tran vdout0_219ck680 FIND v(dout0_219) AT=345.025n

.meas tran vdout0_220ck680 FIND v(dout0_220) AT=345.025n

.meas tran vdout0_221ck680 FIND v(dout0_221) AT=345.025n

.meas tran vdout0_222ck680 FIND v(dout0_222) AT=345.025n

.meas tran vdout0_223ck680 FIND v(dout0_223) AT=345.025n

.meas tran vdout0_224ck680 FIND v(dout0_224) AT=345.025n

.meas tran vdout0_225ck680 FIND v(dout0_225) AT=345.025n

.meas tran vdout0_226ck680 FIND v(dout0_226) AT=345.025n

.meas tran vdout0_227ck680 FIND v(dout0_227) AT=345.025n

.meas tran vdout0_228ck680 FIND v(dout0_228) AT=345.025n

.meas tran vdout0_229ck680 FIND v(dout0_229) AT=345.025n

.meas tran vdout0_230ck680 FIND v(dout0_230) AT=345.025n

.meas tran vdout0_231ck680 FIND v(dout0_231) AT=345.025n

.meas tran vdout0_232ck680 FIND v(dout0_232) AT=345.025n

.meas tran vdout0_233ck680 FIND v(dout0_233) AT=345.025n

.meas tran vdout0_234ck680 FIND v(dout0_234) AT=345.025n

.meas tran vdout0_235ck680 FIND v(dout0_235) AT=345.025n

.meas tran vdout0_236ck680 FIND v(dout0_236) AT=345.025n

.meas tran vdout0_237ck680 FIND v(dout0_237) AT=345.025n

.meas tran vdout0_238ck680 FIND v(dout0_238) AT=345.025n

.meas tran vdout0_239ck680 FIND v(dout0_239) AT=345.025n

.meas tran vdout0_240ck680 FIND v(dout0_240) AT=345.025n

.meas tran vdout0_241ck680 FIND v(dout0_241) AT=345.025n

.meas tran vdout0_242ck680 FIND v(dout0_242) AT=345.025n

.meas tran vdout0_243ck680 FIND v(dout0_243) AT=345.025n

.meas tran vdout0_244ck680 FIND v(dout0_244) AT=345.025n

.meas tran vdout0_245ck680 FIND v(dout0_245) AT=345.025n

.meas tran vdout0_246ck680 FIND v(dout0_246) AT=345.025n

.meas tran vdout0_247ck680 FIND v(dout0_247) AT=345.025n

.meas tran vdout0_248ck680 FIND v(dout0_248) AT=345.025n

.meas tran vdout0_249ck680 FIND v(dout0_249) AT=345.025n

.meas tran vdout0_250ck680 FIND v(dout0_250) AT=345.025n

.meas tran vdout0_251ck680 FIND v(dout0_251) AT=345.025n

.meas tran vdout0_252ck680 FIND v(dout0_252) AT=345.025n

.meas tran vdout0_253ck680 FIND v(dout0_253) AT=345.025n

.meas tran vdout0_254ck680 FIND v(dout0_254) AT=345.025n

.meas tran vdout0_255ck680 FIND v(dout0_255) AT=345.025n

.meas tran vdout0_0ck700 FIND v(dout0_0) AT=355.025n

.meas tran vdout0_1ck700 FIND v(dout0_1) AT=355.025n

.meas tran vdout0_2ck700 FIND v(dout0_2) AT=355.025n

.meas tran vdout0_3ck700 FIND v(dout0_3) AT=355.025n

.meas tran vdout0_4ck700 FIND v(dout0_4) AT=355.025n

.meas tran vdout0_5ck700 FIND v(dout0_5) AT=355.025n

.meas tran vdout0_6ck700 FIND v(dout0_6) AT=355.025n

.meas tran vdout0_7ck700 FIND v(dout0_7) AT=355.025n

.meas tran vdout0_8ck700 FIND v(dout0_8) AT=355.025n

.meas tran vdout0_9ck700 FIND v(dout0_9) AT=355.025n

.meas tran vdout0_10ck700 FIND v(dout0_10) AT=355.025n

.meas tran vdout0_11ck700 FIND v(dout0_11) AT=355.025n

.meas tran vdout0_12ck700 FIND v(dout0_12) AT=355.025n

.meas tran vdout0_13ck700 FIND v(dout0_13) AT=355.025n

.meas tran vdout0_14ck700 FIND v(dout0_14) AT=355.025n

.meas tran vdout0_15ck700 FIND v(dout0_15) AT=355.025n

.meas tran vdout0_16ck700 FIND v(dout0_16) AT=355.025n

.meas tran vdout0_17ck700 FIND v(dout0_17) AT=355.025n

.meas tran vdout0_18ck700 FIND v(dout0_18) AT=355.025n

.meas tran vdout0_19ck700 FIND v(dout0_19) AT=355.025n

.meas tran vdout0_20ck700 FIND v(dout0_20) AT=355.025n

.meas tran vdout0_21ck700 FIND v(dout0_21) AT=355.025n

.meas tran vdout0_22ck700 FIND v(dout0_22) AT=355.025n

.meas tran vdout0_23ck700 FIND v(dout0_23) AT=355.025n

.meas tran vdout0_24ck700 FIND v(dout0_24) AT=355.025n

.meas tran vdout0_25ck700 FIND v(dout0_25) AT=355.025n

.meas tran vdout0_26ck700 FIND v(dout0_26) AT=355.025n

.meas tran vdout0_27ck700 FIND v(dout0_27) AT=355.025n

.meas tran vdout0_28ck700 FIND v(dout0_28) AT=355.025n

.meas tran vdout0_29ck700 FIND v(dout0_29) AT=355.025n

.meas tran vdout0_30ck700 FIND v(dout0_30) AT=355.025n

.meas tran vdout0_31ck700 FIND v(dout0_31) AT=355.025n

.meas tran vdout0_32ck700 FIND v(dout0_32) AT=355.025n

.meas tran vdout0_33ck700 FIND v(dout0_33) AT=355.025n

.meas tran vdout0_34ck700 FIND v(dout0_34) AT=355.025n

.meas tran vdout0_35ck700 FIND v(dout0_35) AT=355.025n

.meas tran vdout0_36ck700 FIND v(dout0_36) AT=355.025n

.meas tran vdout0_37ck700 FIND v(dout0_37) AT=355.025n

.meas tran vdout0_38ck700 FIND v(dout0_38) AT=355.025n

.meas tran vdout0_39ck700 FIND v(dout0_39) AT=355.025n

.meas tran vdout0_40ck700 FIND v(dout0_40) AT=355.025n

.meas tran vdout0_41ck700 FIND v(dout0_41) AT=355.025n

.meas tran vdout0_42ck700 FIND v(dout0_42) AT=355.025n

.meas tran vdout0_43ck700 FIND v(dout0_43) AT=355.025n

.meas tran vdout0_44ck700 FIND v(dout0_44) AT=355.025n

.meas tran vdout0_45ck700 FIND v(dout0_45) AT=355.025n

.meas tran vdout0_46ck700 FIND v(dout0_46) AT=355.025n

.meas tran vdout0_47ck700 FIND v(dout0_47) AT=355.025n

.meas tran vdout0_48ck700 FIND v(dout0_48) AT=355.025n

.meas tran vdout0_49ck700 FIND v(dout0_49) AT=355.025n

.meas tran vdout0_50ck700 FIND v(dout0_50) AT=355.025n

.meas tran vdout0_51ck700 FIND v(dout0_51) AT=355.025n

.meas tran vdout0_52ck700 FIND v(dout0_52) AT=355.025n

.meas tran vdout0_53ck700 FIND v(dout0_53) AT=355.025n

.meas tran vdout0_54ck700 FIND v(dout0_54) AT=355.025n

.meas tran vdout0_55ck700 FIND v(dout0_55) AT=355.025n

.meas tran vdout0_56ck700 FIND v(dout0_56) AT=355.025n

.meas tran vdout0_57ck700 FIND v(dout0_57) AT=355.025n

.meas tran vdout0_58ck700 FIND v(dout0_58) AT=355.025n

.meas tran vdout0_59ck700 FIND v(dout0_59) AT=355.025n

.meas tran vdout0_60ck700 FIND v(dout0_60) AT=355.025n

.meas tran vdout0_61ck700 FIND v(dout0_61) AT=355.025n

.meas tran vdout0_62ck700 FIND v(dout0_62) AT=355.025n

.meas tran vdout0_63ck700 FIND v(dout0_63) AT=355.025n

.meas tran vdout0_64ck700 FIND v(dout0_64) AT=355.025n

.meas tran vdout0_65ck700 FIND v(dout0_65) AT=355.025n

.meas tran vdout0_66ck700 FIND v(dout0_66) AT=355.025n

.meas tran vdout0_67ck700 FIND v(dout0_67) AT=355.025n

.meas tran vdout0_68ck700 FIND v(dout0_68) AT=355.025n

.meas tran vdout0_69ck700 FIND v(dout0_69) AT=355.025n

.meas tran vdout0_70ck700 FIND v(dout0_70) AT=355.025n

.meas tran vdout0_71ck700 FIND v(dout0_71) AT=355.025n

.meas tran vdout0_72ck700 FIND v(dout0_72) AT=355.025n

.meas tran vdout0_73ck700 FIND v(dout0_73) AT=355.025n

.meas tran vdout0_74ck700 FIND v(dout0_74) AT=355.025n

.meas tran vdout0_75ck700 FIND v(dout0_75) AT=355.025n

.meas tran vdout0_76ck700 FIND v(dout0_76) AT=355.025n

.meas tran vdout0_77ck700 FIND v(dout0_77) AT=355.025n

.meas tran vdout0_78ck700 FIND v(dout0_78) AT=355.025n

.meas tran vdout0_79ck700 FIND v(dout0_79) AT=355.025n

.meas tran vdout0_80ck700 FIND v(dout0_80) AT=355.025n

.meas tran vdout0_81ck700 FIND v(dout0_81) AT=355.025n

.meas tran vdout0_82ck700 FIND v(dout0_82) AT=355.025n

.meas tran vdout0_83ck700 FIND v(dout0_83) AT=355.025n

.meas tran vdout0_84ck700 FIND v(dout0_84) AT=355.025n

.meas tran vdout0_85ck700 FIND v(dout0_85) AT=355.025n

.meas tran vdout0_86ck700 FIND v(dout0_86) AT=355.025n

.meas tran vdout0_87ck700 FIND v(dout0_87) AT=355.025n

.meas tran vdout0_88ck700 FIND v(dout0_88) AT=355.025n

.meas tran vdout0_89ck700 FIND v(dout0_89) AT=355.025n

.meas tran vdout0_90ck700 FIND v(dout0_90) AT=355.025n

.meas tran vdout0_91ck700 FIND v(dout0_91) AT=355.025n

.meas tran vdout0_92ck700 FIND v(dout0_92) AT=355.025n

.meas tran vdout0_93ck700 FIND v(dout0_93) AT=355.025n

.meas tran vdout0_94ck700 FIND v(dout0_94) AT=355.025n

.meas tran vdout0_95ck700 FIND v(dout0_95) AT=355.025n

.meas tran vdout0_96ck700 FIND v(dout0_96) AT=355.025n

.meas tran vdout0_97ck700 FIND v(dout0_97) AT=355.025n

.meas tran vdout0_98ck700 FIND v(dout0_98) AT=355.025n

.meas tran vdout0_99ck700 FIND v(dout0_99) AT=355.025n

.meas tran vdout0_100ck700 FIND v(dout0_100) AT=355.025n

.meas tran vdout0_101ck700 FIND v(dout0_101) AT=355.025n

.meas tran vdout0_102ck700 FIND v(dout0_102) AT=355.025n

.meas tran vdout0_103ck700 FIND v(dout0_103) AT=355.025n

.meas tran vdout0_104ck700 FIND v(dout0_104) AT=355.025n

.meas tran vdout0_105ck700 FIND v(dout0_105) AT=355.025n

.meas tran vdout0_106ck700 FIND v(dout0_106) AT=355.025n

.meas tran vdout0_107ck700 FIND v(dout0_107) AT=355.025n

.meas tran vdout0_108ck700 FIND v(dout0_108) AT=355.025n

.meas tran vdout0_109ck700 FIND v(dout0_109) AT=355.025n

.meas tran vdout0_110ck700 FIND v(dout0_110) AT=355.025n

.meas tran vdout0_111ck700 FIND v(dout0_111) AT=355.025n

.meas tran vdout0_112ck700 FIND v(dout0_112) AT=355.025n

.meas tran vdout0_113ck700 FIND v(dout0_113) AT=355.025n

.meas tran vdout0_114ck700 FIND v(dout0_114) AT=355.025n

.meas tran vdout0_115ck700 FIND v(dout0_115) AT=355.025n

.meas tran vdout0_116ck700 FIND v(dout0_116) AT=355.025n

.meas tran vdout0_117ck700 FIND v(dout0_117) AT=355.025n

.meas tran vdout0_118ck700 FIND v(dout0_118) AT=355.025n

.meas tran vdout0_119ck700 FIND v(dout0_119) AT=355.025n

.meas tran vdout0_120ck700 FIND v(dout0_120) AT=355.025n

.meas tran vdout0_121ck700 FIND v(dout0_121) AT=355.025n

.meas tran vdout0_122ck700 FIND v(dout0_122) AT=355.025n

.meas tran vdout0_123ck700 FIND v(dout0_123) AT=355.025n

.meas tran vdout0_124ck700 FIND v(dout0_124) AT=355.025n

.meas tran vdout0_125ck700 FIND v(dout0_125) AT=355.025n

.meas tran vdout0_126ck700 FIND v(dout0_126) AT=355.025n

.meas tran vdout0_127ck700 FIND v(dout0_127) AT=355.025n

.meas tran vdout0_128ck700 FIND v(dout0_128) AT=355.025n

.meas tran vdout0_129ck700 FIND v(dout0_129) AT=355.025n

.meas tran vdout0_130ck700 FIND v(dout0_130) AT=355.025n

.meas tran vdout0_131ck700 FIND v(dout0_131) AT=355.025n

.meas tran vdout0_132ck700 FIND v(dout0_132) AT=355.025n

.meas tran vdout0_133ck700 FIND v(dout0_133) AT=355.025n

.meas tran vdout0_134ck700 FIND v(dout0_134) AT=355.025n

.meas tran vdout0_135ck700 FIND v(dout0_135) AT=355.025n

.meas tran vdout0_136ck700 FIND v(dout0_136) AT=355.025n

.meas tran vdout0_137ck700 FIND v(dout0_137) AT=355.025n

.meas tran vdout0_138ck700 FIND v(dout0_138) AT=355.025n

.meas tran vdout0_139ck700 FIND v(dout0_139) AT=355.025n

.meas tran vdout0_140ck700 FIND v(dout0_140) AT=355.025n

.meas tran vdout0_141ck700 FIND v(dout0_141) AT=355.025n

.meas tran vdout0_142ck700 FIND v(dout0_142) AT=355.025n

.meas tran vdout0_143ck700 FIND v(dout0_143) AT=355.025n

.meas tran vdout0_144ck700 FIND v(dout0_144) AT=355.025n

.meas tran vdout0_145ck700 FIND v(dout0_145) AT=355.025n

.meas tran vdout0_146ck700 FIND v(dout0_146) AT=355.025n

.meas tran vdout0_147ck700 FIND v(dout0_147) AT=355.025n

.meas tran vdout0_148ck700 FIND v(dout0_148) AT=355.025n

.meas tran vdout0_149ck700 FIND v(dout0_149) AT=355.025n

.meas tran vdout0_150ck700 FIND v(dout0_150) AT=355.025n

.meas tran vdout0_151ck700 FIND v(dout0_151) AT=355.025n

.meas tran vdout0_152ck700 FIND v(dout0_152) AT=355.025n

.meas tran vdout0_153ck700 FIND v(dout0_153) AT=355.025n

.meas tran vdout0_154ck700 FIND v(dout0_154) AT=355.025n

.meas tran vdout0_155ck700 FIND v(dout0_155) AT=355.025n

.meas tran vdout0_156ck700 FIND v(dout0_156) AT=355.025n

.meas tran vdout0_157ck700 FIND v(dout0_157) AT=355.025n

.meas tran vdout0_158ck700 FIND v(dout0_158) AT=355.025n

.meas tran vdout0_159ck700 FIND v(dout0_159) AT=355.025n

.meas tran vdout0_160ck700 FIND v(dout0_160) AT=355.025n

.meas tran vdout0_161ck700 FIND v(dout0_161) AT=355.025n

.meas tran vdout0_162ck700 FIND v(dout0_162) AT=355.025n

.meas tran vdout0_163ck700 FIND v(dout0_163) AT=355.025n

.meas tran vdout0_164ck700 FIND v(dout0_164) AT=355.025n

.meas tran vdout0_165ck700 FIND v(dout0_165) AT=355.025n

.meas tran vdout0_166ck700 FIND v(dout0_166) AT=355.025n

.meas tran vdout0_167ck700 FIND v(dout0_167) AT=355.025n

.meas tran vdout0_168ck700 FIND v(dout0_168) AT=355.025n

.meas tran vdout0_169ck700 FIND v(dout0_169) AT=355.025n

.meas tran vdout0_170ck700 FIND v(dout0_170) AT=355.025n

.meas tran vdout0_171ck700 FIND v(dout0_171) AT=355.025n

.meas tran vdout0_172ck700 FIND v(dout0_172) AT=355.025n

.meas tran vdout0_173ck700 FIND v(dout0_173) AT=355.025n

.meas tran vdout0_174ck700 FIND v(dout0_174) AT=355.025n

.meas tran vdout0_175ck700 FIND v(dout0_175) AT=355.025n

.meas tran vdout0_176ck700 FIND v(dout0_176) AT=355.025n

.meas tran vdout0_177ck700 FIND v(dout0_177) AT=355.025n

.meas tran vdout0_178ck700 FIND v(dout0_178) AT=355.025n

.meas tran vdout0_179ck700 FIND v(dout0_179) AT=355.025n

.meas tran vdout0_180ck700 FIND v(dout0_180) AT=355.025n

.meas tran vdout0_181ck700 FIND v(dout0_181) AT=355.025n

.meas tran vdout0_182ck700 FIND v(dout0_182) AT=355.025n

.meas tran vdout0_183ck700 FIND v(dout0_183) AT=355.025n

.meas tran vdout0_184ck700 FIND v(dout0_184) AT=355.025n

.meas tran vdout0_185ck700 FIND v(dout0_185) AT=355.025n

.meas tran vdout0_186ck700 FIND v(dout0_186) AT=355.025n

.meas tran vdout0_187ck700 FIND v(dout0_187) AT=355.025n

.meas tran vdout0_188ck700 FIND v(dout0_188) AT=355.025n

.meas tran vdout0_189ck700 FIND v(dout0_189) AT=355.025n

.meas tran vdout0_190ck700 FIND v(dout0_190) AT=355.025n

.meas tran vdout0_191ck700 FIND v(dout0_191) AT=355.025n

.meas tran vdout0_192ck700 FIND v(dout0_192) AT=355.025n

.meas tran vdout0_193ck700 FIND v(dout0_193) AT=355.025n

.meas tran vdout0_194ck700 FIND v(dout0_194) AT=355.025n

.meas tran vdout0_195ck700 FIND v(dout0_195) AT=355.025n

.meas tran vdout0_196ck700 FIND v(dout0_196) AT=355.025n

.meas tran vdout0_197ck700 FIND v(dout0_197) AT=355.025n

.meas tran vdout0_198ck700 FIND v(dout0_198) AT=355.025n

.meas tran vdout0_199ck700 FIND v(dout0_199) AT=355.025n

.meas tran vdout0_200ck700 FIND v(dout0_200) AT=355.025n

.meas tran vdout0_201ck700 FIND v(dout0_201) AT=355.025n

.meas tran vdout0_202ck700 FIND v(dout0_202) AT=355.025n

.meas tran vdout0_203ck700 FIND v(dout0_203) AT=355.025n

.meas tran vdout0_204ck700 FIND v(dout0_204) AT=355.025n

.meas tran vdout0_205ck700 FIND v(dout0_205) AT=355.025n

.meas tran vdout0_206ck700 FIND v(dout0_206) AT=355.025n

.meas tran vdout0_207ck700 FIND v(dout0_207) AT=355.025n

.meas tran vdout0_208ck700 FIND v(dout0_208) AT=355.025n

.meas tran vdout0_209ck700 FIND v(dout0_209) AT=355.025n

.meas tran vdout0_210ck700 FIND v(dout0_210) AT=355.025n

.meas tran vdout0_211ck700 FIND v(dout0_211) AT=355.025n

.meas tran vdout0_212ck700 FIND v(dout0_212) AT=355.025n

.meas tran vdout0_213ck700 FIND v(dout0_213) AT=355.025n

.meas tran vdout0_214ck700 FIND v(dout0_214) AT=355.025n

.meas tran vdout0_215ck700 FIND v(dout0_215) AT=355.025n

.meas tran vdout0_216ck700 FIND v(dout0_216) AT=355.025n

.meas tran vdout0_217ck700 FIND v(dout0_217) AT=355.025n

.meas tran vdout0_218ck700 FIND v(dout0_218) AT=355.025n

.meas tran vdout0_219ck700 FIND v(dout0_219) AT=355.025n

.meas tran vdout0_220ck700 FIND v(dout0_220) AT=355.025n

.meas tran vdout0_221ck700 FIND v(dout0_221) AT=355.025n

.meas tran vdout0_222ck700 FIND v(dout0_222) AT=355.025n

.meas tran vdout0_223ck700 FIND v(dout0_223) AT=355.025n

.meas tran vdout0_224ck700 FIND v(dout0_224) AT=355.025n

.meas tran vdout0_225ck700 FIND v(dout0_225) AT=355.025n

.meas tran vdout0_226ck700 FIND v(dout0_226) AT=355.025n

.meas tran vdout0_227ck700 FIND v(dout0_227) AT=355.025n

.meas tran vdout0_228ck700 FIND v(dout0_228) AT=355.025n

.meas tran vdout0_229ck700 FIND v(dout0_229) AT=355.025n

.meas tran vdout0_230ck700 FIND v(dout0_230) AT=355.025n

.meas tran vdout0_231ck700 FIND v(dout0_231) AT=355.025n

.meas tran vdout0_232ck700 FIND v(dout0_232) AT=355.025n

.meas tran vdout0_233ck700 FIND v(dout0_233) AT=355.025n

.meas tran vdout0_234ck700 FIND v(dout0_234) AT=355.025n

.meas tran vdout0_235ck700 FIND v(dout0_235) AT=355.025n

.meas tran vdout0_236ck700 FIND v(dout0_236) AT=355.025n

.meas tran vdout0_237ck700 FIND v(dout0_237) AT=355.025n

.meas tran vdout0_238ck700 FIND v(dout0_238) AT=355.025n

.meas tran vdout0_239ck700 FIND v(dout0_239) AT=355.025n

.meas tran vdout0_240ck700 FIND v(dout0_240) AT=355.025n

.meas tran vdout0_241ck700 FIND v(dout0_241) AT=355.025n

.meas tran vdout0_242ck700 FIND v(dout0_242) AT=355.025n

.meas tran vdout0_243ck700 FIND v(dout0_243) AT=355.025n

.meas tran vdout0_244ck700 FIND v(dout0_244) AT=355.025n

.meas tran vdout0_245ck700 FIND v(dout0_245) AT=355.025n

.meas tran vdout0_246ck700 FIND v(dout0_246) AT=355.025n

.meas tran vdout0_247ck700 FIND v(dout0_247) AT=355.025n

.meas tran vdout0_248ck700 FIND v(dout0_248) AT=355.025n

.meas tran vdout0_249ck700 FIND v(dout0_249) AT=355.025n

.meas tran vdout0_250ck700 FIND v(dout0_250) AT=355.025n

.meas tran vdout0_251ck700 FIND v(dout0_251) AT=355.025n

.meas tran vdout0_252ck700 FIND v(dout0_252) AT=355.025n

.meas tran vdout0_253ck700 FIND v(dout0_253) AT=355.025n

.meas tran vdout0_254ck700 FIND v(dout0_254) AT=355.025n

.meas tran vdout0_255ck700 FIND v(dout0_255) AT=355.025n

.meas tran vdout0_0ck730 FIND v(dout0_0) AT=370.025n

.meas tran vdout0_1ck730 FIND v(dout0_1) AT=370.025n

.meas tran vdout0_2ck730 FIND v(dout0_2) AT=370.025n

.meas tran vdout0_3ck730 FIND v(dout0_3) AT=370.025n

.meas tran vdout0_4ck730 FIND v(dout0_4) AT=370.025n

.meas tran vdout0_5ck730 FIND v(dout0_5) AT=370.025n

.meas tran vdout0_6ck730 FIND v(dout0_6) AT=370.025n

.meas tran vdout0_7ck730 FIND v(dout0_7) AT=370.025n

.meas tran vdout0_8ck730 FIND v(dout0_8) AT=370.025n

.meas tran vdout0_9ck730 FIND v(dout0_9) AT=370.025n

.meas tran vdout0_10ck730 FIND v(dout0_10) AT=370.025n

.meas tran vdout0_11ck730 FIND v(dout0_11) AT=370.025n

.meas tran vdout0_12ck730 FIND v(dout0_12) AT=370.025n

.meas tran vdout0_13ck730 FIND v(dout0_13) AT=370.025n

.meas tran vdout0_14ck730 FIND v(dout0_14) AT=370.025n

.meas tran vdout0_15ck730 FIND v(dout0_15) AT=370.025n

.meas tran vdout0_16ck730 FIND v(dout0_16) AT=370.025n

.meas tran vdout0_17ck730 FIND v(dout0_17) AT=370.025n

.meas tran vdout0_18ck730 FIND v(dout0_18) AT=370.025n

.meas tran vdout0_19ck730 FIND v(dout0_19) AT=370.025n

.meas tran vdout0_20ck730 FIND v(dout0_20) AT=370.025n

.meas tran vdout0_21ck730 FIND v(dout0_21) AT=370.025n

.meas tran vdout0_22ck730 FIND v(dout0_22) AT=370.025n

.meas tran vdout0_23ck730 FIND v(dout0_23) AT=370.025n

.meas tran vdout0_24ck730 FIND v(dout0_24) AT=370.025n

.meas tran vdout0_25ck730 FIND v(dout0_25) AT=370.025n

.meas tran vdout0_26ck730 FIND v(dout0_26) AT=370.025n

.meas tran vdout0_27ck730 FIND v(dout0_27) AT=370.025n

.meas tran vdout0_28ck730 FIND v(dout0_28) AT=370.025n

.meas tran vdout0_29ck730 FIND v(dout0_29) AT=370.025n

.meas tran vdout0_30ck730 FIND v(dout0_30) AT=370.025n

.meas tran vdout0_31ck730 FIND v(dout0_31) AT=370.025n

.meas tran vdout0_32ck730 FIND v(dout0_32) AT=370.025n

.meas tran vdout0_33ck730 FIND v(dout0_33) AT=370.025n

.meas tran vdout0_34ck730 FIND v(dout0_34) AT=370.025n

.meas tran vdout0_35ck730 FIND v(dout0_35) AT=370.025n

.meas tran vdout0_36ck730 FIND v(dout0_36) AT=370.025n

.meas tran vdout0_37ck730 FIND v(dout0_37) AT=370.025n

.meas tran vdout0_38ck730 FIND v(dout0_38) AT=370.025n

.meas tran vdout0_39ck730 FIND v(dout0_39) AT=370.025n

.meas tran vdout0_40ck730 FIND v(dout0_40) AT=370.025n

.meas tran vdout0_41ck730 FIND v(dout0_41) AT=370.025n

.meas tran vdout0_42ck730 FIND v(dout0_42) AT=370.025n

.meas tran vdout0_43ck730 FIND v(dout0_43) AT=370.025n

.meas tran vdout0_44ck730 FIND v(dout0_44) AT=370.025n

.meas tran vdout0_45ck730 FIND v(dout0_45) AT=370.025n

.meas tran vdout0_46ck730 FIND v(dout0_46) AT=370.025n

.meas tran vdout0_47ck730 FIND v(dout0_47) AT=370.025n

.meas tran vdout0_48ck730 FIND v(dout0_48) AT=370.025n

.meas tran vdout0_49ck730 FIND v(dout0_49) AT=370.025n

.meas tran vdout0_50ck730 FIND v(dout0_50) AT=370.025n

.meas tran vdout0_51ck730 FIND v(dout0_51) AT=370.025n

.meas tran vdout0_52ck730 FIND v(dout0_52) AT=370.025n

.meas tran vdout0_53ck730 FIND v(dout0_53) AT=370.025n

.meas tran vdout0_54ck730 FIND v(dout0_54) AT=370.025n

.meas tran vdout0_55ck730 FIND v(dout0_55) AT=370.025n

.meas tran vdout0_56ck730 FIND v(dout0_56) AT=370.025n

.meas tran vdout0_57ck730 FIND v(dout0_57) AT=370.025n

.meas tran vdout0_58ck730 FIND v(dout0_58) AT=370.025n

.meas tran vdout0_59ck730 FIND v(dout0_59) AT=370.025n

.meas tran vdout0_60ck730 FIND v(dout0_60) AT=370.025n

.meas tran vdout0_61ck730 FIND v(dout0_61) AT=370.025n

.meas tran vdout0_62ck730 FIND v(dout0_62) AT=370.025n

.meas tran vdout0_63ck730 FIND v(dout0_63) AT=370.025n

.meas tran vdout0_64ck730 FIND v(dout0_64) AT=370.025n

.meas tran vdout0_65ck730 FIND v(dout0_65) AT=370.025n

.meas tran vdout0_66ck730 FIND v(dout0_66) AT=370.025n

.meas tran vdout0_67ck730 FIND v(dout0_67) AT=370.025n

.meas tran vdout0_68ck730 FIND v(dout0_68) AT=370.025n

.meas tran vdout0_69ck730 FIND v(dout0_69) AT=370.025n

.meas tran vdout0_70ck730 FIND v(dout0_70) AT=370.025n

.meas tran vdout0_71ck730 FIND v(dout0_71) AT=370.025n

.meas tran vdout0_72ck730 FIND v(dout0_72) AT=370.025n

.meas tran vdout0_73ck730 FIND v(dout0_73) AT=370.025n

.meas tran vdout0_74ck730 FIND v(dout0_74) AT=370.025n

.meas tran vdout0_75ck730 FIND v(dout0_75) AT=370.025n

.meas tran vdout0_76ck730 FIND v(dout0_76) AT=370.025n

.meas tran vdout0_77ck730 FIND v(dout0_77) AT=370.025n

.meas tran vdout0_78ck730 FIND v(dout0_78) AT=370.025n

.meas tran vdout0_79ck730 FIND v(dout0_79) AT=370.025n

.meas tran vdout0_80ck730 FIND v(dout0_80) AT=370.025n

.meas tran vdout0_81ck730 FIND v(dout0_81) AT=370.025n

.meas tran vdout0_82ck730 FIND v(dout0_82) AT=370.025n

.meas tran vdout0_83ck730 FIND v(dout0_83) AT=370.025n

.meas tran vdout0_84ck730 FIND v(dout0_84) AT=370.025n

.meas tran vdout0_85ck730 FIND v(dout0_85) AT=370.025n

.meas tran vdout0_86ck730 FIND v(dout0_86) AT=370.025n

.meas tran vdout0_87ck730 FIND v(dout0_87) AT=370.025n

.meas tran vdout0_88ck730 FIND v(dout0_88) AT=370.025n

.meas tran vdout0_89ck730 FIND v(dout0_89) AT=370.025n

.meas tran vdout0_90ck730 FIND v(dout0_90) AT=370.025n

.meas tran vdout0_91ck730 FIND v(dout0_91) AT=370.025n

.meas tran vdout0_92ck730 FIND v(dout0_92) AT=370.025n

.meas tran vdout0_93ck730 FIND v(dout0_93) AT=370.025n

.meas tran vdout0_94ck730 FIND v(dout0_94) AT=370.025n

.meas tran vdout0_95ck730 FIND v(dout0_95) AT=370.025n

.meas tran vdout0_96ck730 FIND v(dout0_96) AT=370.025n

.meas tran vdout0_97ck730 FIND v(dout0_97) AT=370.025n

.meas tran vdout0_98ck730 FIND v(dout0_98) AT=370.025n

.meas tran vdout0_99ck730 FIND v(dout0_99) AT=370.025n

.meas tran vdout0_100ck730 FIND v(dout0_100) AT=370.025n

.meas tran vdout0_101ck730 FIND v(dout0_101) AT=370.025n

.meas tran vdout0_102ck730 FIND v(dout0_102) AT=370.025n

.meas tran vdout0_103ck730 FIND v(dout0_103) AT=370.025n

.meas tran vdout0_104ck730 FIND v(dout0_104) AT=370.025n

.meas tran vdout0_105ck730 FIND v(dout0_105) AT=370.025n

.meas tran vdout0_106ck730 FIND v(dout0_106) AT=370.025n

.meas tran vdout0_107ck730 FIND v(dout0_107) AT=370.025n

.meas tran vdout0_108ck730 FIND v(dout0_108) AT=370.025n

.meas tran vdout0_109ck730 FIND v(dout0_109) AT=370.025n

.meas tran vdout0_110ck730 FIND v(dout0_110) AT=370.025n

.meas tran vdout0_111ck730 FIND v(dout0_111) AT=370.025n

.meas tran vdout0_112ck730 FIND v(dout0_112) AT=370.025n

.meas tran vdout0_113ck730 FIND v(dout0_113) AT=370.025n

.meas tran vdout0_114ck730 FIND v(dout0_114) AT=370.025n

.meas tran vdout0_115ck730 FIND v(dout0_115) AT=370.025n

.meas tran vdout0_116ck730 FIND v(dout0_116) AT=370.025n

.meas tran vdout0_117ck730 FIND v(dout0_117) AT=370.025n

.meas tran vdout0_118ck730 FIND v(dout0_118) AT=370.025n

.meas tran vdout0_119ck730 FIND v(dout0_119) AT=370.025n

.meas tran vdout0_120ck730 FIND v(dout0_120) AT=370.025n

.meas tran vdout0_121ck730 FIND v(dout0_121) AT=370.025n

.meas tran vdout0_122ck730 FIND v(dout0_122) AT=370.025n

.meas tran vdout0_123ck730 FIND v(dout0_123) AT=370.025n

.meas tran vdout0_124ck730 FIND v(dout0_124) AT=370.025n

.meas tran vdout0_125ck730 FIND v(dout0_125) AT=370.025n

.meas tran vdout0_126ck730 FIND v(dout0_126) AT=370.025n

.meas tran vdout0_127ck730 FIND v(dout0_127) AT=370.025n

.meas tran vdout0_128ck730 FIND v(dout0_128) AT=370.025n

.meas tran vdout0_129ck730 FIND v(dout0_129) AT=370.025n

.meas tran vdout0_130ck730 FIND v(dout0_130) AT=370.025n

.meas tran vdout0_131ck730 FIND v(dout0_131) AT=370.025n

.meas tran vdout0_132ck730 FIND v(dout0_132) AT=370.025n

.meas tran vdout0_133ck730 FIND v(dout0_133) AT=370.025n

.meas tran vdout0_134ck730 FIND v(dout0_134) AT=370.025n

.meas tran vdout0_135ck730 FIND v(dout0_135) AT=370.025n

.meas tran vdout0_136ck730 FIND v(dout0_136) AT=370.025n

.meas tran vdout0_137ck730 FIND v(dout0_137) AT=370.025n

.meas tran vdout0_138ck730 FIND v(dout0_138) AT=370.025n

.meas tran vdout0_139ck730 FIND v(dout0_139) AT=370.025n

.meas tran vdout0_140ck730 FIND v(dout0_140) AT=370.025n

.meas tran vdout0_141ck730 FIND v(dout0_141) AT=370.025n

.meas tran vdout0_142ck730 FIND v(dout0_142) AT=370.025n

.meas tran vdout0_143ck730 FIND v(dout0_143) AT=370.025n

.meas tran vdout0_144ck730 FIND v(dout0_144) AT=370.025n

.meas tran vdout0_145ck730 FIND v(dout0_145) AT=370.025n

.meas tran vdout0_146ck730 FIND v(dout0_146) AT=370.025n

.meas tran vdout0_147ck730 FIND v(dout0_147) AT=370.025n

.meas tran vdout0_148ck730 FIND v(dout0_148) AT=370.025n

.meas tran vdout0_149ck730 FIND v(dout0_149) AT=370.025n

.meas tran vdout0_150ck730 FIND v(dout0_150) AT=370.025n

.meas tran vdout0_151ck730 FIND v(dout0_151) AT=370.025n

.meas tran vdout0_152ck730 FIND v(dout0_152) AT=370.025n

.meas tran vdout0_153ck730 FIND v(dout0_153) AT=370.025n

.meas tran vdout0_154ck730 FIND v(dout0_154) AT=370.025n

.meas tran vdout0_155ck730 FIND v(dout0_155) AT=370.025n

.meas tran vdout0_156ck730 FIND v(dout0_156) AT=370.025n

.meas tran vdout0_157ck730 FIND v(dout0_157) AT=370.025n

.meas tran vdout0_158ck730 FIND v(dout0_158) AT=370.025n

.meas tran vdout0_159ck730 FIND v(dout0_159) AT=370.025n

.meas tran vdout0_160ck730 FIND v(dout0_160) AT=370.025n

.meas tran vdout0_161ck730 FIND v(dout0_161) AT=370.025n

.meas tran vdout0_162ck730 FIND v(dout0_162) AT=370.025n

.meas tran vdout0_163ck730 FIND v(dout0_163) AT=370.025n

.meas tran vdout0_164ck730 FIND v(dout0_164) AT=370.025n

.meas tran vdout0_165ck730 FIND v(dout0_165) AT=370.025n

.meas tran vdout0_166ck730 FIND v(dout0_166) AT=370.025n

.meas tran vdout0_167ck730 FIND v(dout0_167) AT=370.025n

.meas tran vdout0_168ck730 FIND v(dout0_168) AT=370.025n

.meas tran vdout0_169ck730 FIND v(dout0_169) AT=370.025n

.meas tran vdout0_170ck730 FIND v(dout0_170) AT=370.025n

.meas tran vdout0_171ck730 FIND v(dout0_171) AT=370.025n

.meas tran vdout0_172ck730 FIND v(dout0_172) AT=370.025n

.meas tran vdout0_173ck730 FIND v(dout0_173) AT=370.025n

.meas tran vdout0_174ck730 FIND v(dout0_174) AT=370.025n

.meas tran vdout0_175ck730 FIND v(dout0_175) AT=370.025n

.meas tran vdout0_176ck730 FIND v(dout0_176) AT=370.025n

.meas tran vdout0_177ck730 FIND v(dout0_177) AT=370.025n

.meas tran vdout0_178ck730 FIND v(dout0_178) AT=370.025n

.meas tran vdout0_179ck730 FIND v(dout0_179) AT=370.025n

.meas tran vdout0_180ck730 FIND v(dout0_180) AT=370.025n

.meas tran vdout0_181ck730 FIND v(dout0_181) AT=370.025n

.meas tran vdout0_182ck730 FIND v(dout0_182) AT=370.025n

.meas tran vdout0_183ck730 FIND v(dout0_183) AT=370.025n

.meas tran vdout0_184ck730 FIND v(dout0_184) AT=370.025n

.meas tran vdout0_185ck730 FIND v(dout0_185) AT=370.025n

.meas tran vdout0_186ck730 FIND v(dout0_186) AT=370.025n

.meas tran vdout0_187ck730 FIND v(dout0_187) AT=370.025n

.meas tran vdout0_188ck730 FIND v(dout0_188) AT=370.025n

.meas tran vdout0_189ck730 FIND v(dout0_189) AT=370.025n

.meas tran vdout0_190ck730 FIND v(dout0_190) AT=370.025n

.meas tran vdout0_191ck730 FIND v(dout0_191) AT=370.025n

.meas tran vdout0_192ck730 FIND v(dout0_192) AT=370.025n

.meas tran vdout0_193ck730 FIND v(dout0_193) AT=370.025n

.meas tran vdout0_194ck730 FIND v(dout0_194) AT=370.025n

.meas tran vdout0_195ck730 FIND v(dout0_195) AT=370.025n

.meas tran vdout0_196ck730 FIND v(dout0_196) AT=370.025n

.meas tran vdout0_197ck730 FIND v(dout0_197) AT=370.025n

.meas tran vdout0_198ck730 FIND v(dout0_198) AT=370.025n

.meas tran vdout0_199ck730 FIND v(dout0_199) AT=370.025n

.meas tran vdout0_200ck730 FIND v(dout0_200) AT=370.025n

.meas tran vdout0_201ck730 FIND v(dout0_201) AT=370.025n

.meas tran vdout0_202ck730 FIND v(dout0_202) AT=370.025n

.meas tran vdout0_203ck730 FIND v(dout0_203) AT=370.025n

.meas tran vdout0_204ck730 FIND v(dout0_204) AT=370.025n

.meas tran vdout0_205ck730 FIND v(dout0_205) AT=370.025n

.meas tran vdout0_206ck730 FIND v(dout0_206) AT=370.025n

.meas tran vdout0_207ck730 FIND v(dout0_207) AT=370.025n

.meas tran vdout0_208ck730 FIND v(dout0_208) AT=370.025n

.meas tran vdout0_209ck730 FIND v(dout0_209) AT=370.025n

.meas tran vdout0_210ck730 FIND v(dout0_210) AT=370.025n

.meas tran vdout0_211ck730 FIND v(dout0_211) AT=370.025n

.meas tran vdout0_212ck730 FIND v(dout0_212) AT=370.025n

.meas tran vdout0_213ck730 FIND v(dout0_213) AT=370.025n

.meas tran vdout0_214ck730 FIND v(dout0_214) AT=370.025n

.meas tran vdout0_215ck730 FIND v(dout0_215) AT=370.025n

.meas tran vdout0_216ck730 FIND v(dout0_216) AT=370.025n

.meas tran vdout0_217ck730 FIND v(dout0_217) AT=370.025n

.meas tran vdout0_218ck730 FIND v(dout0_218) AT=370.025n

.meas tran vdout0_219ck730 FIND v(dout0_219) AT=370.025n

.meas tran vdout0_220ck730 FIND v(dout0_220) AT=370.025n

.meas tran vdout0_221ck730 FIND v(dout0_221) AT=370.025n

.meas tran vdout0_222ck730 FIND v(dout0_222) AT=370.025n

.meas tran vdout0_223ck730 FIND v(dout0_223) AT=370.025n

.meas tran vdout0_224ck730 FIND v(dout0_224) AT=370.025n

.meas tran vdout0_225ck730 FIND v(dout0_225) AT=370.025n

.meas tran vdout0_226ck730 FIND v(dout0_226) AT=370.025n

.meas tran vdout0_227ck730 FIND v(dout0_227) AT=370.025n

.meas tran vdout0_228ck730 FIND v(dout0_228) AT=370.025n

.meas tran vdout0_229ck730 FIND v(dout0_229) AT=370.025n

.meas tran vdout0_230ck730 FIND v(dout0_230) AT=370.025n

.meas tran vdout0_231ck730 FIND v(dout0_231) AT=370.025n

.meas tran vdout0_232ck730 FIND v(dout0_232) AT=370.025n

.meas tran vdout0_233ck730 FIND v(dout0_233) AT=370.025n

.meas tran vdout0_234ck730 FIND v(dout0_234) AT=370.025n

.meas tran vdout0_235ck730 FIND v(dout0_235) AT=370.025n

.meas tran vdout0_236ck730 FIND v(dout0_236) AT=370.025n

.meas tran vdout0_237ck730 FIND v(dout0_237) AT=370.025n

.meas tran vdout0_238ck730 FIND v(dout0_238) AT=370.025n

.meas tran vdout0_239ck730 FIND v(dout0_239) AT=370.025n

.meas tran vdout0_240ck730 FIND v(dout0_240) AT=370.025n

.meas tran vdout0_241ck730 FIND v(dout0_241) AT=370.025n

.meas tran vdout0_242ck730 FIND v(dout0_242) AT=370.025n

.meas tran vdout0_243ck730 FIND v(dout0_243) AT=370.025n

.meas tran vdout0_244ck730 FIND v(dout0_244) AT=370.025n

.meas tran vdout0_245ck730 FIND v(dout0_245) AT=370.025n

.meas tran vdout0_246ck730 FIND v(dout0_246) AT=370.025n

.meas tran vdout0_247ck730 FIND v(dout0_247) AT=370.025n

.meas tran vdout0_248ck730 FIND v(dout0_248) AT=370.025n

.meas tran vdout0_249ck730 FIND v(dout0_249) AT=370.025n

.meas tran vdout0_250ck730 FIND v(dout0_250) AT=370.025n

.meas tran vdout0_251ck730 FIND v(dout0_251) AT=370.025n

.meas tran vdout0_252ck730 FIND v(dout0_252) AT=370.025n

.meas tran vdout0_253ck730 FIND v(dout0_253) AT=370.025n

.meas tran vdout0_254ck730 FIND v(dout0_254) AT=370.025n

.meas tran vdout0_255ck730 FIND v(dout0_255) AT=370.025n

.meas tran vdout0_0ck740 FIND v(dout0_0) AT=375.025n

.meas tran vdout0_1ck740 FIND v(dout0_1) AT=375.025n

.meas tran vdout0_2ck740 FIND v(dout0_2) AT=375.025n

.meas tran vdout0_3ck740 FIND v(dout0_3) AT=375.025n

.meas tran vdout0_4ck740 FIND v(dout0_4) AT=375.025n

.meas tran vdout0_5ck740 FIND v(dout0_5) AT=375.025n

.meas tran vdout0_6ck740 FIND v(dout0_6) AT=375.025n

.meas tran vdout0_7ck740 FIND v(dout0_7) AT=375.025n

.meas tran vdout0_8ck740 FIND v(dout0_8) AT=375.025n

.meas tran vdout0_9ck740 FIND v(dout0_9) AT=375.025n

.meas tran vdout0_10ck740 FIND v(dout0_10) AT=375.025n

.meas tran vdout0_11ck740 FIND v(dout0_11) AT=375.025n

.meas tran vdout0_12ck740 FIND v(dout0_12) AT=375.025n

.meas tran vdout0_13ck740 FIND v(dout0_13) AT=375.025n

.meas tran vdout0_14ck740 FIND v(dout0_14) AT=375.025n

.meas tran vdout0_15ck740 FIND v(dout0_15) AT=375.025n

.meas tran vdout0_16ck740 FIND v(dout0_16) AT=375.025n

.meas tran vdout0_17ck740 FIND v(dout0_17) AT=375.025n

.meas tran vdout0_18ck740 FIND v(dout0_18) AT=375.025n

.meas tran vdout0_19ck740 FIND v(dout0_19) AT=375.025n

.meas tran vdout0_20ck740 FIND v(dout0_20) AT=375.025n

.meas tran vdout0_21ck740 FIND v(dout0_21) AT=375.025n

.meas tran vdout0_22ck740 FIND v(dout0_22) AT=375.025n

.meas tran vdout0_23ck740 FIND v(dout0_23) AT=375.025n

.meas tran vdout0_24ck740 FIND v(dout0_24) AT=375.025n

.meas tran vdout0_25ck740 FIND v(dout0_25) AT=375.025n

.meas tran vdout0_26ck740 FIND v(dout0_26) AT=375.025n

.meas tran vdout0_27ck740 FIND v(dout0_27) AT=375.025n

.meas tran vdout0_28ck740 FIND v(dout0_28) AT=375.025n

.meas tran vdout0_29ck740 FIND v(dout0_29) AT=375.025n

.meas tran vdout0_30ck740 FIND v(dout0_30) AT=375.025n

.meas tran vdout0_31ck740 FIND v(dout0_31) AT=375.025n

.meas tran vdout0_32ck740 FIND v(dout0_32) AT=375.025n

.meas tran vdout0_33ck740 FIND v(dout0_33) AT=375.025n

.meas tran vdout0_34ck740 FIND v(dout0_34) AT=375.025n

.meas tran vdout0_35ck740 FIND v(dout0_35) AT=375.025n

.meas tran vdout0_36ck740 FIND v(dout0_36) AT=375.025n

.meas tran vdout0_37ck740 FIND v(dout0_37) AT=375.025n

.meas tran vdout0_38ck740 FIND v(dout0_38) AT=375.025n

.meas tran vdout0_39ck740 FIND v(dout0_39) AT=375.025n

.meas tran vdout0_40ck740 FIND v(dout0_40) AT=375.025n

.meas tran vdout0_41ck740 FIND v(dout0_41) AT=375.025n

.meas tran vdout0_42ck740 FIND v(dout0_42) AT=375.025n

.meas tran vdout0_43ck740 FIND v(dout0_43) AT=375.025n

.meas tran vdout0_44ck740 FIND v(dout0_44) AT=375.025n

.meas tran vdout0_45ck740 FIND v(dout0_45) AT=375.025n

.meas tran vdout0_46ck740 FIND v(dout0_46) AT=375.025n

.meas tran vdout0_47ck740 FIND v(dout0_47) AT=375.025n

.meas tran vdout0_48ck740 FIND v(dout0_48) AT=375.025n

.meas tran vdout0_49ck740 FIND v(dout0_49) AT=375.025n

.meas tran vdout0_50ck740 FIND v(dout0_50) AT=375.025n

.meas tran vdout0_51ck740 FIND v(dout0_51) AT=375.025n

.meas tran vdout0_52ck740 FIND v(dout0_52) AT=375.025n

.meas tran vdout0_53ck740 FIND v(dout0_53) AT=375.025n

.meas tran vdout0_54ck740 FIND v(dout0_54) AT=375.025n

.meas tran vdout0_55ck740 FIND v(dout0_55) AT=375.025n

.meas tran vdout0_56ck740 FIND v(dout0_56) AT=375.025n

.meas tran vdout0_57ck740 FIND v(dout0_57) AT=375.025n

.meas tran vdout0_58ck740 FIND v(dout0_58) AT=375.025n

.meas tran vdout0_59ck740 FIND v(dout0_59) AT=375.025n

.meas tran vdout0_60ck740 FIND v(dout0_60) AT=375.025n

.meas tran vdout0_61ck740 FIND v(dout0_61) AT=375.025n

.meas tran vdout0_62ck740 FIND v(dout0_62) AT=375.025n

.meas tran vdout0_63ck740 FIND v(dout0_63) AT=375.025n

.meas tran vdout0_64ck740 FIND v(dout0_64) AT=375.025n

.meas tran vdout0_65ck740 FIND v(dout0_65) AT=375.025n

.meas tran vdout0_66ck740 FIND v(dout0_66) AT=375.025n

.meas tran vdout0_67ck740 FIND v(dout0_67) AT=375.025n

.meas tran vdout0_68ck740 FIND v(dout0_68) AT=375.025n

.meas tran vdout0_69ck740 FIND v(dout0_69) AT=375.025n

.meas tran vdout0_70ck740 FIND v(dout0_70) AT=375.025n

.meas tran vdout0_71ck740 FIND v(dout0_71) AT=375.025n

.meas tran vdout0_72ck740 FIND v(dout0_72) AT=375.025n

.meas tran vdout0_73ck740 FIND v(dout0_73) AT=375.025n

.meas tran vdout0_74ck740 FIND v(dout0_74) AT=375.025n

.meas tran vdout0_75ck740 FIND v(dout0_75) AT=375.025n

.meas tran vdout0_76ck740 FIND v(dout0_76) AT=375.025n

.meas tran vdout0_77ck740 FIND v(dout0_77) AT=375.025n

.meas tran vdout0_78ck740 FIND v(dout0_78) AT=375.025n

.meas tran vdout0_79ck740 FIND v(dout0_79) AT=375.025n

.meas tran vdout0_80ck740 FIND v(dout0_80) AT=375.025n

.meas tran vdout0_81ck740 FIND v(dout0_81) AT=375.025n

.meas tran vdout0_82ck740 FIND v(dout0_82) AT=375.025n

.meas tran vdout0_83ck740 FIND v(dout0_83) AT=375.025n

.meas tran vdout0_84ck740 FIND v(dout0_84) AT=375.025n

.meas tran vdout0_85ck740 FIND v(dout0_85) AT=375.025n

.meas tran vdout0_86ck740 FIND v(dout0_86) AT=375.025n

.meas tran vdout0_87ck740 FIND v(dout0_87) AT=375.025n

.meas tran vdout0_88ck740 FIND v(dout0_88) AT=375.025n

.meas tran vdout0_89ck740 FIND v(dout0_89) AT=375.025n

.meas tran vdout0_90ck740 FIND v(dout0_90) AT=375.025n

.meas tran vdout0_91ck740 FIND v(dout0_91) AT=375.025n

.meas tran vdout0_92ck740 FIND v(dout0_92) AT=375.025n

.meas tran vdout0_93ck740 FIND v(dout0_93) AT=375.025n

.meas tran vdout0_94ck740 FIND v(dout0_94) AT=375.025n

.meas tran vdout0_95ck740 FIND v(dout0_95) AT=375.025n

.meas tran vdout0_96ck740 FIND v(dout0_96) AT=375.025n

.meas tran vdout0_97ck740 FIND v(dout0_97) AT=375.025n

.meas tran vdout0_98ck740 FIND v(dout0_98) AT=375.025n

.meas tran vdout0_99ck740 FIND v(dout0_99) AT=375.025n

.meas tran vdout0_100ck740 FIND v(dout0_100) AT=375.025n

.meas tran vdout0_101ck740 FIND v(dout0_101) AT=375.025n

.meas tran vdout0_102ck740 FIND v(dout0_102) AT=375.025n

.meas tran vdout0_103ck740 FIND v(dout0_103) AT=375.025n

.meas tran vdout0_104ck740 FIND v(dout0_104) AT=375.025n

.meas tran vdout0_105ck740 FIND v(dout0_105) AT=375.025n

.meas tran vdout0_106ck740 FIND v(dout0_106) AT=375.025n

.meas tran vdout0_107ck740 FIND v(dout0_107) AT=375.025n

.meas tran vdout0_108ck740 FIND v(dout0_108) AT=375.025n

.meas tran vdout0_109ck740 FIND v(dout0_109) AT=375.025n

.meas tran vdout0_110ck740 FIND v(dout0_110) AT=375.025n

.meas tran vdout0_111ck740 FIND v(dout0_111) AT=375.025n

.meas tran vdout0_112ck740 FIND v(dout0_112) AT=375.025n

.meas tran vdout0_113ck740 FIND v(dout0_113) AT=375.025n

.meas tran vdout0_114ck740 FIND v(dout0_114) AT=375.025n

.meas tran vdout0_115ck740 FIND v(dout0_115) AT=375.025n

.meas tran vdout0_116ck740 FIND v(dout0_116) AT=375.025n

.meas tran vdout0_117ck740 FIND v(dout0_117) AT=375.025n

.meas tran vdout0_118ck740 FIND v(dout0_118) AT=375.025n

.meas tran vdout0_119ck740 FIND v(dout0_119) AT=375.025n

.meas tran vdout0_120ck740 FIND v(dout0_120) AT=375.025n

.meas tran vdout0_121ck740 FIND v(dout0_121) AT=375.025n

.meas tran vdout0_122ck740 FIND v(dout0_122) AT=375.025n

.meas tran vdout0_123ck740 FIND v(dout0_123) AT=375.025n

.meas tran vdout0_124ck740 FIND v(dout0_124) AT=375.025n

.meas tran vdout0_125ck740 FIND v(dout0_125) AT=375.025n

.meas tran vdout0_126ck740 FIND v(dout0_126) AT=375.025n

.meas tran vdout0_127ck740 FIND v(dout0_127) AT=375.025n

.meas tran vdout0_128ck740 FIND v(dout0_128) AT=375.025n

.meas tran vdout0_129ck740 FIND v(dout0_129) AT=375.025n

.meas tran vdout0_130ck740 FIND v(dout0_130) AT=375.025n

.meas tran vdout0_131ck740 FIND v(dout0_131) AT=375.025n

.meas tran vdout0_132ck740 FIND v(dout0_132) AT=375.025n

.meas tran vdout0_133ck740 FIND v(dout0_133) AT=375.025n

.meas tran vdout0_134ck740 FIND v(dout0_134) AT=375.025n

.meas tran vdout0_135ck740 FIND v(dout0_135) AT=375.025n

.meas tran vdout0_136ck740 FIND v(dout0_136) AT=375.025n

.meas tran vdout0_137ck740 FIND v(dout0_137) AT=375.025n

.meas tran vdout0_138ck740 FIND v(dout0_138) AT=375.025n

.meas tran vdout0_139ck740 FIND v(dout0_139) AT=375.025n

.meas tran vdout0_140ck740 FIND v(dout0_140) AT=375.025n

.meas tran vdout0_141ck740 FIND v(dout0_141) AT=375.025n

.meas tran vdout0_142ck740 FIND v(dout0_142) AT=375.025n

.meas tran vdout0_143ck740 FIND v(dout0_143) AT=375.025n

.meas tran vdout0_144ck740 FIND v(dout0_144) AT=375.025n

.meas tran vdout0_145ck740 FIND v(dout0_145) AT=375.025n

.meas tran vdout0_146ck740 FIND v(dout0_146) AT=375.025n

.meas tran vdout0_147ck740 FIND v(dout0_147) AT=375.025n

.meas tran vdout0_148ck740 FIND v(dout0_148) AT=375.025n

.meas tran vdout0_149ck740 FIND v(dout0_149) AT=375.025n

.meas tran vdout0_150ck740 FIND v(dout0_150) AT=375.025n

.meas tran vdout0_151ck740 FIND v(dout0_151) AT=375.025n

.meas tran vdout0_152ck740 FIND v(dout0_152) AT=375.025n

.meas tran vdout0_153ck740 FIND v(dout0_153) AT=375.025n

.meas tran vdout0_154ck740 FIND v(dout0_154) AT=375.025n

.meas tran vdout0_155ck740 FIND v(dout0_155) AT=375.025n

.meas tran vdout0_156ck740 FIND v(dout0_156) AT=375.025n

.meas tran vdout0_157ck740 FIND v(dout0_157) AT=375.025n

.meas tran vdout0_158ck740 FIND v(dout0_158) AT=375.025n

.meas tran vdout0_159ck740 FIND v(dout0_159) AT=375.025n

.meas tran vdout0_160ck740 FIND v(dout0_160) AT=375.025n

.meas tran vdout0_161ck740 FIND v(dout0_161) AT=375.025n

.meas tran vdout0_162ck740 FIND v(dout0_162) AT=375.025n

.meas tran vdout0_163ck740 FIND v(dout0_163) AT=375.025n

.meas tran vdout0_164ck740 FIND v(dout0_164) AT=375.025n

.meas tran vdout0_165ck740 FIND v(dout0_165) AT=375.025n

.meas tran vdout0_166ck740 FIND v(dout0_166) AT=375.025n

.meas tran vdout0_167ck740 FIND v(dout0_167) AT=375.025n

.meas tran vdout0_168ck740 FIND v(dout0_168) AT=375.025n

.meas tran vdout0_169ck740 FIND v(dout0_169) AT=375.025n

.meas tran vdout0_170ck740 FIND v(dout0_170) AT=375.025n

.meas tran vdout0_171ck740 FIND v(dout0_171) AT=375.025n

.meas tran vdout0_172ck740 FIND v(dout0_172) AT=375.025n

.meas tran vdout0_173ck740 FIND v(dout0_173) AT=375.025n

.meas tran vdout0_174ck740 FIND v(dout0_174) AT=375.025n

.meas tran vdout0_175ck740 FIND v(dout0_175) AT=375.025n

.meas tran vdout0_176ck740 FIND v(dout0_176) AT=375.025n

.meas tran vdout0_177ck740 FIND v(dout0_177) AT=375.025n

.meas tran vdout0_178ck740 FIND v(dout0_178) AT=375.025n

.meas tran vdout0_179ck740 FIND v(dout0_179) AT=375.025n

.meas tran vdout0_180ck740 FIND v(dout0_180) AT=375.025n

.meas tran vdout0_181ck740 FIND v(dout0_181) AT=375.025n

.meas tran vdout0_182ck740 FIND v(dout0_182) AT=375.025n

.meas tran vdout0_183ck740 FIND v(dout0_183) AT=375.025n

.meas tran vdout0_184ck740 FIND v(dout0_184) AT=375.025n

.meas tran vdout0_185ck740 FIND v(dout0_185) AT=375.025n

.meas tran vdout0_186ck740 FIND v(dout0_186) AT=375.025n

.meas tran vdout0_187ck740 FIND v(dout0_187) AT=375.025n

.meas tran vdout0_188ck740 FIND v(dout0_188) AT=375.025n

.meas tran vdout0_189ck740 FIND v(dout0_189) AT=375.025n

.meas tran vdout0_190ck740 FIND v(dout0_190) AT=375.025n

.meas tran vdout0_191ck740 FIND v(dout0_191) AT=375.025n

.meas tran vdout0_192ck740 FIND v(dout0_192) AT=375.025n

.meas tran vdout0_193ck740 FIND v(dout0_193) AT=375.025n

.meas tran vdout0_194ck740 FIND v(dout0_194) AT=375.025n

.meas tran vdout0_195ck740 FIND v(dout0_195) AT=375.025n

.meas tran vdout0_196ck740 FIND v(dout0_196) AT=375.025n

.meas tran vdout0_197ck740 FIND v(dout0_197) AT=375.025n

.meas tran vdout0_198ck740 FIND v(dout0_198) AT=375.025n

.meas tran vdout0_199ck740 FIND v(dout0_199) AT=375.025n

.meas tran vdout0_200ck740 FIND v(dout0_200) AT=375.025n

.meas tran vdout0_201ck740 FIND v(dout0_201) AT=375.025n

.meas tran vdout0_202ck740 FIND v(dout0_202) AT=375.025n

.meas tran vdout0_203ck740 FIND v(dout0_203) AT=375.025n

.meas tran vdout0_204ck740 FIND v(dout0_204) AT=375.025n

.meas tran vdout0_205ck740 FIND v(dout0_205) AT=375.025n

.meas tran vdout0_206ck740 FIND v(dout0_206) AT=375.025n

.meas tran vdout0_207ck740 FIND v(dout0_207) AT=375.025n

.meas tran vdout0_208ck740 FIND v(dout0_208) AT=375.025n

.meas tran vdout0_209ck740 FIND v(dout0_209) AT=375.025n

.meas tran vdout0_210ck740 FIND v(dout0_210) AT=375.025n

.meas tran vdout0_211ck740 FIND v(dout0_211) AT=375.025n

.meas tran vdout0_212ck740 FIND v(dout0_212) AT=375.025n

.meas tran vdout0_213ck740 FIND v(dout0_213) AT=375.025n

.meas tran vdout0_214ck740 FIND v(dout0_214) AT=375.025n

.meas tran vdout0_215ck740 FIND v(dout0_215) AT=375.025n

.meas tran vdout0_216ck740 FIND v(dout0_216) AT=375.025n

.meas tran vdout0_217ck740 FIND v(dout0_217) AT=375.025n

.meas tran vdout0_218ck740 FIND v(dout0_218) AT=375.025n

.meas tran vdout0_219ck740 FIND v(dout0_219) AT=375.025n

.meas tran vdout0_220ck740 FIND v(dout0_220) AT=375.025n

.meas tran vdout0_221ck740 FIND v(dout0_221) AT=375.025n

.meas tran vdout0_222ck740 FIND v(dout0_222) AT=375.025n

.meas tran vdout0_223ck740 FIND v(dout0_223) AT=375.025n

.meas tran vdout0_224ck740 FIND v(dout0_224) AT=375.025n

.meas tran vdout0_225ck740 FIND v(dout0_225) AT=375.025n

.meas tran vdout0_226ck740 FIND v(dout0_226) AT=375.025n

.meas tran vdout0_227ck740 FIND v(dout0_227) AT=375.025n

.meas tran vdout0_228ck740 FIND v(dout0_228) AT=375.025n

.meas tran vdout0_229ck740 FIND v(dout0_229) AT=375.025n

.meas tran vdout0_230ck740 FIND v(dout0_230) AT=375.025n

.meas tran vdout0_231ck740 FIND v(dout0_231) AT=375.025n

.meas tran vdout0_232ck740 FIND v(dout0_232) AT=375.025n

.meas tran vdout0_233ck740 FIND v(dout0_233) AT=375.025n

.meas tran vdout0_234ck740 FIND v(dout0_234) AT=375.025n

.meas tran vdout0_235ck740 FIND v(dout0_235) AT=375.025n

.meas tran vdout0_236ck740 FIND v(dout0_236) AT=375.025n

.meas tran vdout0_237ck740 FIND v(dout0_237) AT=375.025n

.meas tran vdout0_238ck740 FIND v(dout0_238) AT=375.025n

.meas tran vdout0_239ck740 FIND v(dout0_239) AT=375.025n

.meas tran vdout0_240ck740 FIND v(dout0_240) AT=375.025n

.meas tran vdout0_241ck740 FIND v(dout0_241) AT=375.025n

.meas tran vdout0_242ck740 FIND v(dout0_242) AT=375.025n

.meas tran vdout0_243ck740 FIND v(dout0_243) AT=375.025n

.meas tran vdout0_244ck740 FIND v(dout0_244) AT=375.025n

.meas tran vdout0_245ck740 FIND v(dout0_245) AT=375.025n

.meas tran vdout0_246ck740 FIND v(dout0_246) AT=375.025n

.meas tran vdout0_247ck740 FIND v(dout0_247) AT=375.025n

.meas tran vdout0_248ck740 FIND v(dout0_248) AT=375.025n

.meas tran vdout0_249ck740 FIND v(dout0_249) AT=375.025n

.meas tran vdout0_250ck740 FIND v(dout0_250) AT=375.025n

.meas tran vdout0_251ck740 FIND v(dout0_251) AT=375.025n

.meas tran vdout0_252ck740 FIND v(dout0_252) AT=375.025n

.meas tran vdout0_253ck740 FIND v(dout0_253) AT=375.025n

.meas tran vdout0_254ck740 FIND v(dout0_254) AT=375.025n

.meas tran vdout0_255ck740 FIND v(dout0_255) AT=375.025n

.meas tran vdout0_0ck750 FIND v(dout0_0) AT=380.025n

.meas tran vdout0_1ck750 FIND v(dout0_1) AT=380.025n

.meas tran vdout0_2ck750 FIND v(dout0_2) AT=380.025n

.meas tran vdout0_3ck750 FIND v(dout0_3) AT=380.025n

.meas tran vdout0_4ck750 FIND v(dout0_4) AT=380.025n

.meas tran vdout0_5ck750 FIND v(dout0_5) AT=380.025n

.meas tran vdout0_6ck750 FIND v(dout0_6) AT=380.025n

.meas tran vdout0_7ck750 FIND v(dout0_7) AT=380.025n

.meas tran vdout0_8ck750 FIND v(dout0_8) AT=380.025n

.meas tran vdout0_9ck750 FIND v(dout0_9) AT=380.025n

.meas tran vdout0_10ck750 FIND v(dout0_10) AT=380.025n

.meas tran vdout0_11ck750 FIND v(dout0_11) AT=380.025n

.meas tran vdout0_12ck750 FIND v(dout0_12) AT=380.025n

.meas tran vdout0_13ck750 FIND v(dout0_13) AT=380.025n

.meas tran vdout0_14ck750 FIND v(dout0_14) AT=380.025n

.meas tran vdout0_15ck750 FIND v(dout0_15) AT=380.025n

.meas tran vdout0_16ck750 FIND v(dout0_16) AT=380.025n

.meas tran vdout0_17ck750 FIND v(dout0_17) AT=380.025n

.meas tran vdout0_18ck750 FIND v(dout0_18) AT=380.025n

.meas tran vdout0_19ck750 FIND v(dout0_19) AT=380.025n

.meas tran vdout0_20ck750 FIND v(dout0_20) AT=380.025n

.meas tran vdout0_21ck750 FIND v(dout0_21) AT=380.025n

.meas tran vdout0_22ck750 FIND v(dout0_22) AT=380.025n

.meas tran vdout0_23ck750 FIND v(dout0_23) AT=380.025n

.meas tran vdout0_24ck750 FIND v(dout0_24) AT=380.025n

.meas tran vdout0_25ck750 FIND v(dout0_25) AT=380.025n

.meas tran vdout0_26ck750 FIND v(dout0_26) AT=380.025n

.meas tran vdout0_27ck750 FIND v(dout0_27) AT=380.025n

.meas tran vdout0_28ck750 FIND v(dout0_28) AT=380.025n

.meas tran vdout0_29ck750 FIND v(dout0_29) AT=380.025n

.meas tran vdout0_30ck750 FIND v(dout0_30) AT=380.025n

.meas tran vdout0_31ck750 FIND v(dout0_31) AT=380.025n

.meas tran vdout0_32ck750 FIND v(dout0_32) AT=380.025n

.meas tran vdout0_33ck750 FIND v(dout0_33) AT=380.025n

.meas tran vdout0_34ck750 FIND v(dout0_34) AT=380.025n

.meas tran vdout0_35ck750 FIND v(dout0_35) AT=380.025n

.meas tran vdout0_36ck750 FIND v(dout0_36) AT=380.025n

.meas tran vdout0_37ck750 FIND v(dout0_37) AT=380.025n

.meas tran vdout0_38ck750 FIND v(dout0_38) AT=380.025n

.meas tran vdout0_39ck750 FIND v(dout0_39) AT=380.025n

.meas tran vdout0_40ck750 FIND v(dout0_40) AT=380.025n

.meas tran vdout0_41ck750 FIND v(dout0_41) AT=380.025n

.meas tran vdout0_42ck750 FIND v(dout0_42) AT=380.025n

.meas tran vdout0_43ck750 FIND v(dout0_43) AT=380.025n

.meas tran vdout0_44ck750 FIND v(dout0_44) AT=380.025n

.meas tran vdout0_45ck750 FIND v(dout0_45) AT=380.025n

.meas tran vdout0_46ck750 FIND v(dout0_46) AT=380.025n

.meas tran vdout0_47ck750 FIND v(dout0_47) AT=380.025n

.meas tran vdout0_48ck750 FIND v(dout0_48) AT=380.025n

.meas tran vdout0_49ck750 FIND v(dout0_49) AT=380.025n

.meas tran vdout0_50ck750 FIND v(dout0_50) AT=380.025n

.meas tran vdout0_51ck750 FIND v(dout0_51) AT=380.025n

.meas tran vdout0_52ck750 FIND v(dout0_52) AT=380.025n

.meas tran vdout0_53ck750 FIND v(dout0_53) AT=380.025n

.meas tran vdout0_54ck750 FIND v(dout0_54) AT=380.025n

.meas tran vdout0_55ck750 FIND v(dout0_55) AT=380.025n

.meas tran vdout0_56ck750 FIND v(dout0_56) AT=380.025n

.meas tran vdout0_57ck750 FIND v(dout0_57) AT=380.025n

.meas tran vdout0_58ck750 FIND v(dout0_58) AT=380.025n

.meas tran vdout0_59ck750 FIND v(dout0_59) AT=380.025n

.meas tran vdout0_60ck750 FIND v(dout0_60) AT=380.025n

.meas tran vdout0_61ck750 FIND v(dout0_61) AT=380.025n

.meas tran vdout0_62ck750 FIND v(dout0_62) AT=380.025n

.meas tran vdout0_63ck750 FIND v(dout0_63) AT=380.025n

.meas tran vdout0_64ck750 FIND v(dout0_64) AT=380.025n

.meas tran vdout0_65ck750 FIND v(dout0_65) AT=380.025n

.meas tran vdout0_66ck750 FIND v(dout0_66) AT=380.025n

.meas tran vdout0_67ck750 FIND v(dout0_67) AT=380.025n

.meas tran vdout0_68ck750 FIND v(dout0_68) AT=380.025n

.meas tran vdout0_69ck750 FIND v(dout0_69) AT=380.025n

.meas tran vdout0_70ck750 FIND v(dout0_70) AT=380.025n

.meas tran vdout0_71ck750 FIND v(dout0_71) AT=380.025n

.meas tran vdout0_72ck750 FIND v(dout0_72) AT=380.025n

.meas tran vdout0_73ck750 FIND v(dout0_73) AT=380.025n

.meas tran vdout0_74ck750 FIND v(dout0_74) AT=380.025n

.meas tran vdout0_75ck750 FIND v(dout0_75) AT=380.025n

.meas tran vdout0_76ck750 FIND v(dout0_76) AT=380.025n

.meas tran vdout0_77ck750 FIND v(dout0_77) AT=380.025n

.meas tran vdout0_78ck750 FIND v(dout0_78) AT=380.025n

.meas tran vdout0_79ck750 FIND v(dout0_79) AT=380.025n

.meas tran vdout0_80ck750 FIND v(dout0_80) AT=380.025n

.meas tran vdout0_81ck750 FIND v(dout0_81) AT=380.025n

.meas tran vdout0_82ck750 FIND v(dout0_82) AT=380.025n

.meas tran vdout0_83ck750 FIND v(dout0_83) AT=380.025n

.meas tran vdout0_84ck750 FIND v(dout0_84) AT=380.025n

.meas tran vdout0_85ck750 FIND v(dout0_85) AT=380.025n

.meas tran vdout0_86ck750 FIND v(dout0_86) AT=380.025n

.meas tran vdout0_87ck750 FIND v(dout0_87) AT=380.025n

.meas tran vdout0_88ck750 FIND v(dout0_88) AT=380.025n

.meas tran vdout0_89ck750 FIND v(dout0_89) AT=380.025n

.meas tran vdout0_90ck750 FIND v(dout0_90) AT=380.025n

.meas tran vdout0_91ck750 FIND v(dout0_91) AT=380.025n

.meas tran vdout0_92ck750 FIND v(dout0_92) AT=380.025n

.meas tran vdout0_93ck750 FIND v(dout0_93) AT=380.025n

.meas tran vdout0_94ck750 FIND v(dout0_94) AT=380.025n

.meas tran vdout0_95ck750 FIND v(dout0_95) AT=380.025n

.meas tran vdout0_96ck750 FIND v(dout0_96) AT=380.025n

.meas tran vdout0_97ck750 FIND v(dout0_97) AT=380.025n

.meas tran vdout0_98ck750 FIND v(dout0_98) AT=380.025n

.meas tran vdout0_99ck750 FIND v(dout0_99) AT=380.025n

.meas tran vdout0_100ck750 FIND v(dout0_100) AT=380.025n

.meas tran vdout0_101ck750 FIND v(dout0_101) AT=380.025n

.meas tran vdout0_102ck750 FIND v(dout0_102) AT=380.025n

.meas tran vdout0_103ck750 FIND v(dout0_103) AT=380.025n

.meas tran vdout0_104ck750 FIND v(dout0_104) AT=380.025n

.meas tran vdout0_105ck750 FIND v(dout0_105) AT=380.025n

.meas tran vdout0_106ck750 FIND v(dout0_106) AT=380.025n

.meas tran vdout0_107ck750 FIND v(dout0_107) AT=380.025n

.meas tran vdout0_108ck750 FIND v(dout0_108) AT=380.025n

.meas tran vdout0_109ck750 FIND v(dout0_109) AT=380.025n

.meas tran vdout0_110ck750 FIND v(dout0_110) AT=380.025n

.meas tran vdout0_111ck750 FIND v(dout0_111) AT=380.025n

.meas tran vdout0_112ck750 FIND v(dout0_112) AT=380.025n

.meas tran vdout0_113ck750 FIND v(dout0_113) AT=380.025n

.meas tran vdout0_114ck750 FIND v(dout0_114) AT=380.025n

.meas tran vdout0_115ck750 FIND v(dout0_115) AT=380.025n

.meas tran vdout0_116ck750 FIND v(dout0_116) AT=380.025n

.meas tran vdout0_117ck750 FIND v(dout0_117) AT=380.025n

.meas tran vdout0_118ck750 FIND v(dout0_118) AT=380.025n

.meas tran vdout0_119ck750 FIND v(dout0_119) AT=380.025n

.meas tran vdout0_120ck750 FIND v(dout0_120) AT=380.025n

.meas tran vdout0_121ck750 FIND v(dout0_121) AT=380.025n

.meas tran vdout0_122ck750 FIND v(dout0_122) AT=380.025n

.meas tran vdout0_123ck750 FIND v(dout0_123) AT=380.025n

.meas tran vdout0_124ck750 FIND v(dout0_124) AT=380.025n

.meas tran vdout0_125ck750 FIND v(dout0_125) AT=380.025n

.meas tran vdout0_126ck750 FIND v(dout0_126) AT=380.025n

.meas tran vdout0_127ck750 FIND v(dout0_127) AT=380.025n

.meas tran vdout0_128ck750 FIND v(dout0_128) AT=380.025n

.meas tran vdout0_129ck750 FIND v(dout0_129) AT=380.025n

.meas tran vdout0_130ck750 FIND v(dout0_130) AT=380.025n

.meas tran vdout0_131ck750 FIND v(dout0_131) AT=380.025n

.meas tran vdout0_132ck750 FIND v(dout0_132) AT=380.025n

.meas tran vdout0_133ck750 FIND v(dout0_133) AT=380.025n

.meas tran vdout0_134ck750 FIND v(dout0_134) AT=380.025n

.meas tran vdout0_135ck750 FIND v(dout0_135) AT=380.025n

.meas tran vdout0_136ck750 FIND v(dout0_136) AT=380.025n

.meas tran vdout0_137ck750 FIND v(dout0_137) AT=380.025n

.meas tran vdout0_138ck750 FIND v(dout0_138) AT=380.025n

.meas tran vdout0_139ck750 FIND v(dout0_139) AT=380.025n

.meas tran vdout0_140ck750 FIND v(dout0_140) AT=380.025n

.meas tran vdout0_141ck750 FIND v(dout0_141) AT=380.025n

.meas tran vdout0_142ck750 FIND v(dout0_142) AT=380.025n

.meas tran vdout0_143ck750 FIND v(dout0_143) AT=380.025n

.meas tran vdout0_144ck750 FIND v(dout0_144) AT=380.025n

.meas tran vdout0_145ck750 FIND v(dout0_145) AT=380.025n

.meas tran vdout0_146ck750 FIND v(dout0_146) AT=380.025n

.meas tran vdout0_147ck750 FIND v(dout0_147) AT=380.025n

.meas tran vdout0_148ck750 FIND v(dout0_148) AT=380.025n

.meas tran vdout0_149ck750 FIND v(dout0_149) AT=380.025n

.meas tran vdout0_150ck750 FIND v(dout0_150) AT=380.025n

.meas tran vdout0_151ck750 FIND v(dout0_151) AT=380.025n

.meas tran vdout0_152ck750 FIND v(dout0_152) AT=380.025n

.meas tran vdout0_153ck750 FIND v(dout0_153) AT=380.025n

.meas tran vdout0_154ck750 FIND v(dout0_154) AT=380.025n

.meas tran vdout0_155ck750 FIND v(dout0_155) AT=380.025n

.meas tran vdout0_156ck750 FIND v(dout0_156) AT=380.025n

.meas tran vdout0_157ck750 FIND v(dout0_157) AT=380.025n

.meas tran vdout0_158ck750 FIND v(dout0_158) AT=380.025n

.meas tran vdout0_159ck750 FIND v(dout0_159) AT=380.025n

.meas tran vdout0_160ck750 FIND v(dout0_160) AT=380.025n

.meas tran vdout0_161ck750 FIND v(dout0_161) AT=380.025n

.meas tran vdout0_162ck750 FIND v(dout0_162) AT=380.025n

.meas tran vdout0_163ck750 FIND v(dout0_163) AT=380.025n

.meas tran vdout0_164ck750 FIND v(dout0_164) AT=380.025n

.meas tran vdout0_165ck750 FIND v(dout0_165) AT=380.025n

.meas tran vdout0_166ck750 FIND v(dout0_166) AT=380.025n

.meas tran vdout0_167ck750 FIND v(dout0_167) AT=380.025n

.meas tran vdout0_168ck750 FIND v(dout0_168) AT=380.025n

.meas tran vdout0_169ck750 FIND v(dout0_169) AT=380.025n

.meas tran vdout0_170ck750 FIND v(dout0_170) AT=380.025n

.meas tran vdout0_171ck750 FIND v(dout0_171) AT=380.025n

.meas tran vdout0_172ck750 FIND v(dout0_172) AT=380.025n

.meas tran vdout0_173ck750 FIND v(dout0_173) AT=380.025n

.meas tran vdout0_174ck750 FIND v(dout0_174) AT=380.025n

.meas tran vdout0_175ck750 FIND v(dout0_175) AT=380.025n

.meas tran vdout0_176ck750 FIND v(dout0_176) AT=380.025n

.meas tran vdout0_177ck750 FIND v(dout0_177) AT=380.025n

.meas tran vdout0_178ck750 FIND v(dout0_178) AT=380.025n

.meas tran vdout0_179ck750 FIND v(dout0_179) AT=380.025n

.meas tran vdout0_180ck750 FIND v(dout0_180) AT=380.025n

.meas tran vdout0_181ck750 FIND v(dout0_181) AT=380.025n

.meas tran vdout0_182ck750 FIND v(dout0_182) AT=380.025n

.meas tran vdout0_183ck750 FIND v(dout0_183) AT=380.025n

.meas tran vdout0_184ck750 FIND v(dout0_184) AT=380.025n

.meas tran vdout0_185ck750 FIND v(dout0_185) AT=380.025n

.meas tran vdout0_186ck750 FIND v(dout0_186) AT=380.025n

.meas tran vdout0_187ck750 FIND v(dout0_187) AT=380.025n

.meas tran vdout0_188ck750 FIND v(dout0_188) AT=380.025n

.meas tran vdout0_189ck750 FIND v(dout0_189) AT=380.025n

.meas tran vdout0_190ck750 FIND v(dout0_190) AT=380.025n

.meas tran vdout0_191ck750 FIND v(dout0_191) AT=380.025n

.meas tran vdout0_192ck750 FIND v(dout0_192) AT=380.025n

.meas tran vdout0_193ck750 FIND v(dout0_193) AT=380.025n

.meas tran vdout0_194ck750 FIND v(dout0_194) AT=380.025n

.meas tran vdout0_195ck750 FIND v(dout0_195) AT=380.025n

.meas tran vdout0_196ck750 FIND v(dout0_196) AT=380.025n

.meas tran vdout0_197ck750 FIND v(dout0_197) AT=380.025n

.meas tran vdout0_198ck750 FIND v(dout0_198) AT=380.025n

.meas tran vdout0_199ck750 FIND v(dout0_199) AT=380.025n

.meas tran vdout0_200ck750 FIND v(dout0_200) AT=380.025n

.meas tran vdout0_201ck750 FIND v(dout0_201) AT=380.025n

.meas tran vdout0_202ck750 FIND v(dout0_202) AT=380.025n

.meas tran vdout0_203ck750 FIND v(dout0_203) AT=380.025n

.meas tran vdout0_204ck750 FIND v(dout0_204) AT=380.025n

.meas tran vdout0_205ck750 FIND v(dout0_205) AT=380.025n

.meas tran vdout0_206ck750 FIND v(dout0_206) AT=380.025n

.meas tran vdout0_207ck750 FIND v(dout0_207) AT=380.025n

.meas tran vdout0_208ck750 FIND v(dout0_208) AT=380.025n

.meas tran vdout0_209ck750 FIND v(dout0_209) AT=380.025n

.meas tran vdout0_210ck750 FIND v(dout0_210) AT=380.025n

.meas tran vdout0_211ck750 FIND v(dout0_211) AT=380.025n

.meas tran vdout0_212ck750 FIND v(dout0_212) AT=380.025n

.meas tran vdout0_213ck750 FIND v(dout0_213) AT=380.025n

.meas tran vdout0_214ck750 FIND v(dout0_214) AT=380.025n

.meas tran vdout0_215ck750 FIND v(dout0_215) AT=380.025n

.meas tran vdout0_216ck750 FIND v(dout0_216) AT=380.025n

.meas tran vdout0_217ck750 FIND v(dout0_217) AT=380.025n

.meas tran vdout0_218ck750 FIND v(dout0_218) AT=380.025n

.meas tran vdout0_219ck750 FIND v(dout0_219) AT=380.025n

.meas tran vdout0_220ck750 FIND v(dout0_220) AT=380.025n

.meas tran vdout0_221ck750 FIND v(dout0_221) AT=380.025n

.meas tran vdout0_222ck750 FIND v(dout0_222) AT=380.025n

.meas tran vdout0_223ck750 FIND v(dout0_223) AT=380.025n

.meas tran vdout0_224ck750 FIND v(dout0_224) AT=380.025n

.meas tran vdout0_225ck750 FIND v(dout0_225) AT=380.025n

.meas tran vdout0_226ck750 FIND v(dout0_226) AT=380.025n

.meas tran vdout0_227ck750 FIND v(dout0_227) AT=380.025n

.meas tran vdout0_228ck750 FIND v(dout0_228) AT=380.025n

.meas tran vdout0_229ck750 FIND v(dout0_229) AT=380.025n

.meas tran vdout0_230ck750 FIND v(dout0_230) AT=380.025n

.meas tran vdout0_231ck750 FIND v(dout0_231) AT=380.025n

.meas tran vdout0_232ck750 FIND v(dout0_232) AT=380.025n

.meas tran vdout0_233ck750 FIND v(dout0_233) AT=380.025n

.meas tran vdout0_234ck750 FIND v(dout0_234) AT=380.025n

.meas tran vdout0_235ck750 FIND v(dout0_235) AT=380.025n

.meas tran vdout0_236ck750 FIND v(dout0_236) AT=380.025n

.meas tran vdout0_237ck750 FIND v(dout0_237) AT=380.025n

.meas tran vdout0_238ck750 FIND v(dout0_238) AT=380.025n

.meas tran vdout0_239ck750 FIND v(dout0_239) AT=380.025n

.meas tran vdout0_240ck750 FIND v(dout0_240) AT=380.025n

.meas tran vdout0_241ck750 FIND v(dout0_241) AT=380.025n

.meas tran vdout0_242ck750 FIND v(dout0_242) AT=380.025n

.meas tran vdout0_243ck750 FIND v(dout0_243) AT=380.025n

.meas tran vdout0_244ck750 FIND v(dout0_244) AT=380.025n

.meas tran vdout0_245ck750 FIND v(dout0_245) AT=380.025n

.meas tran vdout0_246ck750 FIND v(dout0_246) AT=380.025n

.meas tran vdout0_247ck750 FIND v(dout0_247) AT=380.025n

.meas tran vdout0_248ck750 FIND v(dout0_248) AT=380.025n

.meas tran vdout0_249ck750 FIND v(dout0_249) AT=380.025n

.meas tran vdout0_250ck750 FIND v(dout0_250) AT=380.025n

.meas tran vdout0_251ck750 FIND v(dout0_251) AT=380.025n

.meas tran vdout0_252ck750 FIND v(dout0_252) AT=380.025n

.meas tran vdout0_253ck750 FIND v(dout0_253) AT=380.025n

.meas tran vdout0_254ck750 FIND v(dout0_254) AT=380.025n

.meas tran vdout0_255ck750 FIND v(dout0_255) AT=380.025n

.meas tran vdout0_0ck790 FIND v(dout0_0) AT=400.025n

.meas tran vdout0_1ck790 FIND v(dout0_1) AT=400.025n

.meas tran vdout0_2ck790 FIND v(dout0_2) AT=400.025n

.meas tran vdout0_3ck790 FIND v(dout0_3) AT=400.025n

.meas tran vdout0_4ck790 FIND v(dout0_4) AT=400.025n

.meas tran vdout0_5ck790 FIND v(dout0_5) AT=400.025n

.meas tran vdout0_6ck790 FIND v(dout0_6) AT=400.025n

.meas tran vdout0_7ck790 FIND v(dout0_7) AT=400.025n

.meas tran vdout0_8ck790 FIND v(dout0_8) AT=400.025n

.meas tran vdout0_9ck790 FIND v(dout0_9) AT=400.025n

.meas tran vdout0_10ck790 FIND v(dout0_10) AT=400.025n

.meas tran vdout0_11ck790 FIND v(dout0_11) AT=400.025n

.meas tran vdout0_12ck790 FIND v(dout0_12) AT=400.025n

.meas tran vdout0_13ck790 FIND v(dout0_13) AT=400.025n

.meas tran vdout0_14ck790 FIND v(dout0_14) AT=400.025n

.meas tran vdout0_15ck790 FIND v(dout0_15) AT=400.025n

.meas tran vdout0_16ck790 FIND v(dout0_16) AT=400.025n

.meas tran vdout0_17ck790 FIND v(dout0_17) AT=400.025n

.meas tran vdout0_18ck790 FIND v(dout0_18) AT=400.025n

.meas tran vdout0_19ck790 FIND v(dout0_19) AT=400.025n

.meas tran vdout0_20ck790 FIND v(dout0_20) AT=400.025n

.meas tran vdout0_21ck790 FIND v(dout0_21) AT=400.025n

.meas tran vdout0_22ck790 FIND v(dout0_22) AT=400.025n

.meas tran vdout0_23ck790 FIND v(dout0_23) AT=400.025n

.meas tran vdout0_24ck790 FIND v(dout0_24) AT=400.025n

.meas tran vdout0_25ck790 FIND v(dout0_25) AT=400.025n

.meas tran vdout0_26ck790 FIND v(dout0_26) AT=400.025n

.meas tran vdout0_27ck790 FIND v(dout0_27) AT=400.025n

.meas tran vdout0_28ck790 FIND v(dout0_28) AT=400.025n

.meas tran vdout0_29ck790 FIND v(dout0_29) AT=400.025n

.meas tran vdout0_30ck790 FIND v(dout0_30) AT=400.025n

.meas tran vdout0_31ck790 FIND v(dout0_31) AT=400.025n

.meas tran vdout0_32ck790 FIND v(dout0_32) AT=400.025n

.meas tran vdout0_33ck790 FIND v(dout0_33) AT=400.025n

.meas tran vdout0_34ck790 FIND v(dout0_34) AT=400.025n

.meas tran vdout0_35ck790 FIND v(dout0_35) AT=400.025n

.meas tran vdout0_36ck790 FIND v(dout0_36) AT=400.025n

.meas tran vdout0_37ck790 FIND v(dout0_37) AT=400.025n

.meas tran vdout0_38ck790 FIND v(dout0_38) AT=400.025n

.meas tran vdout0_39ck790 FIND v(dout0_39) AT=400.025n

.meas tran vdout0_40ck790 FIND v(dout0_40) AT=400.025n

.meas tran vdout0_41ck790 FIND v(dout0_41) AT=400.025n

.meas tran vdout0_42ck790 FIND v(dout0_42) AT=400.025n

.meas tran vdout0_43ck790 FIND v(dout0_43) AT=400.025n

.meas tran vdout0_44ck790 FIND v(dout0_44) AT=400.025n

.meas tran vdout0_45ck790 FIND v(dout0_45) AT=400.025n

.meas tran vdout0_46ck790 FIND v(dout0_46) AT=400.025n

.meas tran vdout0_47ck790 FIND v(dout0_47) AT=400.025n

.meas tran vdout0_48ck790 FIND v(dout0_48) AT=400.025n

.meas tran vdout0_49ck790 FIND v(dout0_49) AT=400.025n

.meas tran vdout0_50ck790 FIND v(dout0_50) AT=400.025n

.meas tran vdout0_51ck790 FIND v(dout0_51) AT=400.025n

.meas tran vdout0_52ck790 FIND v(dout0_52) AT=400.025n

.meas tran vdout0_53ck790 FIND v(dout0_53) AT=400.025n

.meas tran vdout0_54ck790 FIND v(dout0_54) AT=400.025n

.meas tran vdout0_55ck790 FIND v(dout0_55) AT=400.025n

.meas tran vdout0_56ck790 FIND v(dout0_56) AT=400.025n

.meas tran vdout0_57ck790 FIND v(dout0_57) AT=400.025n

.meas tran vdout0_58ck790 FIND v(dout0_58) AT=400.025n

.meas tran vdout0_59ck790 FIND v(dout0_59) AT=400.025n

.meas tran vdout0_60ck790 FIND v(dout0_60) AT=400.025n

.meas tran vdout0_61ck790 FIND v(dout0_61) AT=400.025n

.meas tran vdout0_62ck790 FIND v(dout0_62) AT=400.025n

.meas tran vdout0_63ck790 FIND v(dout0_63) AT=400.025n

.meas tran vdout0_64ck790 FIND v(dout0_64) AT=400.025n

.meas tran vdout0_65ck790 FIND v(dout0_65) AT=400.025n

.meas tran vdout0_66ck790 FIND v(dout0_66) AT=400.025n

.meas tran vdout0_67ck790 FIND v(dout0_67) AT=400.025n

.meas tran vdout0_68ck790 FIND v(dout0_68) AT=400.025n

.meas tran vdout0_69ck790 FIND v(dout0_69) AT=400.025n

.meas tran vdout0_70ck790 FIND v(dout0_70) AT=400.025n

.meas tran vdout0_71ck790 FIND v(dout0_71) AT=400.025n

.meas tran vdout0_72ck790 FIND v(dout0_72) AT=400.025n

.meas tran vdout0_73ck790 FIND v(dout0_73) AT=400.025n

.meas tran vdout0_74ck790 FIND v(dout0_74) AT=400.025n

.meas tran vdout0_75ck790 FIND v(dout0_75) AT=400.025n

.meas tran vdout0_76ck790 FIND v(dout0_76) AT=400.025n

.meas tran vdout0_77ck790 FIND v(dout0_77) AT=400.025n

.meas tran vdout0_78ck790 FIND v(dout0_78) AT=400.025n

.meas tran vdout0_79ck790 FIND v(dout0_79) AT=400.025n

.meas tran vdout0_80ck790 FIND v(dout0_80) AT=400.025n

.meas tran vdout0_81ck790 FIND v(dout0_81) AT=400.025n

.meas tran vdout0_82ck790 FIND v(dout0_82) AT=400.025n

.meas tran vdout0_83ck790 FIND v(dout0_83) AT=400.025n

.meas tran vdout0_84ck790 FIND v(dout0_84) AT=400.025n

.meas tran vdout0_85ck790 FIND v(dout0_85) AT=400.025n

.meas tran vdout0_86ck790 FIND v(dout0_86) AT=400.025n

.meas tran vdout0_87ck790 FIND v(dout0_87) AT=400.025n

.meas tran vdout0_88ck790 FIND v(dout0_88) AT=400.025n

.meas tran vdout0_89ck790 FIND v(dout0_89) AT=400.025n

.meas tran vdout0_90ck790 FIND v(dout0_90) AT=400.025n

.meas tran vdout0_91ck790 FIND v(dout0_91) AT=400.025n

.meas tran vdout0_92ck790 FIND v(dout0_92) AT=400.025n

.meas tran vdout0_93ck790 FIND v(dout0_93) AT=400.025n

.meas tran vdout0_94ck790 FIND v(dout0_94) AT=400.025n

.meas tran vdout0_95ck790 FIND v(dout0_95) AT=400.025n

.meas tran vdout0_96ck790 FIND v(dout0_96) AT=400.025n

.meas tran vdout0_97ck790 FIND v(dout0_97) AT=400.025n

.meas tran vdout0_98ck790 FIND v(dout0_98) AT=400.025n

.meas tran vdout0_99ck790 FIND v(dout0_99) AT=400.025n

.meas tran vdout0_100ck790 FIND v(dout0_100) AT=400.025n

.meas tran vdout0_101ck790 FIND v(dout0_101) AT=400.025n

.meas tran vdout0_102ck790 FIND v(dout0_102) AT=400.025n

.meas tran vdout0_103ck790 FIND v(dout0_103) AT=400.025n

.meas tran vdout0_104ck790 FIND v(dout0_104) AT=400.025n

.meas tran vdout0_105ck790 FIND v(dout0_105) AT=400.025n

.meas tran vdout0_106ck790 FIND v(dout0_106) AT=400.025n

.meas tran vdout0_107ck790 FIND v(dout0_107) AT=400.025n

.meas tran vdout0_108ck790 FIND v(dout0_108) AT=400.025n

.meas tran vdout0_109ck790 FIND v(dout0_109) AT=400.025n

.meas tran vdout0_110ck790 FIND v(dout0_110) AT=400.025n

.meas tran vdout0_111ck790 FIND v(dout0_111) AT=400.025n

.meas tran vdout0_112ck790 FIND v(dout0_112) AT=400.025n

.meas tran vdout0_113ck790 FIND v(dout0_113) AT=400.025n

.meas tran vdout0_114ck790 FIND v(dout0_114) AT=400.025n

.meas tran vdout0_115ck790 FIND v(dout0_115) AT=400.025n

.meas tran vdout0_116ck790 FIND v(dout0_116) AT=400.025n

.meas tran vdout0_117ck790 FIND v(dout0_117) AT=400.025n

.meas tran vdout0_118ck790 FIND v(dout0_118) AT=400.025n

.meas tran vdout0_119ck790 FIND v(dout0_119) AT=400.025n

.meas tran vdout0_120ck790 FIND v(dout0_120) AT=400.025n

.meas tran vdout0_121ck790 FIND v(dout0_121) AT=400.025n

.meas tran vdout0_122ck790 FIND v(dout0_122) AT=400.025n

.meas tran vdout0_123ck790 FIND v(dout0_123) AT=400.025n

.meas tran vdout0_124ck790 FIND v(dout0_124) AT=400.025n

.meas tran vdout0_125ck790 FIND v(dout0_125) AT=400.025n

.meas tran vdout0_126ck790 FIND v(dout0_126) AT=400.025n

.meas tran vdout0_127ck790 FIND v(dout0_127) AT=400.025n

.meas tran vdout0_128ck790 FIND v(dout0_128) AT=400.025n

.meas tran vdout0_129ck790 FIND v(dout0_129) AT=400.025n

.meas tran vdout0_130ck790 FIND v(dout0_130) AT=400.025n

.meas tran vdout0_131ck790 FIND v(dout0_131) AT=400.025n

.meas tran vdout0_132ck790 FIND v(dout0_132) AT=400.025n

.meas tran vdout0_133ck790 FIND v(dout0_133) AT=400.025n

.meas tran vdout0_134ck790 FIND v(dout0_134) AT=400.025n

.meas tran vdout0_135ck790 FIND v(dout0_135) AT=400.025n

.meas tran vdout0_136ck790 FIND v(dout0_136) AT=400.025n

.meas tran vdout0_137ck790 FIND v(dout0_137) AT=400.025n

.meas tran vdout0_138ck790 FIND v(dout0_138) AT=400.025n

.meas tran vdout0_139ck790 FIND v(dout0_139) AT=400.025n

.meas tran vdout0_140ck790 FIND v(dout0_140) AT=400.025n

.meas tran vdout0_141ck790 FIND v(dout0_141) AT=400.025n

.meas tran vdout0_142ck790 FIND v(dout0_142) AT=400.025n

.meas tran vdout0_143ck790 FIND v(dout0_143) AT=400.025n

.meas tran vdout0_144ck790 FIND v(dout0_144) AT=400.025n

.meas tran vdout0_145ck790 FIND v(dout0_145) AT=400.025n

.meas tran vdout0_146ck790 FIND v(dout0_146) AT=400.025n

.meas tran vdout0_147ck790 FIND v(dout0_147) AT=400.025n

.meas tran vdout0_148ck790 FIND v(dout0_148) AT=400.025n

.meas tran vdout0_149ck790 FIND v(dout0_149) AT=400.025n

.meas tran vdout0_150ck790 FIND v(dout0_150) AT=400.025n

.meas tran vdout0_151ck790 FIND v(dout0_151) AT=400.025n

.meas tran vdout0_152ck790 FIND v(dout0_152) AT=400.025n

.meas tran vdout0_153ck790 FIND v(dout0_153) AT=400.025n

.meas tran vdout0_154ck790 FIND v(dout0_154) AT=400.025n

.meas tran vdout0_155ck790 FIND v(dout0_155) AT=400.025n

.meas tran vdout0_156ck790 FIND v(dout0_156) AT=400.025n

.meas tran vdout0_157ck790 FIND v(dout0_157) AT=400.025n

.meas tran vdout0_158ck790 FIND v(dout0_158) AT=400.025n

.meas tran vdout0_159ck790 FIND v(dout0_159) AT=400.025n

.meas tran vdout0_160ck790 FIND v(dout0_160) AT=400.025n

.meas tran vdout0_161ck790 FIND v(dout0_161) AT=400.025n

.meas tran vdout0_162ck790 FIND v(dout0_162) AT=400.025n

.meas tran vdout0_163ck790 FIND v(dout0_163) AT=400.025n

.meas tran vdout0_164ck790 FIND v(dout0_164) AT=400.025n

.meas tran vdout0_165ck790 FIND v(dout0_165) AT=400.025n

.meas tran vdout0_166ck790 FIND v(dout0_166) AT=400.025n

.meas tran vdout0_167ck790 FIND v(dout0_167) AT=400.025n

.meas tran vdout0_168ck790 FIND v(dout0_168) AT=400.025n

.meas tran vdout0_169ck790 FIND v(dout0_169) AT=400.025n

.meas tran vdout0_170ck790 FIND v(dout0_170) AT=400.025n

.meas tran vdout0_171ck790 FIND v(dout0_171) AT=400.025n

.meas tran vdout0_172ck790 FIND v(dout0_172) AT=400.025n

.meas tran vdout0_173ck790 FIND v(dout0_173) AT=400.025n

.meas tran vdout0_174ck790 FIND v(dout0_174) AT=400.025n

.meas tran vdout0_175ck790 FIND v(dout0_175) AT=400.025n

.meas tran vdout0_176ck790 FIND v(dout0_176) AT=400.025n

.meas tran vdout0_177ck790 FIND v(dout0_177) AT=400.025n

.meas tran vdout0_178ck790 FIND v(dout0_178) AT=400.025n

.meas tran vdout0_179ck790 FIND v(dout0_179) AT=400.025n

.meas tran vdout0_180ck790 FIND v(dout0_180) AT=400.025n

.meas tran vdout0_181ck790 FIND v(dout0_181) AT=400.025n

.meas tran vdout0_182ck790 FIND v(dout0_182) AT=400.025n

.meas tran vdout0_183ck790 FIND v(dout0_183) AT=400.025n

.meas tran vdout0_184ck790 FIND v(dout0_184) AT=400.025n

.meas tran vdout0_185ck790 FIND v(dout0_185) AT=400.025n

.meas tran vdout0_186ck790 FIND v(dout0_186) AT=400.025n

.meas tran vdout0_187ck790 FIND v(dout0_187) AT=400.025n

.meas tran vdout0_188ck790 FIND v(dout0_188) AT=400.025n

.meas tran vdout0_189ck790 FIND v(dout0_189) AT=400.025n

.meas tran vdout0_190ck790 FIND v(dout0_190) AT=400.025n

.meas tran vdout0_191ck790 FIND v(dout0_191) AT=400.025n

.meas tran vdout0_192ck790 FIND v(dout0_192) AT=400.025n

.meas tran vdout0_193ck790 FIND v(dout0_193) AT=400.025n

.meas tran vdout0_194ck790 FIND v(dout0_194) AT=400.025n

.meas tran vdout0_195ck790 FIND v(dout0_195) AT=400.025n

.meas tran vdout0_196ck790 FIND v(dout0_196) AT=400.025n

.meas tran vdout0_197ck790 FIND v(dout0_197) AT=400.025n

.meas tran vdout0_198ck790 FIND v(dout0_198) AT=400.025n

.meas tran vdout0_199ck790 FIND v(dout0_199) AT=400.025n

.meas tran vdout0_200ck790 FIND v(dout0_200) AT=400.025n

.meas tran vdout0_201ck790 FIND v(dout0_201) AT=400.025n

.meas tran vdout0_202ck790 FIND v(dout0_202) AT=400.025n

.meas tran vdout0_203ck790 FIND v(dout0_203) AT=400.025n

.meas tran vdout0_204ck790 FIND v(dout0_204) AT=400.025n

.meas tran vdout0_205ck790 FIND v(dout0_205) AT=400.025n

.meas tran vdout0_206ck790 FIND v(dout0_206) AT=400.025n

.meas tran vdout0_207ck790 FIND v(dout0_207) AT=400.025n

.meas tran vdout0_208ck790 FIND v(dout0_208) AT=400.025n

.meas tran vdout0_209ck790 FIND v(dout0_209) AT=400.025n

.meas tran vdout0_210ck790 FIND v(dout0_210) AT=400.025n

.meas tran vdout0_211ck790 FIND v(dout0_211) AT=400.025n

.meas tran vdout0_212ck790 FIND v(dout0_212) AT=400.025n

.meas tran vdout0_213ck790 FIND v(dout0_213) AT=400.025n

.meas tran vdout0_214ck790 FIND v(dout0_214) AT=400.025n

.meas tran vdout0_215ck790 FIND v(dout0_215) AT=400.025n

.meas tran vdout0_216ck790 FIND v(dout0_216) AT=400.025n

.meas tran vdout0_217ck790 FIND v(dout0_217) AT=400.025n

.meas tran vdout0_218ck790 FIND v(dout0_218) AT=400.025n

.meas tran vdout0_219ck790 FIND v(dout0_219) AT=400.025n

.meas tran vdout0_220ck790 FIND v(dout0_220) AT=400.025n

.meas tran vdout0_221ck790 FIND v(dout0_221) AT=400.025n

.meas tran vdout0_222ck790 FIND v(dout0_222) AT=400.025n

.meas tran vdout0_223ck790 FIND v(dout0_223) AT=400.025n

.meas tran vdout0_224ck790 FIND v(dout0_224) AT=400.025n

.meas tran vdout0_225ck790 FIND v(dout0_225) AT=400.025n

.meas tran vdout0_226ck790 FIND v(dout0_226) AT=400.025n

.meas tran vdout0_227ck790 FIND v(dout0_227) AT=400.025n

.meas tran vdout0_228ck790 FIND v(dout0_228) AT=400.025n

.meas tran vdout0_229ck790 FIND v(dout0_229) AT=400.025n

.meas tran vdout0_230ck790 FIND v(dout0_230) AT=400.025n

.meas tran vdout0_231ck790 FIND v(dout0_231) AT=400.025n

.meas tran vdout0_232ck790 FIND v(dout0_232) AT=400.025n

.meas tran vdout0_233ck790 FIND v(dout0_233) AT=400.025n

.meas tran vdout0_234ck790 FIND v(dout0_234) AT=400.025n

.meas tran vdout0_235ck790 FIND v(dout0_235) AT=400.025n

.meas tran vdout0_236ck790 FIND v(dout0_236) AT=400.025n

.meas tran vdout0_237ck790 FIND v(dout0_237) AT=400.025n

.meas tran vdout0_238ck790 FIND v(dout0_238) AT=400.025n

.meas tran vdout0_239ck790 FIND v(dout0_239) AT=400.025n

.meas tran vdout0_240ck790 FIND v(dout0_240) AT=400.025n

.meas tran vdout0_241ck790 FIND v(dout0_241) AT=400.025n

.meas tran vdout0_242ck790 FIND v(dout0_242) AT=400.025n

.meas tran vdout0_243ck790 FIND v(dout0_243) AT=400.025n

.meas tran vdout0_244ck790 FIND v(dout0_244) AT=400.025n

.meas tran vdout0_245ck790 FIND v(dout0_245) AT=400.025n

.meas tran vdout0_246ck790 FIND v(dout0_246) AT=400.025n

.meas tran vdout0_247ck790 FIND v(dout0_247) AT=400.025n

.meas tran vdout0_248ck790 FIND v(dout0_248) AT=400.025n

.meas tran vdout0_249ck790 FIND v(dout0_249) AT=400.025n

.meas tran vdout0_250ck790 FIND v(dout0_250) AT=400.025n

.meas tran vdout0_251ck790 FIND v(dout0_251) AT=400.025n

.meas tran vdout0_252ck790 FIND v(dout0_252) AT=400.025n

.meas tran vdout0_253ck790 FIND v(dout0_253) AT=400.025n

.meas tran vdout0_254ck790 FIND v(dout0_254) AT=400.025n

.meas tran vdout0_255ck790 FIND v(dout0_255) AT=400.025n

.meas tran vdout0_0ck850 FIND v(dout0_0) AT=430.025n

.meas tran vdout0_1ck850 FIND v(dout0_1) AT=430.025n

.meas tran vdout0_2ck850 FIND v(dout0_2) AT=430.025n

.meas tran vdout0_3ck850 FIND v(dout0_3) AT=430.025n

.meas tran vdout0_4ck850 FIND v(dout0_4) AT=430.025n

.meas tran vdout0_5ck850 FIND v(dout0_5) AT=430.025n

.meas tran vdout0_6ck850 FIND v(dout0_6) AT=430.025n

.meas tran vdout0_7ck850 FIND v(dout0_7) AT=430.025n

.meas tran vdout0_8ck850 FIND v(dout0_8) AT=430.025n

.meas tran vdout0_9ck850 FIND v(dout0_9) AT=430.025n

.meas tran vdout0_10ck850 FIND v(dout0_10) AT=430.025n

.meas tran vdout0_11ck850 FIND v(dout0_11) AT=430.025n

.meas tran vdout0_12ck850 FIND v(dout0_12) AT=430.025n

.meas tran vdout0_13ck850 FIND v(dout0_13) AT=430.025n

.meas tran vdout0_14ck850 FIND v(dout0_14) AT=430.025n

.meas tran vdout0_15ck850 FIND v(dout0_15) AT=430.025n

.meas tran vdout0_16ck850 FIND v(dout0_16) AT=430.025n

.meas tran vdout0_17ck850 FIND v(dout0_17) AT=430.025n

.meas tran vdout0_18ck850 FIND v(dout0_18) AT=430.025n

.meas tran vdout0_19ck850 FIND v(dout0_19) AT=430.025n

.meas tran vdout0_20ck850 FIND v(dout0_20) AT=430.025n

.meas tran vdout0_21ck850 FIND v(dout0_21) AT=430.025n

.meas tran vdout0_22ck850 FIND v(dout0_22) AT=430.025n

.meas tran vdout0_23ck850 FIND v(dout0_23) AT=430.025n

.meas tran vdout0_24ck850 FIND v(dout0_24) AT=430.025n

.meas tran vdout0_25ck850 FIND v(dout0_25) AT=430.025n

.meas tran vdout0_26ck850 FIND v(dout0_26) AT=430.025n

.meas tran vdout0_27ck850 FIND v(dout0_27) AT=430.025n

.meas tran vdout0_28ck850 FIND v(dout0_28) AT=430.025n

.meas tran vdout0_29ck850 FIND v(dout0_29) AT=430.025n

.meas tran vdout0_30ck850 FIND v(dout0_30) AT=430.025n

.meas tran vdout0_31ck850 FIND v(dout0_31) AT=430.025n

.meas tran vdout0_32ck850 FIND v(dout0_32) AT=430.025n

.meas tran vdout0_33ck850 FIND v(dout0_33) AT=430.025n

.meas tran vdout0_34ck850 FIND v(dout0_34) AT=430.025n

.meas tran vdout0_35ck850 FIND v(dout0_35) AT=430.025n

.meas tran vdout0_36ck850 FIND v(dout0_36) AT=430.025n

.meas tran vdout0_37ck850 FIND v(dout0_37) AT=430.025n

.meas tran vdout0_38ck850 FIND v(dout0_38) AT=430.025n

.meas tran vdout0_39ck850 FIND v(dout0_39) AT=430.025n

.meas tran vdout0_40ck850 FIND v(dout0_40) AT=430.025n

.meas tran vdout0_41ck850 FIND v(dout0_41) AT=430.025n

.meas tran vdout0_42ck850 FIND v(dout0_42) AT=430.025n

.meas tran vdout0_43ck850 FIND v(dout0_43) AT=430.025n

.meas tran vdout0_44ck850 FIND v(dout0_44) AT=430.025n

.meas tran vdout0_45ck850 FIND v(dout0_45) AT=430.025n

.meas tran vdout0_46ck850 FIND v(dout0_46) AT=430.025n

.meas tran vdout0_47ck850 FIND v(dout0_47) AT=430.025n

.meas tran vdout0_48ck850 FIND v(dout0_48) AT=430.025n

.meas tran vdout0_49ck850 FIND v(dout0_49) AT=430.025n

.meas tran vdout0_50ck850 FIND v(dout0_50) AT=430.025n

.meas tran vdout0_51ck850 FIND v(dout0_51) AT=430.025n

.meas tran vdout0_52ck850 FIND v(dout0_52) AT=430.025n

.meas tran vdout0_53ck850 FIND v(dout0_53) AT=430.025n

.meas tran vdout0_54ck850 FIND v(dout0_54) AT=430.025n

.meas tran vdout0_55ck850 FIND v(dout0_55) AT=430.025n

.meas tran vdout0_56ck850 FIND v(dout0_56) AT=430.025n

.meas tran vdout0_57ck850 FIND v(dout0_57) AT=430.025n

.meas tran vdout0_58ck850 FIND v(dout0_58) AT=430.025n

.meas tran vdout0_59ck850 FIND v(dout0_59) AT=430.025n

.meas tran vdout0_60ck850 FIND v(dout0_60) AT=430.025n

.meas tran vdout0_61ck850 FIND v(dout0_61) AT=430.025n

.meas tran vdout0_62ck850 FIND v(dout0_62) AT=430.025n

.meas tran vdout0_63ck850 FIND v(dout0_63) AT=430.025n

.meas tran vdout0_64ck850 FIND v(dout0_64) AT=430.025n

.meas tran vdout0_65ck850 FIND v(dout0_65) AT=430.025n

.meas tran vdout0_66ck850 FIND v(dout0_66) AT=430.025n

.meas tran vdout0_67ck850 FIND v(dout0_67) AT=430.025n

.meas tran vdout0_68ck850 FIND v(dout0_68) AT=430.025n

.meas tran vdout0_69ck850 FIND v(dout0_69) AT=430.025n

.meas tran vdout0_70ck850 FIND v(dout0_70) AT=430.025n

.meas tran vdout0_71ck850 FIND v(dout0_71) AT=430.025n

.meas tran vdout0_72ck850 FIND v(dout0_72) AT=430.025n

.meas tran vdout0_73ck850 FIND v(dout0_73) AT=430.025n

.meas tran vdout0_74ck850 FIND v(dout0_74) AT=430.025n

.meas tran vdout0_75ck850 FIND v(dout0_75) AT=430.025n

.meas tran vdout0_76ck850 FIND v(dout0_76) AT=430.025n

.meas tran vdout0_77ck850 FIND v(dout0_77) AT=430.025n

.meas tran vdout0_78ck850 FIND v(dout0_78) AT=430.025n

.meas tran vdout0_79ck850 FIND v(dout0_79) AT=430.025n

.meas tran vdout0_80ck850 FIND v(dout0_80) AT=430.025n

.meas tran vdout0_81ck850 FIND v(dout0_81) AT=430.025n

.meas tran vdout0_82ck850 FIND v(dout0_82) AT=430.025n

.meas tran vdout0_83ck850 FIND v(dout0_83) AT=430.025n

.meas tran vdout0_84ck850 FIND v(dout0_84) AT=430.025n

.meas tran vdout0_85ck850 FIND v(dout0_85) AT=430.025n

.meas tran vdout0_86ck850 FIND v(dout0_86) AT=430.025n

.meas tran vdout0_87ck850 FIND v(dout0_87) AT=430.025n

.meas tran vdout0_88ck850 FIND v(dout0_88) AT=430.025n

.meas tran vdout0_89ck850 FIND v(dout0_89) AT=430.025n

.meas tran vdout0_90ck850 FIND v(dout0_90) AT=430.025n

.meas tran vdout0_91ck850 FIND v(dout0_91) AT=430.025n

.meas tran vdout0_92ck850 FIND v(dout0_92) AT=430.025n

.meas tran vdout0_93ck850 FIND v(dout0_93) AT=430.025n

.meas tran vdout0_94ck850 FIND v(dout0_94) AT=430.025n

.meas tran vdout0_95ck850 FIND v(dout0_95) AT=430.025n

.meas tran vdout0_96ck850 FIND v(dout0_96) AT=430.025n

.meas tran vdout0_97ck850 FIND v(dout0_97) AT=430.025n

.meas tran vdout0_98ck850 FIND v(dout0_98) AT=430.025n

.meas tran vdout0_99ck850 FIND v(dout0_99) AT=430.025n

.meas tran vdout0_100ck850 FIND v(dout0_100) AT=430.025n

.meas tran vdout0_101ck850 FIND v(dout0_101) AT=430.025n

.meas tran vdout0_102ck850 FIND v(dout0_102) AT=430.025n

.meas tran vdout0_103ck850 FIND v(dout0_103) AT=430.025n

.meas tran vdout0_104ck850 FIND v(dout0_104) AT=430.025n

.meas tran vdout0_105ck850 FIND v(dout0_105) AT=430.025n

.meas tran vdout0_106ck850 FIND v(dout0_106) AT=430.025n

.meas tran vdout0_107ck850 FIND v(dout0_107) AT=430.025n

.meas tran vdout0_108ck850 FIND v(dout0_108) AT=430.025n

.meas tran vdout0_109ck850 FIND v(dout0_109) AT=430.025n

.meas tran vdout0_110ck850 FIND v(dout0_110) AT=430.025n

.meas tran vdout0_111ck850 FIND v(dout0_111) AT=430.025n

.meas tran vdout0_112ck850 FIND v(dout0_112) AT=430.025n

.meas tran vdout0_113ck850 FIND v(dout0_113) AT=430.025n

.meas tran vdout0_114ck850 FIND v(dout0_114) AT=430.025n

.meas tran vdout0_115ck850 FIND v(dout0_115) AT=430.025n

.meas tran vdout0_116ck850 FIND v(dout0_116) AT=430.025n

.meas tran vdout0_117ck850 FIND v(dout0_117) AT=430.025n

.meas tran vdout0_118ck850 FIND v(dout0_118) AT=430.025n

.meas tran vdout0_119ck850 FIND v(dout0_119) AT=430.025n

.meas tran vdout0_120ck850 FIND v(dout0_120) AT=430.025n

.meas tran vdout0_121ck850 FIND v(dout0_121) AT=430.025n

.meas tran vdout0_122ck850 FIND v(dout0_122) AT=430.025n

.meas tran vdout0_123ck850 FIND v(dout0_123) AT=430.025n

.meas tran vdout0_124ck850 FIND v(dout0_124) AT=430.025n

.meas tran vdout0_125ck850 FIND v(dout0_125) AT=430.025n

.meas tran vdout0_126ck850 FIND v(dout0_126) AT=430.025n

.meas tran vdout0_127ck850 FIND v(dout0_127) AT=430.025n

.meas tran vdout0_128ck850 FIND v(dout0_128) AT=430.025n

.meas tran vdout0_129ck850 FIND v(dout0_129) AT=430.025n

.meas tran vdout0_130ck850 FIND v(dout0_130) AT=430.025n

.meas tran vdout0_131ck850 FIND v(dout0_131) AT=430.025n

.meas tran vdout0_132ck850 FIND v(dout0_132) AT=430.025n

.meas tran vdout0_133ck850 FIND v(dout0_133) AT=430.025n

.meas tran vdout0_134ck850 FIND v(dout0_134) AT=430.025n

.meas tran vdout0_135ck850 FIND v(dout0_135) AT=430.025n

.meas tran vdout0_136ck850 FIND v(dout0_136) AT=430.025n

.meas tran vdout0_137ck850 FIND v(dout0_137) AT=430.025n

.meas tran vdout0_138ck850 FIND v(dout0_138) AT=430.025n

.meas tran vdout0_139ck850 FIND v(dout0_139) AT=430.025n

.meas tran vdout0_140ck850 FIND v(dout0_140) AT=430.025n

.meas tran vdout0_141ck850 FIND v(dout0_141) AT=430.025n

.meas tran vdout0_142ck850 FIND v(dout0_142) AT=430.025n

.meas tran vdout0_143ck850 FIND v(dout0_143) AT=430.025n

.meas tran vdout0_144ck850 FIND v(dout0_144) AT=430.025n

.meas tran vdout0_145ck850 FIND v(dout0_145) AT=430.025n

.meas tran vdout0_146ck850 FIND v(dout0_146) AT=430.025n

.meas tran vdout0_147ck850 FIND v(dout0_147) AT=430.025n

.meas tran vdout0_148ck850 FIND v(dout0_148) AT=430.025n

.meas tran vdout0_149ck850 FIND v(dout0_149) AT=430.025n

.meas tran vdout0_150ck850 FIND v(dout0_150) AT=430.025n

.meas tran vdout0_151ck850 FIND v(dout0_151) AT=430.025n

.meas tran vdout0_152ck850 FIND v(dout0_152) AT=430.025n

.meas tran vdout0_153ck850 FIND v(dout0_153) AT=430.025n

.meas tran vdout0_154ck850 FIND v(dout0_154) AT=430.025n

.meas tran vdout0_155ck850 FIND v(dout0_155) AT=430.025n

.meas tran vdout0_156ck850 FIND v(dout0_156) AT=430.025n

.meas tran vdout0_157ck850 FIND v(dout0_157) AT=430.025n

.meas tran vdout0_158ck850 FIND v(dout0_158) AT=430.025n

.meas tran vdout0_159ck850 FIND v(dout0_159) AT=430.025n

.meas tran vdout0_160ck850 FIND v(dout0_160) AT=430.025n

.meas tran vdout0_161ck850 FIND v(dout0_161) AT=430.025n

.meas tran vdout0_162ck850 FIND v(dout0_162) AT=430.025n

.meas tran vdout0_163ck850 FIND v(dout0_163) AT=430.025n

.meas tran vdout0_164ck850 FIND v(dout0_164) AT=430.025n

.meas tran vdout0_165ck850 FIND v(dout0_165) AT=430.025n

.meas tran vdout0_166ck850 FIND v(dout0_166) AT=430.025n

.meas tran vdout0_167ck850 FIND v(dout0_167) AT=430.025n

.meas tran vdout0_168ck850 FIND v(dout0_168) AT=430.025n

.meas tran vdout0_169ck850 FIND v(dout0_169) AT=430.025n

.meas tran vdout0_170ck850 FIND v(dout0_170) AT=430.025n

.meas tran vdout0_171ck850 FIND v(dout0_171) AT=430.025n

.meas tran vdout0_172ck850 FIND v(dout0_172) AT=430.025n

.meas tran vdout0_173ck850 FIND v(dout0_173) AT=430.025n

.meas tran vdout0_174ck850 FIND v(dout0_174) AT=430.025n

.meas tran vdout0_175ck850 FIND v(dout0_175) AT=430.025n

.meas tran vdout0_176ck850 FIND v(dout0_176) AT=430.025n

.meas tran vdout0_177ck850 FIND v(dout0_177) AT=430.025n

.meas tran vdout0_178ck850 FIND v(dout0_178) AT=430.025n

.meas tran vdout0_179ck850 FIND v(dout0_179) AT=430.025n

.meas tran vdout0_180ck850 FIND v(dout0_180) AT=430.025n

.meas tran vdout0_181ck850 FIND v(dout0_181) AT=430.025n

.meas tran vdout0_182ck850 FIND v(dout0_182) AT=430.025n

.meas tran vdout0_183ck850 FIND v(dout0_183) AT=430.025n

.meas tran vdout0_184ck850 FIND v(dout0_184) AT=430.025n

.meas tran vdout0_185ck850 FIND v(dout0_185) AT=430.025n

.meas tran vdout0_186ck850 FIND v(dout0_186) AT=430.025n

.meas tran vdout0_187ck850 FIND v(dout0_187) AT=430.025n

.meas tran vdout0_188ck850 FIND v(dout0_188) AT=430.025n

.meas tran vdout0_189ck850 FIND v(dout0_189) AT=430.025n

.meas tran vdout0_190ck850 FIND v(dout0_190) AT=430.025n

.meas tran vdout0_191ck850 FIND v(dout0_191) AT=430.025n

.meas tran vdout0_192ck850 FIND v(dout0_192) AT=430.025n

.meas tran vdout0_193ck850 FIND v(dout0_193) AT=430.025n

.meas tran vdout0_194ck850 FIND v(dout0_194) AT=430.025n

.meas tran vdout0_195ck850 FIND v(dout0_195) AT=430.025n

.meas tran vdout0_196ck850 FIND v(dout0_196) AT=430.025n

.meas tran vdout0_197ck850 FIND v(dout0_197) AT=430.025n

.meas tran vdout0_198ck850 FIND v(dout0_198) AT=430.025n

.meas tran vdout0_199ck850 FIND v(dout0_199) AT=430.025n

.meas tran vdout0_200ck850 FIND v(dout0_200) AT=430.025n

.meas tran vdout0_201ck850 FIND v(dout0_201) AT=430.025n

.meas tran vdout0_202ck850 FIND v(dout0_202) AT=430.025n

.meas tran vdout0_203ck850 FIND v(dout0_203) AT=430.025n

.meas tran vdout0_204ck850 FIND v(dout0_204) AT=430.025n

.meas tran vdout0_205ck850 FIND v(dout0_205) AT=430.025n

.meas tran vdout0_206ck850 FIND v(dout0_206) AT=430.025n

.meas tran vdout0_207ck850 FIND v(dout0_207) AT=430.025n

.meas tran vdout0_208ck850 FIND v(dout0_208) AT=430.025n

.meas tran vdout0_209ck850 FIND v(dout0_209) AT=430.025n

.meas tran vdout0_210ck850 FIND v(dout0_210) AT=430.025n

.meas tran vdout0_211ck850 FIND v(dout0_211) AT=430.025n

.meas tran vdout0_212ck850 FIND v(dout0_212) AT=430.025n

.meas tran vdout0_213ck850 FIND v(dout0_213) AT=430.025n

.meas tran vdout0_214ck850 FIND v(dout0_214) AT=430.025n

.meas tran vdout0_215ck850 FIND v(dout0_215) AT=430.025n

.meas tran vdout0_216ck850 FIND v(dout0_216) AT=430.025n

.meas tran vdout0_217ck850 FIND v(dout0_217) AT=430.025n

.meas tran vdout0_218ck850 FIND v(dout0_218) AT=430.025n

.meas tran vdout0_219ck850 FIND v(dout0_219) AT=430.025n

.meas tran vdout0_220ck850 FIND v(dout0_220) AT=430.025n

.meas tran vdout0_221ck850 FIND v(dout0_221) AT=430.025n

.meas tran vdout0_222ck850 FIND v(dout0_222) AT=430.025n

.meas tran vdout0_223ck850 FIND v(dout0_223) AT=430.025n

.meas tran vdout0_224ck850 FIND v(dout0_224) AT=430.025n

.meas tran vdout0_225ck850 FIND v(dout0_225) AT=430.025n

.meas tran vdout0_226ck850 FIND v(dout0_226) AT=430.025n

.meas tran vdout0_227ck850 FIND v(dout0_227) AT=430.025n

.meas tran vdout0_228ck850 FIND v(dout0_228) AT=430.025n

.meas tran vdout0_229ck850 FIND v(dout0_229) AT=430.025n

.meas tran vdout0_230ck850 FIND v(dout0_230) AT=430.025n

.meas tran vdout0_231ck850 FIND v(dout0_231) AT=430.025n

.meas tran vdout0_232ck850 FIND v(dout0_232) AT=430.025n

.meas tran vdout0_233ck850 FIND v(dout0_233) AT=430.025n

.meas tran vdout0_234ck850 FIND v(dout0_234) AT=430.025n

.meas tran vdout0_235ck850 FIND v(dout0_235) AT=430.025n

.meas tran vdout0_236ck850 FIND v(dout0_236) AT=430.025n

.meas tran vdout0_237ck850 FIND v(dout0_237) AT=430.025n

.meas tran vdout0_238ck850 FIND v(dout0_238) AT=430.025n

.meas tran vdout0_239ck850 FIND v(dout0_239) AT=430.025n

.meas tran vdout0_240ck850 FIND v(dout0_240) AT=430.025n

.meas tran vdout0_241ck850 FIND v(dout0_241) AT=430.025n

.meas tran vdout0_242ck850 FIND v(dout0_242) AT=430.025n

.meas tran vdout0_243ck850 FIND v(dout0_243) AT=430.025n

.meas tran vdout0_244ck850 FIND v(dout0_244) AT=430.025n

.meas tran vdout0_245ck850 FIND v(dout0_245) AT=430.025n

.meas tran vdout0_246ck850 FIND v(dout0_246) AT=430.025n

.meas tran vdout0_247ck850 FIND v(dout0_247) AT=430.025n

.meas tran vdout0_248ck850 FIND v(dout0_248) AT=430.025n

.meas tran vdout0_249ck850 FIND v(dout0_249) AT=430.025n

.meas tran vdout0_250ck850 FIND v(dout0_250) AT=430.025n

.meas tran vdout0_251ck850 FIND v(dout0_251) AT=430.025n

.meas tran vdout0_252ck850 FIND v(dout0_252) AT=430.025n

.meas tran vdout0_253ck850 FIND v(dout0_253) AT=430.025n

.meas tran vdout0_254ck850 FIND v(dout0_254) AT=430.025n

.meas tran vdout0_255ck850 FIND v(dout0_255) AT=430.025n

.meas tran vdout0_0ck860 FIND v(dout0_0) AT=435.025n

.meas tran vdout0_1ck860 FIND v(dout0_1) AT=435.025n

.meas tran vdout0_2ck860 FIND v(dout0_2) AT=435.025n

.meas tran vdout0_3ck860 FIND v(dout0_3) AT=435.025n

.meas tran vdout0_4ck860 FIND v(dout0_4) AT=435.025n

.meas tran vdout0_5ck860 FIND v(dout0_5) AT=435.025n

.meas tran vdout0_6ck860 FIND v(dout0_6) AT=435.025n

.meas tran vdout0_7ck860 FIND v(dout0_7) AT=435.025n

.meas tran vdout0_8ck860 FIND v(dout0_8) AT=435.025n

.meas tran vdout0_9ck860 FIND v(dout0_9) AT=435.025n

.meas tran vdout0_10ck860 FIND v(dout0_10) AT=435.025n

.meas tran vdout0_11ck860 FIND v(dout0_11) AT=435.025n

.meas tran vdout0_12ck860 FIND v(dout0_12) AT=435.025n

.meas tran vdout0_13ck860 FIND v(dout0_13) AT=435.025n

.meas tran vdout0_14ck860 FIND v(dout0_14) AT=435.025n

.meas tran vdout0_15ck860 FIND v(dout0_15) AT=435.025n

.meas tran vdout0_16ck860 FIND v(dout0_16) AT=435.025n

.meas tran vdout0_17ck860 FIND v(dout0_17) AT=435.025n

.meas tran vdout0_18ck860 FIND v(dout0_18) AT=435.025n

.meas tran vdout0_19ck860 FIND v(dout0_19) AT=435.025n

.meas tran vdout0_20ck860 FIND v(dout0_20) AT=435.025n

.meas tran vdout0_21ck860 FIND v(dout0_21) AT=435.025n

.meas tran vdout0_22ck860 FIND v(dout0_22) AT=435.025n

.meas tran vdout0_23ck860 FIND v(dout0_23) AT=435.025n

.meas tran vdout0_24ck860 FIND v(dout0_24) AT=435.025n

.meas tran vdout0_25ck860 FIND v(dout0_25) AT=435.025n

.meas tran vdout0_26ck860 FIND v(dout0_26) AT=435.025n

.meas tran vdout0_27ck860 FIND v(dout0_27) AT=435.025n

.meas tran vdout0_28ck860 FIND v(dout0_28) AT=435.025n

.meas tran vdout0_29ck860 FIND v(dout0_29) AT=435.025n

.meas tran vdout0_30ck860 FIND v(dout0_30) AT=435.025n

.meas tran vdout0_31ck860 FIND v(dout0_31) AT=435.025n

.meas tran vdout0_32ck860 FIND v(dout0_32) AT=435.025n

.meas tran vdout0_33ck860 FIND v(dout0_33) AT=435.025n

.meas tran vdout0_34ck860 FIND v(dout0_34) AT=435.025n

.meas tran vdout0_35ck860 FIND v(dout0_35) AT=435.025n

.meas tran vdout0_36ck860 FIND v(dout0_36) AT=435.025n

.meas tran vdout0_37ck860 FIND v(dout0_37) AT=435.025n

.meas tran vdout0_38ck860 FIND v(dout0_38) AT=435.025n

.meas tran vdout0_39ck860 FIND v(dout0_39) AT=435.025n

.meas tran vdout0_40ck860 FIND v(dout0_40) AT=435.025n

.meas tran vdout0_41ck860 FIND v(dout0_41) AT=435.025n

.meas tran vdout0_42ck860 FIND v(dout0_42) AT=435.025n

.meas tran vdout0_43ck860 FIND v(dout0_43) AT=435.025n

.meas tran vdout0_44ck860 FIND v(dout0_44) AT=435.025n

.meas tran vdout0_45ck860 FIND v(dout0_45) AT=435.025n

.meas tran vdout0_46ck860 FIND v(dout0_46) AT=435.025n

.meas tran vdout0_47ck860 FIND v(dout0_47) AT=435.025n

.meas tran vdout0_48ck860 FIND v(dout0_48) AT=435.025n

.meas tran vdout0_49ck860 FIND v(dout0_49) AT=435.025n

.meas tran vdout0_50ck860 FIND v(dout0_50) AT=435.025n

.meas tran vdout0_51ck860 FIND v(dout0_51) AT=435.025n

.meas tran vdout0_52ck860 FIND v(dout0_52) AT=435.025n

.meas tran vdout0_53ck860 FIND v(dout0_53) AT=435.025n

.meas tran vdout0_54ck860 FIND v(dout0_54) AT=435.025n

.meas tran vdout0_55ck860 FIND v(dout0_55) AT=435.025n

.meas tran vdout0_56ck860 FIND v(dout0_56) AT=435.025n

.meas tran vdout0_57ck860 FIND v(dout0_57) AT=435.025n

.meas tran vdout0_58ck860 FIND v(dout0_58) AT=435.025n

.meas tran vdout0_59ck860 FIND v(dout0_59) AT=435.025n

.meas tran vdout0_60ck860 FIND v(dout0_60) AT=435.025n

.meas tran vdout0_61ck860 FIND v(dout0_61) AT=435.025n

.meas tran vdout0_62ck860 FIND v(dout0_62) AT=435.025n

.meas tran vdout0_63ck860 FIND v(dout0_63) AT=435.025n

.meas tran vdout0_64ck860 FIND v(dout0_64) AT=435.025n

.meas tran vdout0_65ck860 FIND v(dout0_65) AT=435.025n

.meas tran vdout0_66ck860 FIND v(dout0_66) AT=435.025n

.meas tran vdout0_67ck860 FIND v(dout0_67) AT=435.025n

.meas tran vdout0_68ck860 FIND v(dout0_68) AT=435.025n

.meas tran vdout0_69ck860 FIND v(dout0_69) AT=435.025n

.meas tran vdout0_70ck860 FIND v(dout0_70) AT=435.025n

.meas tran vdout0_71ck860 FIND v(dout0_71) AT=435.025n

.meas tran vdout0_72ck860 FIND v(dout0_72) AT=435.025n

.meas tran vdout0_73ck860 FIND v(dout0_73) AT=435.025n

.meas tran vdout0_74ck860 FIND v(dout0_74) AT=435.025n

.meas tran vdout0_75ck860 FIND v(dout0_75) AT=435.025n

.meas tran vdout0_76ck860 FIND v(dout0_76) AT=435.025n

.meas tran vdout0_77ck860 FIND v(dout0_77) AT=435.025n

.meas tran vdout0_78ck860 FIND v(dout0_78) AT=435.025n

.meas tran vdout0_79ck860 FIND v(dout0_79) AT=435.025n

.meas tran vdout0_80ck860 FIND v(dout0_80) AT=435.025n

.meas tran vdout0_81ck860 FIND v(dout0_81) AT=435.025n

.meas tran vdout0_82ck860 FIND v(dout0_82) AT=435.025n

.meas tran vdout0_83ck860 FIND v(dout0_83) AT=435.025n

.meas tran vdout0_84ck860 FIND v(dout0_84) AT=435.025n

.meas tran vdout0_85ck860 FIND v(dout0_85) AT=435.025n

.meas tran vdout0_86ck860 FIND v(dout0_86) AT=435.025n

.meas tran vdout0_87ck860 FIND v(dout0_87) AT=435.025n

.meas tran vdout0_88ck860 FIND v(dout0_88) AT=435.025n

.meas tran vdout0_89ck860 FIND v(dout0_89) AT=435.025n

.meas tran vdout0_90ck860 FIND v(dout0_90) AT=435.025n

.meas tran vdout0_91ck860 FIND v(dout0_91) AT=435.025n

.meas tran vdout0_92ck860 FIND v(dout0_92) AT=435.025n

.meas tran vdout0_93ck860 FIND v(dout0_93) AT=435.025n

.meas tran vdout0_94ck860 FIND v(dout0_94) AT=435.025n

.meas tran vdout0_95ck860 FIND v(dout0_95) AT=435.025n

.meas tran vdout0_96ck860 FIND v(dout0_96) AT=435.025n

.meas tran vdout0_97ck860 FIND v(dout0_97) AT=435.025n

.meas tran vdout0_98ck860 FIND v(dout0_98) AT=435.025n

.meas tran vdout0_99ck860 FIND v(dout0_99) AT=435.025n

.meas tran vdout0_100ck860 FIND v(dout0_100) AT=435.025n

.meas tran vdout0_101ck860 FIND v(dout0_101) AT=435.025n

.meas tran vdout0_102ck860 FIND v(dout0_102) AT=435.025n

.meas tran vdout0_103ck860 FIND v(dout0_103) AT=435.025n

.meas tran vdout0_104ck860 FIND v(dout0_104) AT=435.025n

.meas tran vdout0_105ck860 FIND v(dout0_105) AT=435.025n

.meas tran vdout0_106ck860 FIND v(dout0_106) AT=435.025n

.meas tran vdout0_107ck860 FIND v(dout0_107) AT=435.025n

.meas tran vdout0_108ck860 FIND v(dout0_108) AT=435.025n

.meas tran vdout0_109ck860 FIND v(dout0_109) AT=435.025n

.meas tran vdout0_110ck860 FIND v(dout0_110) AT=435.025n

.meas tran vdout0_111ck860 FIND v(dout0_111) AT=435.025n

.meas tran vdout0_112ck860 FIND v(dout0_112) AT=435.025n

.meas tran vdout0_113ck860 FIND v(dout0_113) AT=435.025n

.meas tran vdout0_114ck860 FIND v(dout0_114) AT=435.025n

.meas tran vdout0_115ck860 FIND v(dout0_115) AT=435.025n

.meas tran vdout0_116ck860 FIND v(dout0_116) AT=435.025n

.meas tran vdout0_117ck860 FIND v(dout0_117) AT=435.025n

.meas tran vdout0_118ck860 FIND v(dout0_118) AT=435.025n

.meas tran vdout0_119ck860 FIND v(dout0_119) AT=435.025n

.meas tran vdout0_120ck860 FIND v(dout0_120) AT=435.025n

.meas tran vdout0_121ck860 FIND v(dout0_121) AT=435.025n

.meas tran vdout0_122ck860 FIND v(dout0_122) AT=435.025n

.meas tran vdout0_123ck860 FIND v(dout0_123) AT=435.025n

.meas tran vdout0_124ck860 FIND v(dout0_124) AT=435.025n

.meas tran vdout0_125ck860 FIND v(dout0_125) AT=435.025n

.meas tran vdout0_126ck860 FIND v(dout0_126) AT=435.025n

.meas tran vdout0_127ck860 FIND v(dout0_127) AT=435.025n

.meas tran vdout0_128ck860 FIND v(dout0_128) AT=435.025n

.meas tran vdout0_129ck860 FIND v(dout0_129) AT=435.025n

.meas tran vdout0_130ck860 FIND v(dout0_130) AT=435.025n

.meas tran vdout0_131ck860 FIND v(dout0_131) AT=435.025n

.meas tran vdout0_132ck860 FIND v(dout0_132) AT=435.025n

.meas tran vdout0_133ck860 FIND v(dout0_133) AT=435.025n

.meas tran vdout0_134ck860 FIND v(dout0_134) AT=435.025n

.meas tran vdout0_135ck860 FIND v(dout0_135) AT=435.025n

.meas tran vdout0_136ck860 FIND v(dout0_136) AT=435.025n

.meas tran vdout0_137ck860 FIND v(dout0_137) AT=435.025n

.meas tran vdout0_138ck860 FIND v(dout0_138) AT=435.025n

.meas tran vdout0_139ck860 FIND v(dout0_139) AT=435.025n

.meas tran vdout0_140ck860 FIND v(dout0_140) AT=435.025n

.meas tran vdout0_141ck860 FIND v(dout0_141) AT=435.025n

.meas tran vdout0_142ck860 FIND v(dout0_142) AT=435.025n

.meas tran vdout0_143ck860 FIND v(dout0_143) AT=435.025n

.meas tran vdout0_144ck860 FIND v(dout0_144) AT=435.025n

.meas tran vdout0_145ck860 FIND v(dout0_145) AT=435.025n

.meas tran vdout0_146ck860 FIND v(dout0_146) AT=435.025n

.meas tran vdout0_147ck860 FIND v(dout0_147) AT=435.025n

.meas tran vdout0_148ck860 FIND v(dout0_148) AT=435.025n

.meas tran vdout0_149ck860 FIND v(dout0_149) AT=435.025n

.meas tran vdout0_150ck860 FIND v(dout0_150) AT=435.025n

.meas tran vdout0_151ck860 FIND v(dout0_151) AT=435.025n

.meas tran vdout0_152ck860 FIND v(dout0_152) AT=435.025n

.meas tran vdout0_153ck860 FIND v(dout0_153) AT=435.025n

.meas tran vdout0_154ck860 FIND v(dout0_154) AT=435.025n

.meas tran vdout0_155ck860 FIND v(dout0_155) AT=435.025n

.meas tran vdout0_156ck860 FIND v(dout0_156) AT=435.025n

.meas tran vdout0_157ck860 FIND v(dout0_157) AT=435.025n

.meas tran vdout0_158ck860 FIND v(dout0_158) AT=435.025n

.meas tran vdout0_159ck860 FIND v(dout0_159) AT=435.025n

.meas tran vdout0_160ck860 FIND v(dout0_160) AT=435.025n

.meas tran vdout0_161ck860 FIND v(dout0_161) AT=435.025n

.meas tran vdout0_162ck860 FIND v(dout0_162) AT=435.025n

.meas tran vdout0_163ck860 FIND v(dout0_163) AT=435.025n

.meas tran vdout0_164ck860 FIND v(dout0_164) AT=435.025n

.meas tran vdout0_165ck860 FIND v(dout0_165) AT=435.025n

.meas tran vdout0_166ck860 FIND v(dout0_166) AT=435.025n

.meas tran vdout0_167ck860 FIND v(dout0_167) AT=435.025n

.meas tran vdout0_168ck860 FIND v(dout0_168) AT=435.025n

.meas tran vdout0_169ck860 FIND v(dout0_169) AT=435.025n

.meas tran vdout0_170ck860 FIND v(dout0_170) AT=435.025n

.meas tran vdout0_171ck860 FIND v(dout0_171) AT=435.025n

.meas tran vdout0_172ck860 FIND v(dout0_172) AT=435.025n

.meas tran vdout0_173ck860 FIND v(dout0_173) AT=435.025n

.meas tran vdout0_174ck860 FIND v(dout0_174) AT=435.025n

.meas tran vdout0_175ck860 FIND v(dout0_175) AT=435.025n

.meas tran vdout0_176ck860 FIND v(dout0_176) AT=435.025n

.meas tran vdout0_177ck860 FIND v(dout0_177) AT=435.025n

.meas tran vdout0_178ck860 FIND v(dout0_178) AT=435.025n

.meas tran vdout0_179ck860 FIND v(dout0_179) AT=435.025n

.meas tran vdout0_180ck860 FIND v(dout0_180) AT=435.025n

.meas tran vdout0_181ck860 FIND v(dout0_181) AT=435.025n

.meas tran vdout0_182ck860 FIND v(dout0_182) AT=435.025n

.meas tran vdout0_183ck860 FIND v(dout0_183) AT=435.025n

.meas tran vdout0_184ck860 FIND v(dout0_184) AT=435.025n

.meas tran vdout0_185ck860 FIND v(dout0_185) AT=435.025n

.meas tran vdout0_186ck860 FIND v(dout0_186) AT=435.025n

.meas tran vdout0_187ck860 FIND v(dout0_187) AT=435.025n

.meas tran vdout0_188ck860 FIND v(dout0_188) AT=435.025n

.meas tran vdout0_189ck860 FIND v(dout0_189) AT=435.025n

.meas tran vdout0_190ck860 FIND v(dout0_190) AT=435.025n

.meas tran vdout0_191ck860 FIND v(dout0_191) AT=435.025n

.meas tran vdout0_192ck860 FIND v(dout0_192) AT=435.025n

.meas tran vdout0_193ck860 FIND v(dout0_193) AT=435.025n

.meas tran vdout0_194ck860 FIND v(dout0_194) AT=435.025n

.meas tran vdout0_195ck860 FIND v(dout0_195) AT=435.025n

.meas tran vdout0_196ck860 FIND v(dout0_196) AT=435.025n

.meas tran vdout0_197ck860 FIND v(dout0_197) AT=435.025n

.meas tran vdout0_198ck860 FIND v(dout0_198) AT=435.025n

.meas tran vdout0_199ck860 FIND v(dout0_199) AT=435.025n

.meas tran vdout0_200ck860 FIND v(dout0_200) AT=435.025n

.meas tran vdout0_201ck860 FIND v(dout0_201) AT=435.025n

.meas tran vdout0_202ck860 FIND v(dout0_202) AT=435.025n

.meas tran vdout0_203ck860 FIND v(dout0_203) AT=435.025n

.meas tran vdout0_204ck860 FIND v(dout0_204) AT=435.025n

.meas tran vdout0_205ck860 FIND v(dout0_205) AT=435.025n

.meas tran vdout0_206ck860 FIND v(dout0_206) AT=435.025n

.meas tran vdout0_207ck860 FIND v(dout0_207) AT=435.025n

.meas tran vdout0_208ck860 FIND v(dout0_208) AT=435.025n

.meas tran vdout0_209ck860 FIND v(dout0_209) AT=435.025n

.meas tran vdout0_210ck860 FIND v(dout0_210) AT=435.025n

.meas tran vdout0_211ck860 FIND v(dout0_211) AT=435.025n

.meas tran vdout0_212ck860 FIND v(dout0_212) AT=435.025n

.meas tran vdout0_213ck860 FIND v(dout0_213) AT=435.025n

.meas tran vdout0_214ck860 FIND v(dout0_214) AT=435.025n

.meas tran vdout0_215ck860 FIND v(dout0_215) AT=435.025n

.meas tran vdout0_216ck860 FIND v(dout0_216) AT=435.025n

.meas tran vdout0_217ck860 FIND v(dout0_217) AT=435.025n

.meas tran vdout0_218ck860 FIND v(dout0_218) AT=435.025n

.meas tran vdout0_219ck860 FIND v(dout0_219) AT=435.025n

.meas tran vdout0_220ck860 FIND v(dout0_220) AT=435.025n

.meas tran vdout0_221ck860 FIND v(dout0_221) AT=435.025n

.meas tran vdout0_222ck860 FIND v(dout0_222) AT=435.025n

.meas tran vdout0_223ck860 FIND v(dout0_223) AT=435.025n

.meas tran vdout0_224ck860 FIND v(dout0_224) AT=435.025n

.meas tran vdout0_225ck860 FIND v(dout0_225) AT=435.025n

.meas tran vdout0_226ck860 FIND v(dout0_226) AT=435.025n

.meas tran vdout0_227ck860 FIND v(dout0_227) AT=435.025n

.meas tran vdout0_228ck860 FIND v(dout0_228) AT=435.025n

.meas tran vdout0_229ck860 FIND v(dout0_229) AT=435.025n

.meas tran vdout0_230ck860 FIND v(dout0_230) AT=435.025n

.meas tran vdout0_231ck860 FIND v(dout0_231) AT=435.025n

.meas tran vdout0_232ck860 FIND v(dout0_232) AT=435.025n

.meas tran vdout0_233ck860 FIND v(dout0_233) AT=435.025n

.meas tran vdout0_234ck860 FIND v(dout0_234) AT=435.025n

.meas tran vdout0_235ck860 FIND v(dout0_235) AT=435.025n

.meas tran vdout0_236ck860 FIND v(dout0_236) AT=435.025n

.meas tran vdout0_237ck860 FIND v(dout0_237) AT=435.025n

.meas tran vdout0_238ck860 FIND v(dout0_238) AT=435.025n

.meas tran vdout0_239ck860 FIND v(dout0_239) AT=435.025n

.meas tran vdout0_240ck860 FIND v(dout0_240) AT=435.025n

.meas tran vdout0_241ck860 FIND v(dout0_241) AT=435.025n

.meas tran vdout0_242ck860 FIND v(dout0_242) AT=435.025n

.meas tran vdout0_243ck860 FIND v(dout0_243) AT=435.025n

.meas tran vdout0_244ck860 FIND v(dout0_244) AT=435.025n

.meas tran vdout0_245ck860 FIND v(dout0_245) AT=435.025n

.meas tran vdout0_246ck860 FIND v(dout0_246) AT=435.025n

.meas tran vdout0_247ck860 FIND v(dout0_247) AT=435.025n

.meas tran vdout0_248ck860 FIND v(dout0_248) AT=435.025n

.meas tran vdout0_249ck860 FIND v(dout0_249) AT=435.025n

.meas tran vdout0_250ck860 FIND v(dout0_250) AT=435.025n

.meas tran vdout0_251ck860 FIND v(dout0_251) AT=435.025n

.meas tran vdout0_252ck860 FIND v(dout0_252) AT=435.025n

.meas tran vdout0_253ck860 FIND v(dout0_253) AT=435.025n

.meas tran vdout0_254ck860 FIND v(dout0_254) AT=435.025n

.meas tran vdout0_255ck860 FIND v(dout0_255) AT=435.025n

.meas tran vdout0_0ck890 FIND v(dout0_0) AT=450.025n

.meas tran vdout0_1ck890 FIND v(dout0_1) AT=450.025n

.meas tran vdout0_2ck890 FIND v(dout0_2) AT=450.025n

.meas tran vdout0_3ck890 FIND v(dout0_3) AT=450.025n

.meas tran vdout0_4ck890 FIND v(dout0_4) AT=450.025n

.meas tran vdout0_5ck890 FIND v(dout0_5) AT=450.025n

.meas tran vdout0_6ck890 FIND v(dout0_6) AT=450.025n

.meas tran vdout0_7ck890 FIND v(dout0_7) AT=450.025n

.meas tran vdout0_8ck890 FIND v(dout0_8) AT=450.025n

.meas tran vdout0_9ck890 FIND v(dout0_9) AT=450.025n

.meas tran vdout0_10ck890 FIND v(dout0_10) AT=450.025n

.meas tran vdout0_11ck890 FIND v(dout0_11) AT=450.025n

.meas tran vdout0_12ck890 FIND v(dout0_12) AT=450.025n

.meas tran vdout0_13ck890 FIND v(dout0_13) AT=450.025n

.meas tran vdout0_14ck890 FIND v(dout0_14) AT=450.025n

.meas tran vdout0_15ck890 FIND v(dout0_15) AT=450.025n

.meas tran vdout0_16ck890 FIND v(dout0_16) AT=450.025n

.meas tran vdout0_17ck890 FIND v(dout0_17) AT=450.025n

.meas tran vdout0_18ck890 FIND v(dout0_18) AT=450.025n

.meas tran vdout0_19ck890 FIND v(dout0_19) AT=450.025n

.meas tran vdout0_20ck890 FIND v(dout0_20) AT=450.025n

.meas tran vdout0_21ck890 FIND v(dout0_21) AT=450.025n

.meas tran vdout0_22ck890 FIND v(dout0_22) AT=450.025n

.meas tran vdout0_23ck890 FIND v(dout0_23) AT=450.025n

.meas tran vdout0_24ck890 FIND v(dout0_24) AT=450.025n

.meas tran vdout0_25ck890 FIND v(dout0_25) AT=450.025n

.meas tran vdout0_26ck890 FIND v(dout0_26) AT=450.025n

.meas tran vdout0_27ck890 FIND v(dout0_27) AT=450.025n

.meas tran vdout0_28ck890 FIND v(dout0_28) AT=450.025n

.meas tran vdout0_29ck890 FIND v(dout0_29) AT=450.025n

.meas tran vdout0_30ck890 FIND v(dout0_30) AT=450.025n

.meas tran vdout0_31ck890 FIND v(dout0_31) AT=450.025n

.meas tran vdout0_32ck890 FIND v(dout0_32) AT=450.025n

.meas tran vdout0_33ck890 FIND v(dout0_33) AT=450.025n

.meas tran vdout0_34ck890 FIND v(dout0_34) AT=450.025n

.meas tran vdout0_35ck890 FIND v(dout0_35) AT=450.025n

.meas tran vdout0_36ck890 FIND v(dout0_36) AT=450.025n

.meas tran vdout0_37ck890 FIND v(dout0_37) AT=450.025n

.meas tran vdout0_38ck890 FIND v(dout0_38) AT=450.025n

.meas tran vdout0_39ck890 FIND v(dout0_39) AT=450.025n

.meas tran vdout0_40ck890 FIND v(dout0_40) AT=450.025n

.meas tran vdout0_41ck890 FIND v(dout0_41) AT=450.025n

.meas tran vdout0_42ck890 FIND v(dout0_42) AT=450.025n

.meas tran vdout0_43ck890 FIND v(dout0_43) AT=450.025n

.meas tran vdout0_44ck890 FIND v(dout0_44) AT=450.025n

.meas tran vdout0_45ck890 FIND v(dout0_45) AT=450.025n

.meas tran vdout0_46ck890 FIND v(dout0_46) AT=450.025n

.meas tran vdout0_47ck890 FIND v(dout0_47) AT=450.025n

.meas tran vdout0_48ck890 FIND v(dout0_48) AT=450.025n

.meas tran vdout0_49ck890 FIND v(dout0_49) AT=450.025n

.meas tran vdout0_50ck890 FIND v(dout0_50) AT=450.025n

.meas tran vdout0_51ck890 FIND v(dout0_51) AT=450.025n

.meas tran vdout0_52ck890 FIND v(dout0_52) AT=450.025n

.meas tran vdout0_53ck890 FIND v(dout0_53) AT=450.025n

.meas tran vdout0_54ck890 FIND v(dout0_54) AT=450.025n

.meas tran vdout0_55ck890 FIND v(dout0_55) AT=450.025n

.meas tran vdout0_56ck890 FIND v(dout0_56) AT=450.025n

.meas tran vdout0_57ck890 FIND v(dout0_57) AT=450.025n

.meas tran vdout0_58ck890 FIND v(dout0_58) AT=450.025n

.meas tran vdout0_59ck890 FIND v(dout0_59) AT=450.025n

.meas tran vdout0_60ck890 FIND v(dout0_60) AT=450.025n

.meas tran vdout0_61ck890 FIND v(dout0_61) AT=450.025n

.meas tran vdout0_62ck890 FIND v(dout0_62) AT=450.025n

.meas tran vdout0_63ck890 FIND v(dout0_63) AT=450.025n

.meas tran vdout0_64ck890 FIND v(dout0_64) AT=450.025n

.meas tran vdout0_65ck890 FIND v(dout0_65) AT=450.025n

.meas tran vdout0_66ck890 FIND v(dout0_66) AT=450.025n

.meas tran vdout0_67ck890 FIND v(dout0_67) AT=450.025n

.meas tran vdout0_68ck890 FIND v(dout0_68) AT=450.025n

.meas tran vdout0_69ck890 FIND v(dout0_69) AT=450.025n

.meas tran vdout0_70ck890 FIND v(dout0_70) AT=450.025n

.meas tran vdout0_71ck890 FIND v(dout0_71) AT=450.025n

.meas tran vdout0_72ck890 FIND v(dout0_72) AT=450.025n

.meas tran vdout0_73ck890 FIND v(dout0_73) AT=450.025n

.meas tran vdout0_74ck890 FIND v(dout0_74) AT=450.025n

.meas tran vdout0_75ck890 FIND v(dout0_75) AT=450.025n

.meas tran vdout0_76ck890 FIND v(dout0_76) AT=450.025n

.meas tran vdout0_77ck890 FIND v(dout0_77) AT=450.025n

.meas tran vdout0_78ck890 FIND v(dout0_78) AT=450.025n

.meas tran vdout0_79ck890 FIND v(dout0_79) AT=450.025n

.meas tran vdout0_80ck890 FIND v(dout0_80) AT=450.025n

.meas tran vdout0_81ck890 FIND v(dout0_81) AT=450.025n

.meas tran vdout0_82ck890 FIND v(dout0_82) AT=450.025n

.meas tran vdout0_83ck890 FIND v(dout0_83) AT=450.025n

.meas tran vdout0_84ck890 FIND v(dout0_84) AT=450.025n

.meas tran vdout0_85ck890 FIND v(dout0_85) AT=450.025n

.meas tran vdout0_86ck890 FIND v(dout0_86) AT=450.025n

.meas tran vdout0_87ck890 FIND v(dout0_87) AT=450.025n

.meas tran vdout0_88ck890 FIND v(dout0_88) AT=450.025n

.meas tran vdout0_89ck890 FIND v(dout0_89) AT=450.025n

.meas tran vdout0_90ck890 FIND v(dout0_90) AT=450.025n

.meas tran vdout0_91ck890 FIND v(dout0_91) AT=450.025n

.meas tran vdout0_92ck890 FIND v(dout0_92) AT=450.025n

.meas tran vdout0_93ck890 FIND v(dout0_93) AT=450.025n

.meas tran vdout0_94ck890 FIND v(dout0_94) AT=450.025n

.meas tran vdout0_95ck890 FIND v(dout0_95) AT=450.025n

.meas tran vdout0_96ck890 FIND v(dout0_96) AT=450.025n

.meas tran vdout0_97ck890 FIND v(dout0_97) AT=450.025n

.meas tran vdout0_98ck890 FIND v(dout0_98) AT=450.025n

.meas tran vdout0_99ck890 FIND v(dout0_99) AT=450.025n

.meas tran vdout0_100ck890 FIND v(dout0_100) AT=450.025n

.meas tran vdout0_101ck890 FIND v(dout0_101) AT=450.025n

.meas tran vdout0_102ck890 FIND v(dout0_102) AT=450.025n

.meas tran vdout0_103ck890 FIND v(dout0_103) AT=450.025n

.meas tran vdout0_104ck890 FIND v(dout0_104) AT=450.025n

.meas tran vdout0_105ck890 FIND v(dout0_105) AT=450.025n

.meas tran vdout0_106ck890 FIND v(dout0_106) AT=450.025n

.meas tran vdout0_107ck890 FIND v(dout0_107) AT=450.025n

.meas tran vdout0_108ck890 FIND v(dout0_108) AT=450.025n

.meas tran vdout0_109ck890 FIND v(dout0_109) AT=450.025n

.meas tran vdout0_110ck890 FIND v(dout0_110) AT=450.025n

.meas tran vdout0_111ck890 FIND v(dout0_111) AT=450.025n

.meas tran vdout0_112ck890 FIND v(dout0_112) AT=450.025n

.meas tran vdout0_113ck890 FIND v(dout0_113) AT=450.025n

.meas tran vdout0_114ck890 FIND v(dout0_114) AT=450.025n

.meas tran vdout0_115ck890 FIND v(dout0_115) AT=450.025n

.meas tran vdout0_116ck890 FIND v(dout0_116) AT=450.025n

.meas tran vdout0_117ck890 FIND v(dout0_117) AT=450.025n

.meas tran vdout0_118ck890 FIND v(dout0_118) AT=450.025n

.meas tran vdout0_119ck890 FIND v(dout0_119) AT=450.025n

.meas tran vdout0_120ck890 FIND v(dout0_120) AT=450.025n

.meas tran vdout0_121ck890 FIND v(dout0_121) AT=450.025n

.meas tran vdout0_122ck890 FIND v(dout0_122) AT=450.025n

.meas tran vdout0_123ck890 FIND v(dout0_123) AT=450.025n

.meas tran vdout0_124ck890 FIND v(dout0_124) AT=450.025n

.meas tran vdout0_125ck890 FIND v(dout0_125) AT=450.025n

.meas tran vdout0_126ck890 FIND v(dout0_126) AT=450.025n

.meas tran vdout0_127ck890 FIND v(dout0_127) AT=450.025n

.meas tran vdout0_128ck890 FIND v(dout0_128) AT=450.025n

.meas tran vdout0_129ck890 FIND v(dout0_129) AT=450.025n

.meas tran vdout0_130ck890 FIND v(dout0_130) AT=450.025n

.meas tran vdout0_131ck890 FIND v(dout0_131) AT=450.025n

.meas tran vdout0_132ck890 FIND v(dout0_132) AT=450.025n

.meas tran vdout0_133ck890 FIND v(dout0_133) AT=450.025n

.meas tran vdout0_134ck890 FIND v(dout0_134) AT=450.025n

.meas tran vdout0_135ck890 FIND v(dout0_135) AT=450.025n

.meas tran vdout0_136ck890 FIND v(dout0_136) AT=450.025n

.meas tran vdout0_137ck890 FIND v(dout0_137) AT=450.025n

.meas tran vdout0_138ck890 FIND v(dout0_138) AT=450.025n

.meas tran vdout0_139ck890 FIND v(dout0_139) AT=450.025n

.meas tran vdout0_140ck890 FIND v(dout0_140) AT=450.025n

.meas tran vdout0_141ck890 FIND v(dout0_141) AT=450.025n

.meas tran vdout0_142ck890 FIND v(dout0_142) AT=450.025n

.meas tran vdout0_143ck890 FIND v(dout0_143) AT=450.025n

.meas tran vdout0_144ck890 FIND v(dout0_144) AT=450.025n

.meas tran vdout0_145ck890 FIND v(dout0_145) AT=450.025n

.meas tran vdout0_146ck890 FIND v(dout0_146) AT=450.025n

.meas tran vdout0_147ck890 FIND v(dout0_147) AT=450.025n

.meas tran vdout0_148ck890 FIND v(dout0_148) AT=450.025n

.meas tran vdout0_149ck890 FIND v(dout0_149) AT=450.025n

.meas tran vdout0_150ck890 FIND v(dout0_150) AT=450.025n

.meas tran vdout0_151ck890 FIND v(dout0_151) AT=450.025n

.meas tran vdout0_152ck890 FIND v(dout0_152) AT=450.025n

.meas tran vdout0_153ck890 FIND v(dout0_153) AT=450.025n

.meas tran vdout0_154ck890 FIND v(dout0_154) AT=450.025n

.meas tran vdout0_155ck890 FIND v(dout0_155) AT=450.025n

.meas tran vdout0_156ck890 FIND v(dout0_156) AT=450.025n

.meas tran vdout0_157ck890 FIND v(dout0_157) AT=450.025n

.meas tran vdout0_158ck890 FIND v(dout0_158) AT=450.025n

.meas tran vdout0_159ck890 FIND v(dout0_159) AT=450.025n

.meas tran vdout0_160ck890 FIND v(dout0_160) AT=450.025n

.meas tran vdout0_161ck890 FIND v(dout0_161) AT=450.025n

.meas tran vdout0_162ck890 FIND v(dout0_162) AT=450.025n

.meas tran vdout0_163ck890 FIND v(dout0_163) AT=450.025n

.meas tran vdout0_164ck890 FIND v(dout0_164) AT=450.025n

.meas tran vdout0_165ck890 FIND v(dout0_165) AT=450.025n

.meas tran vdout0_166ck890 FIND v(dout0_166) AT=450.025n

.meas tran vdout0_167ck890 FIND v(dout0_167) AT=450.025n

.meas tran vdout0_168ck890 FIND v(dout0_168) AT=450.025n

.meas tran vdout0_169ck890 FIND v(dout0_169) AT=450.025n

.meas tran vdout0_170ck890 FIND v(dout0_170) AT=450.025n

.meas tran vdout0_171ck890 FIND v(dout0_171) AT=450.025n

.meas tran vdout0_172ck890 FIND v(dout0_172) AT=450.025n

.meas tran vdout0_173ck890 FIND v(dout0_173) AT=450.025n

.meas tran vdout0_174ck890 FIND v(dout0_174) AT=450.025n

.meas tran vdout0_175ck890 FIND v(dout0_175) AT=450.025n

.meas tran vdout0_176ck890 FIND v(dout0_176) AT=450.025n

.meas tran vdout0_177ck890 FIND v(dout0_177) AT=450.025n

.meas tran vdout0_178ck890 FIND v(dout0_178) AT=450.025n

.meas tran vdout0_179ck890 FIND v(dout0_179) AT=450.025n

.meas tran vdout0_180ck890 FIND v(dout0_180) AT=450.025n

.meas tran vdout0_181ck890 FIND v(dout0_181) AT=450.025n

.meas tran vdout0_182ck890 FIND v(dout0_182) AT=450.025n

.meas tran vdout0_183ck890 FIND v(dout0_183) AT=450.025n

.meas tran vdout0_184ck890 FIND v(dout0_184) AT=450.025n

.meas tran vdout0_185ck890 FIND v(dout0_185) AT=450.025n

.meas tran vdout0_186ck890 FIND v(dout0_186) AT=450.025n

.meas tran vdout0_187ck890 FIND v(dout0_187) AT=450.025n

.meas tran vdout0_188ck890 FIND v(dout0_188) AT=450.025n

.meas tran vdout0_189ck890 FIND v(dout0_189) AT=450.025n

.meas tran vdout0_190ck890 FIND v(dout0_190) AT=450.025n

.meas tran vdout0_191ck890 FIND v(dout0_191) AT=450.025n

.meas tran vdout0_192ck890 FIND v(dout0_192) AT=450.025n

.meas tran vdout0_193ck890 FIND v(dout0_193) AT=450.025n

.meas tran vdout0_194ck890 FIND v(dout0_194) AT=450.025n

.meas tran vdout0_195ck890 FIND v(dout0_195) AT=450.025n

.meas tran vdout0_196ck890 FIND v(dout0_196) AT=450.025n

.meas tran vdout0_197ck890 FIND v(dout0_197) AT=450.025n

.meas tran vdout0_198ck890 FIND v(dout0_198) AT=450.025n

.meas tran vdout0_199ck890 FIND v(dout0_199) AT=450.025n

.meas tran vdout0_200ck890 FIND v(dout0_200) AT=450.025n

.meas tran vdout0_201ck890 FIND v(dout0_201) AT=450.025n

.meas tran vdout0_202ck890 FIND v(dout0_202) AT=450.025n

.meas tran vdout0_203ck890 FIND v(dout0_203) AT=450.025n

.meas tran vdout0_204ck890 FIND v(dout0_204) AT=450.025n

.meas tran vdout0_205ck890 FIND v(dout0_205) AT=450.025n

.meas tran vdout0_206ck890 FIND v(dout0_206) AT=450.025n

.meas tran vdout0_207ck890 FIND v(dout0_207) AT=450.025n

.meas tran vdout0_208ck890 FIND v(dout0_208) AT=450.025n

.meas tran vdout0_209ck890 FIND v(dout0_209) AT=450.025n

.meas tran vdout0_210ck890 FIND v(dout0_210) AT=450.025n

.meas tran vdout0_211ck890 FIND v(dout0_211) AT=450.025n

.meas tran vdout0_212ck890 FIND v(dout0_212) AT=450.025n

.meas tran vdout0_213ck890 FIND v(dout0_213) AT=450.025n

.meas tran vdout0_214ck890 FIND v(dout0_214) AT=450.025n

.meas tran vdout0_215ck890 FIND v(dout0_215) AT=450.025n

.meas tran vdout0_216ck890 FIND v(dout0_216) AT=450.025n

.meas tran vdout0_217ck890 FIND v(dout0_217) AT=450.025n

.meas tran vdout0_218ck890 FIND v(dout0_218) AT=450.025n

.meas tran vdout0_219ck890 FIND v(dout0_219) AT=450.025n

.meas tran vdout0_220ck890 FIND v(dout0_220) AT=450.025n

.meas tran vdout0_221ck890 FIND v(dout0_221) AT=450.025n

.meas tran vdout0_222ck890 FIND v(dout0_222) AT=450.025n

.meas tran vdout0_223ck890 FIND v(dout0_223) AT=450.025n

.meas tran vdout0_224ck890 FIND v(dout0_224) AT=450.025n

.meas tran vdout0_225ck890 FIND v(dout0_225) AT=450.025n

.meas tran vdout0_226ck890 FIND v(dout0_226) AT=450.025n

.meas tran vdout0_227ck890 FIND v(dout0_227) AT=450.025n

.meas tran vdout0_228ck890 FIND v(dout0_228) AT=450.025n

.meas tran vdout0_229ck890 FIND v(dout0_229) AT=450.025n

.meas tran vdout0_230ck890 FIND v(dout0_230) AT=450.025n

.meas tran vdout0_231ck890 FIND v(dout0_231) AT=450.025n

.meas tran vdout0_232ck890 FIND v(dout0_232) AT=450.025n

.meas tran vdout0_233ck890 FIND v(dout0_233) AT=450.025n

.meas tran vdout0_234ck890 FIND v(dout0_234) AT=450.025n

.meas tran vdout0_235ck890 FIND v(dout0_235) AT=450.025n

.meas tran vdout0_236ck890 FIND v(dout0_236) AT=450.025n

.meas tran vdout0_237ck890 FIND v(dout0_237) AT=450.025n

.meas tran vdout0_238ck890 FIND v(dout0_238) AT=450.025n

.meas tran vdout0_239ck890 FIND v(dout0_239) AT=450.025n

.meas tran vdout0_240ck890 FIND v(dout0_240) AT=450.025n

.meas tran vdout0_241ck890 FIND v(dout0_241) AT=450.025n

.meas tran vdout0_242ck890 FIND v(dout0_242) AT=450.025n

.meas tran vdout0_243ck890 FIND v(dout0_243) AT=450.025n

.meas tran vdout0_244ck890 FIND v(dout0_244) AT=450.025n

.meas tran vdout0_245ck890 FIND v(dout0_245) AT=450.025n

.meas tran vdout0_246ck890 FIND v(dout0_246) AT=450.025n

.meas tran vdout0_247ck890 FIND v(dout0_247) AT=450.025n

.meas tran vdout0_248ck890 FIND v(dout0_248) AT=450.025n

.meas tran vdout0_249ck890 FIND v(dout0_249) AT=450.025n

.meas tran vdout0_250ck890 FIND v(dout0_250) AT=450.025n

.meas tran vdout0_251ck890 FIND v(dout0_251) AT=450.025n

.meas tran vdout0_252ck890 FIND v(dout0_252) AT=450.025n

.meas tran vdout0_253ck890 FIND v(dout0_253) AT=450.025n

.meas tran vdout0_254ck890 FIND v(dout0_254) AT=450.025n

.meas tran vdout0_255ck890 FIND v(dout0_255) AT=450.025n

.meas tran vdout0_0ck930 FIND v(dout0_0) AT=470.025n

.meas tran vdout0_1ck930 FIND v(dout0_1) AT=470.025n

.meas tran vdout0_2ck930 FIND v(dout0_2) AT=470.025n

.meas tran vdout0_3ck930 FIND v(dout0_3) AT=470.025n

.meas tran vdout0_4ck930 FIND v(dout0_4) AT=470.025n

.meas tran vdout0_5ck930 FIND v(dout0_5) AT=470.025n

.meas tran vdout0_6ck930 FIND v(dout0_6) AT=470.025n

.meas tran vdout0_7ck930 FIND v(dout0_7) AT=470.025n

.meas tran vdout0_8ck930 FIND v(dout0_8) AT=470.025n

.meas tran vdout0_9ck930 FIND v(dout0_9) AT=470.025n

.meas tran vdout0_10ck930 FIND v(dout0_10) AT=470.025n

.meas tran vdout0_11ck930 FIND v(dout0_11) AT=470.025n

.meas tran vdout0_12ck930 FIND v(dout0_12) AT=470.025n

.meas tran vdout0_13ck930 FIND v(dout0_13) AT=470.025n

.meas tran vdout0_14ck930 FIND v(dout0_14) AT=470.025n

.meas tran vdout0_15ck930 FIND v(dout0_15) AT=470.025n

.meas tran vdout0_16ck930 FIND v(dout0_16) AT=470.025n

.meas tran vdout0_17ck930 FIND v(dout0_17) AT=470.025n

.meas tran vdout0_18ck930 FIND v(dout0_18) AT=470.025n

.meas tran vdout0_19ck930 FIND v(dout0_19) AT=470.025n

.meas tran vdout0_20ck930 FIND v(dout0_20) AT=470.025n

.meas tran vdout0_21ck930 FIND v(dout0_21) AT=470.025n

.meas tran vdout0_22ck930 FIND v(dout0_22) AT=470.025n

.meas tran vdout0_23ck930 FIND v(dout0_23) AT=470.025n

.meas tran vdout0_24ck930 FIND v(dout0_24) AT=470.025n

.meas tran vdout0_25ck930 FIND v(dout0_25) AT=470.025n

.meas tran vdout0_26ck930 FIND v(dout0_26) AT=470.025n

.meas tran vdout0_27ck930 FIND v(dout0_27) AT=470.025n

.meas tran vdout0_28ck930 FIND v(dout0_28) AT=470.025n

.meas tran vdout0_29ck930 FIND v(dout0_29) AT=470.025n

.meas tran vdout0_30ck930 FIND v(dout0_30) AT=470.025n

.meas tran vdout0_31ck930 FIND v(dout0_31) AT=470.025n

.meas tran vdout0_32ck930 FIND v(dout0_32) AT=470.025n

.meas tran vdout0_33ck930 FIND v(dout0_33) AT=470.025n

.meas tran vdout0_34ck930 FIND v(dout0_34) AT=470.025n

.meas tran vdout0_35ck930 FIND v(dout0_35) AT=470.025n

.meas tran vdout0_36ck930 FIND v(dout0_36) AT=470.025n

.meas tran vdout0_37ck930 FIND v(dout0_37) AT=470.025n

.meas tran vdout0_38ck930 FIND v(dout0_38) AT=470.025n

.meas tran vdout0_39ck930 FIND v(dout0_39) AT=470.025n

.meas tran vdout0_40ck930 FIND v(dout0_40) AT=470.025n

.meas tran vdout0_41ck930 FIND v(dout0_41) AT=470.025n

.meas tran vdout0_42ck930 FIND v(dout0_42) AT=470.025n

.meas tran vdout0_43ck930 FIND v(dout0_43) AT=470.025n

.meas tran vdout0_44ck930 FIND v(dout0_44) AT=470.025n

.meas tran vdout0_45ck930 FIND v(dout0_45) AT=470.025n

.meas tran vdout0_46ck930 FIND v(dout0_46) AT=470.025n

.meas tran vdout0_47ck930 FIND v(dout0_47) AT=470.025n

.meas tran vdout0_48ck930 FIND v(dout0_48) AT=470.025n

.meas tran vdout0_49ck930 FIND v(dout0_49) AT=470.025n

.meas tran vdout0_50ck930 FIND v(dout0_50) AT=470.025n

.meas tran vdout0_51ck930 FIND v(dout0_51) AT=470.025n

.meas tran vdout0_52ck930 FIND v(dout0_52) AT=470.025n

.meas tran vdout0_53ck930 FIND v(dout0_53) AT=470.025n

.meas tran vdout0_54ck930 FIND v(dout0_54) AT=470.025n

.meas tran vdout0_55ck930 FIND v(dout0_55) AT=470.025n

.meas tran vdout0_56ck930 FIND v(dout0_56) AT=470.025n

.meas tran vdout0_57ck930 FIND v(dout0_57) AT=470.025n

.meas tran vdout0_58ck930 FIND v(dout0_58) AT=470.025n

.meas tran vdout0_59ck930 FIND v(dout0_59) AT=470.025n

.meas tran vdout0_60ck930 FIND v(dout0_60) AT=470.025n

.meas tran vdout0_61ck930 FIND v(dout0_61) AT=470.025n

.meas tran vdout0_62ck930 FIND v(dout0_62) AT=470.025n

.meas tran vdout0_63ck930 FIND v(dout0_63) AT=470.025n

.meas tran vdout0_64ck930 FIND v(dout0_64) AT=470.025n

.meas tran vdout0_65ck930 FIND v(dout0_65) AT=470.025n

.meas tran vdout0_66ck930 FIND v(dout0_66) AT=470.025n

.meas tran vdout0_67ck930 FIND v(dout0_67) AT=470.025n

.meas tran vdout0_68ck930 FIND v(dout0_68) AT=470.025n

.meas tran vdout0_69ck930 FIND v(dout0_69) AT=470.025n

.meas tran vdout0_70ck930 FIND v(dout0_70) AT=470.025n

.meas tran vdout0_71ck930 FIND v(dout0_71) AT=470.025n

.meas tran vdout0_72ck930 FIND v(dout0_72) AT=470.025n

.meas tran vdout0_73ck930 FIND v(dout0_73) AT=470.025n

.meas tran vdout0_74ck930 FIND v(dout0_74) AT=470.025n

.meas tran vdout0_75ck930 FIND v(dout0_75) AT=470.025n

.meas tran vdout0_76ck930 FIND v(dout0_76) AT=470.025n

.meas tran vdout0_77ck930 FIND v(dout0_77) AT=470.025n

.meas tran vdout0_78ck930 FIND v(dout0_78) AT=470.025n

.meas tran vdout0_79ck930 FIND v(dout0_79) AT=470.025n

.meas tran vdout0_80ck930 FIND v(dout0_80) AT=470.025n

.meas tran vdout0_81ck930 FIND v(dout0_81) AT=470.025n

.meas tran vdout0_82ck930 FIND v(dout0_82) AT=470.025n

.meas tran vdout0_83ck930 FIND v(dout0_83) AT=470.025n

.meas tran vdout0_84ck930 FIND v(dout0_84) AT=470.025n

.meas tran vdout0_85ck930 FIND v(dout0_85) AT=470.025n

.meas tran vdout0_86ck930 FIND v(dout0_86) AT=470.025n

.meas tran vdout0_87ck930 FIND v(dout0_87) AT=470.025n

.meas tran vdout0_88ck930 FIND v(dout0_88) AT=470.025n

.meas tran vdout0_89ck930 FIND v(dout0_89) AT=470.025n

.meas tran vdout0_90ck930 FIND v(dout0_90) AT=470.025n

.meas tran vdout0_91ck930 FIND v(dout0_91) AT=470.025n

.meas tran vdout0_92ck930 FIND v(dout0_92) AT=470.025n

.meas tran vdout0_93ck930 FIND v(dout0_93) AT=470.025n

.meas tran vdout0_94ck930 FIND v(dout0_94) AT=470.025n

.meas tran vdout0_95ck930 FIND v(dout0_95) AT=470.025n

.meas tran vdout0_96ck930 FIND v(dout0_96) AT=470.025n

.meas tran vdout0_97ck930 FIND v(dout0_97) AT=470.025n

.meas tran vdout0_98ck930 FIND v(dout0_98) AT=470.025n

.meas tran vdout0_99ck930 FIND v(dout0_99) AT=470.025n

.meas tran vdout0_100ck930 FIND v(dout0_100) AT=470.025n

.meas tran vdout0_101ck930 FIND v(dout0_101) AT=470.025n

.meas tran vdout0_102ck930 FIND v(dout0_102) AT=470.025n

.meas tran vdout0_103ck930 FIND v(dout0_103) AT=470.025n

.meas tran vdout0_104ck930 FIND v(dout0_104) AT=470.025n

.meas tran vdout0_105ck930 FIND v(dout0_105) AT=470.025n

.meas tran vdout0_106ck930 FIND v(dout0_106) AT=470.025n

.meas tran vdout0_107ck930 FIND v(dout0_107) AT=470.025n

.meas tran vdout0_108ck930 FIND v(dout0_108) AT=470.025n

.meas tran vdout0_109ck930 FIND v(dout0_109) AT=470.025n

.meas tran vdout0_110ck930 FIND v(dout0_110) AT=470.025n

.meas tran vdout0_111ck930 FIND v(dout0_111) AT=470.025n

.meas tran vdout0_112ck930 FIND v(dout0_112) AT=470.025n

.meas tran vdout0_113ck930 FIND v(dout0_113) AT=470.025n

.meas tran vdout0_114ck930 FIND v(dout0_114) AT=470.025n

.meas tran vdout0_115ck930 FIND v(dout0_115) AT=470.025n

.meas tran vdout0_116ck930 FIND v(dout0_116) AT=470.025n

.meas tran vdout0_117ck930 FIND v(dout0_117) AT=470.025n

.meas tran vdout0_118ck930 FIND v(dout0_118) AT=470.025n

.meas tran vdout0_119ck930 FIND v(dout0_119) AT=470.025n

.meas tran vdout0_120ck930 FIND v(dout0_120) AT=470.025n

.meas tran vdout0_121ck930 FIND v(dout0_121) AT=470.025n

.meas tran vdout0_122ck930 FIND v(dout0_122) AT=470.025n

.meas tran vdout0_123ck930 FIND v(dout0_123) AT=470.025n

.meas tran vdout0_124ck930 FIND v(dout0_124) AT=470.025n

.meas tran vdout0_125ck930 FIND v(dout0_125) AT=470.025n

.meas tran vdout0_126ck930 FIND v(dout0_126) AT=470.025n

.meas tran vdout0_127ck930 FIND v(dout0_127) AT=470.025n

.meas tran vdout0_128ck930 FIND v(dout0_128) AT=470.025n

.meas tran vdout0_129ck930 FIND v(dout0_129) AT=470.025n

.meas tran vdout0_130ck930 FIND v(dout0_130) AT=470.025n

.meas tran vdout0_131ck930 FIND v(dout0_131) AT=470.025n

.meas tran vdout0_132ck930 FIND v(dout0_132) AT=470.025n

.meas tran vdout0_133ck930 FIND v(dout0_133) AT=470.025n

.meas tran vdout0_134ck930 FIND v(dout0_134) AT=470.025n

.meas tran vdout0_135ck930 FIND v(dout0_135) AT=470.025n

.meas tran vdout0_136ck930 FIND v(dout0_136) AT=470.025n

.meas tran vdout0_137ck930 FIND v(dout0_137) AT=470.025n

.meas tran vdout0_138ck930 FIND v(dout0_138) AT=470.025n

.meas tran vdout0_139ck930 FIND v(dout0_139) AT=470.025n

.meas tran vdout0_140ck930 FIND v(dout0_140) AT=470.025n

.meas tran vdout0_141ck930 FIND v(dout0_141) AT=470.025n

.meas tran vdout0_142ck930 FIND v(dout0_142) AT=470.025n

.meas tran vdout0_143ck930 FIND v(dout0_143) AT=470.025n

.meas tran vdout0_144ck930 FIND v(dout0_144) AT=470.025n

.meas tran vdout0_145ck930 FIND v(dout0_145) AT=470.025n

.meas tran vdout0_146ck930 FIND v(dout0_146) AT=470.025n

.meas tran vdout0_147ck930 FIND v(dout0_147) AT=470.025n

.meas tran vdout0_148ck930 FIND v(dout0_148) AT=470.025n

.meas tran vdout0_149ck930 FIND v(dout0_149) AT=470.025n

.meas tran vdout0_150ck930 FIND v(dout0_150) AT=470.025n

.meas tran vdout0_151ck930 FIND v(dout0_151) AT=470.025n

.meas tran vdout0_152ck930 FIND v(dout0_152) AT=470.025n

.meas tran vdout0_153ck930 FIND v(dout0_153) AT=470.025n

.meas tran vdout0_154ck930 FIND v(dout0_154) AT=470.025n

.meas tran vdout0_155ck930 FIND v(dout0_155) AT=470.025n

.meas tran vdout0_156ck930 FIND v(dout0_156) AT=470.025n

.meas tran vdout0_157ck930 FIND v(dout0_157) AT=470.025n

.meas tran vdout0_158ck930 FIND v(dout0_158) AT=470.025n

.meas tran vdout0_159ck930 FIND v(dout0_159) AT=470.025n

.meas tran vdout0_160ck930 FIND v(dout0_160) AT=470.025n

.meas tran vdout0_161ck930 FIND v(dout0_161) AT=470.025n

.meas tran vdout0_162ck930 FIND v(dout0_162) AT=470.025n

.meas tran vdout0_163ck930 FIND v(dout0_163) AT=470.025n

.meas tran vdout0_164ck930 FIND v(dout0_164) AT=470.025n

.meas tran vdout0_165ck930 FIND v(dout0_165) AT=470.025n

.meas tran vdout0_166ck930 FIND v(dout0_166) AT=470.025n

.meas tran vdout0_167ck930 FIND v(dout0_167) AT=470.025n

.meas tran vdout0_168ck930 FIND v(dout0_168) AT=470.025n

.meas tran vdout0_169ck930 FIND v(dout0_169) AT=470.025n

.meas tran vdout0_170ck930 FIND v(dout0_170) AT=470.025n

.meas tran vdout0_171ck930 FIND v(dout0_171) AT=470.025n

.meas tran vdout0_172ck930 FIND v(dout0_172) AT=470.025n

.meas tran vdout0_173ck930 FIND v(dout0_173) AT=470.025n

.meas tran vdout0_174ck930 FIND v(dout0_174) AT=470.025n

.meas tran vdout0_175ck930 FIND v(dout0_175) AT=470.025n

.meas tran vdout0_176ck930 FIND v(dout0_176) AT=470.025n

.meas tran vdout0_177ck930 FIND v(dout0_177) AT=470.025n

.meas tran vdout0_178ck930 FIND v(dout0_178) AT=470.025n

.meas tran vdout0_179ck930 FIND v(dout0_179) AT=470.025n

.meas tran vdout0_180ck930 FIND v(dout0_180) AT=470.025n

.meas tran vdout0_181ck930 FIND v(dout0_181) AT=470.025n

.meas tran vdout0_182ck930 FIND v(dout0_182) AT=470.025n

.meas tran vdout0_183ck930 FIND v(dout0_183) AT=470.025n

.meas tran vdout0_184ck930 FIND v(dout0_184) AT=470.025n

.meas tran vdout0_185ck930 FIND v(dout0_185) AT=470.025n

.meas tran vdout0_186ck930 FIND v(dout0_186) AT=470.025n

.meas tran vdout0_187ck930 FIND v(dout0_187) AT=470.025n

.meas tran vdout0_188ck930 FIND v(dout0_188) AT=470.025n

.meas tran vdout0_189ck930 FIND v(dout0_189) AT=470.025n

.meas tran vdout0_190ck930 FIND v(dout0_190) AT=470.025n

.meas tran vdout0_191ck930 FIND v(dout0_191) AT=470.025n

.meas tran vdout0_192ck930 FIND v(dout0_192) AT=470.025n

.meas tran vdout0_193ck930 FIND v(dout0_193) AT=470.025n

.meas tran vdout0_194ck930 FIND v(dout0_194) AT=470.025n

.meas tran vdout0_195ck930 FIND v(dout0_195) AT=470.025n

.meas tran vdout0_196ck930 FIND v(dout0_196) AT=470.025n

.meas tran vdout0_197ck930 FIND v(dout0_197) AT=470.025n

.meas tran vdout0_198ck930 FIND v(dout0_198) AT=470.025n

.meas tran vdout0_199ck930 FIND v(dout0_199) AT=470.025n

.meas tran vdout0_200ck930 FIND v(dout0_200) AT=470.025n

.meas tran vdout0_201ck930 FIND v(dout0_201) AT=470.025n

.meas tran vdout0_202ck930 FIND v(dout0_202) AT=470.025n

.meas tran vdout0_203ck930 FIND v(dout0_203) AT=470.025n

.meas tran vdout0_204ck930 FIND v(dout0_204) AT=470.025n

.meas tran vdout0_205ck930 FIND v(dout0_205) AT=470.025n

.meas tran vdout0_206ck930 FIND v(dout0_206) AT=470.025n

.meas tran vdout0_207ck930 FIND v(dout0_207) AT=470.025n

.meas tran vdout0_208ck930 FIND v(dout0_208) AT=470.025n

.meas tran vdout0_209ck930 FIND v(dout0_209) AT=470.025n

.meas tran vdout0_210ck930 FIND v(dout0_210) AT=470.025n

.meas tran vdout0_211ck930 FIND v(dout0_211) AT=470.025n

.meas tran vdout0_212ck930 FIND v(dout0_212) AT=470.025n

.meas tran vdout0_213ck930 FIND v(dout0_213) AT=470.025n

.meas tran vdout0_214ck930 FIND v(dout0_214) AT=470.025n

.meas tran vdout0_215ck930 FIND v(dout0_215) AT=470.025n

.meas tran vdout0_216ck930 FIND v(dout0_216) AT=470.025n

.meas tran vdout0_217ck930 FIND v(dout0_217) AT=470.025n

.meas tran vdout0_218ck930 FIND v(dout0_218) AT=470.025n

.meas tran vdout0_219ck930 FIND v(dout0_219) AT=470.025n

.meas tran vdout0_220ck930 FIND v(dout0_220) AT=470.025n

.meas tran vdout0_221ck930 FIND v(dout0_221) AT=470.025n

.meas tran vdout0_222ck930 FIND v(dout0_222) AT=470.025n

.meas tran vdout0_223ck930 FIND v(dout0_223) AT=470.025n

.meas tran vdout0_224ck930 FIND v(dout0_224) AT=470.025n

.meas tran vdout0_225ck930 FIND v(dout0_225) AT=470.025n

.meas tran vdout0_226ck930 FIND v(dout0_226) AT=470.025n

.meas tran vdout0_227ck930 FIND v(dout0_227) AT=470.025n

.meas tran vdout0_228ck930 FIND v(dout0_228) AT=470.025n

.meas tran vdout0_229ck930 FIND v(dout0_229) AT=470.025n

.meas tran vdout0_230ck930 FIND v(dout0_230) AT=470.025n

.meas tran vdout0_231ck930 FIND v(dout0_231) AT=470.025n

.meas tran vdout0_232ck930 FIND v(dout0_232) AT=470.025n

.meas tran vdout0_233ck930 FIND v(dout0_233) AT=470.025n

.meas tran vdout0_234ck930 FIND v(dout0_234) AT=470.025n

.meas tran vdout0_235ck930 FIND v(dout0_235) AT=470.025n

.meas tran vdout0_236ck930 FIND v(dout0_236) AT=470.025n

.meas tran vdout0_237ck930 FIND v(dout0_237) AT=470.025n

.meas tran vdout0_238ck930 FIND v(dout0_238) AT=470.025n

.meas tran vdout0_239ck930 FIND v(dout0_239) AT=470.025n

.meas tran vdout0_240ck930 FIND v(dout0_240) AT=470.025n

.meas tran vdout0_241ck930 FIND v(dout0_241) AT=470.025n

.meas tran vdout0_242ck930 FIND v(dout0_242) AT=470.025n

.meas tran vdout0_243ck930 FIND v(dout0_243) AT=470.025n

.meas tran vdout0_244ck930 FIND v(dout0_244) AT=470.025n

.meas tran vdout0_245ck930 FIND v(dout0_245) AT=470.025n

.meas tran vdout0_246ck930 FIND v(dout0_246) AT=470.025n

.meas tran vdout0_247ck930 FIND v(dout0_247) AT=470.025n

.meas tran vdout0_248ck930 FIND v(dout0_248) AT=470.025n

.meas tran vdout0_249ck930 FIND v(dout0_249) AT=470.025n

.meas tran vdout0_250ck930 FIND v(dout0_250) AT=470.025n

.meas tran vdout0_251ck930 FIND v(dout0_251) AT=470.025n

.meas tran vdout0_252ck930 FIND v(dout0_252) AT=470.025n

.meas tran vdout0_253ck930 FIND v(dout0_253) AT=470.025n

.meas tran vdout0_254ck930 FIND v(dout0_254) AT=470.025n

.meas tran vdout0_255ck930 FIND v(dout0_255) AT=470.025n

.meas tran vdout0_0ck950 FIND v(dout0_0) AT=480.025n

.meas tran vdout0_1ck950 FIND v(dout0_1) AT=480.025n

.meas tran vdout0_2ck950 FIND v(dout0_2) AT=480.025n

.meas tran vdout0_3ck950 FIND v(dout0_3) AT=480.025n

.meas tran vdout0_4ck950 FIND v(dout0_4) AT=480.025n

.meas tran vdout0_5ck950 FIND v(dout0_5) AT=480.025n

.meas tran vdout0_6ck950 FIND v(dout0_6) AT=480.025n

.meas tran vdout0_7ck950 FIND v(dout0_7) AT=480.025n

.meas tran vdout0_8ck950 FIND v(dout0_8) AT=480.025n

.meas tran vdout0_9ck950 FIND v(dout0_9) AT=480.025n

.meas tran vdout0_10ck950 FIND v(dout0_10) AT=480.025n

.meas tran vdout0_11ck950 FIND v(dout0_11) AT=480.025n

.meas tran vdout0_12ck950 FIND v(dout0_12) AT=480.025n

.meas tran vdout0_13ck950 FIND v(dout0_13) AT=480.025n

.meas tran vdout0_14ck950 FIND v(dout0_14) AT=480.025n

.meas tran vdout0_15ck950 FIND v(dout0_15) AT=480.025n

.meas tran vdout0_16ck950 FIND v(dout0_16) AT=480.025n

.meas tran vdout0_17ck950 FIND v(dout0_17) AT=480.025n

.meas tran vdout0_18ck950 FIND v(dout0_18) AT=480.025n

.meas tran vdout0_19ck950 FIND v(dout0_19) AT=480.025n

.meas tran vdout0_20ck950 FIND v(dout0_20) AT=480.025n

.meas tran vdout0_21ck950 FIND v(dout0_21) AT=480.025n

.meas tran vdout0_22ck950 FIND v(dout0_22) AT=480.025n

.meas tran vdout0_23ck950 FIND v(dout0_23) AT=480.025n

.meas tran vdout0_24ck950 FIND v(dout0_24) AT=480.025n

.meas tran vdout0_25ck950 FIND v(dout0_25) AT=480.025n

.meas tran vdout0_26ck950 FIND v(dout0_26) AT=480.025n

.meas tran vdout0_27ck950 FIND v(dout0_27) AT=480.025n

.meas tran vdout0_28ck950 FIND v(dout0_28) AT=480.025n

.meas tran vdout0_29ck950 FIND v(dout0_29) AT=480.025n

.meas tran vdout0_30ck950 FIND v(dout0_30) AT=480.025n

.meas tran vdout0_31ck950 FIND v(dout0_31) AT=480.025n

.meas tran vdout0_32ck950 FIND v(dout0_32) AT=480.025n

.meas tran vdout0_33ck950 FIND v(dout0_33) AT=480.025n

.meas tran vdout0_34ck950 FIND v(dout0_34) AT=480.025n

.meas tran vdout0_35ck950 FIND v(dout0_35) AT=480.025n

.meas tran vdout0_36ck950 FIND v(dout0_36) AT=480.025n

.meas tran vdout0_37ck950 FIND v(dout0_37) AT=480.025n

.meas tran vdout0_38ck950 FIND v(dout0_38) AT=480.025n

.meas tran vdout0_39ck950 FIND v(dout0_39) AT=480.025n

.meas tran vdout0_40ck950 FIND v(dout0_40) AT=480.025n

.meas tran vdout0_41ck950 FIND v(dout0_41) AT=480.025n

.meas tran vdout0_42ck950 FIND v(dout0_42) AT=480.025n

.meas tran vdout0_43ck950 FIND v(dout0_43) AT=480.025n

.meas tran vdout0_44ck950 FIND v(dout0_44) AT=480.025n

.meas tran vdout0_45ck950 FIND v(dout0_45) AT=480.025n

.meas tran vdout0_46ck950 FIND v(dout0_46) AT=480.025n

.meas tran vdout0_47ck950 FIND v(dout0_47) AT=480.025n

.meas tran vdout0_48ck950 FIND v(dout0_48) AT=480.025n

.meas tran vdout0_49ck950 FIND v(dout0_49) AT=480.025n

.meas tran vdout0_50ck950 FIND v(dout0_50) AT=480.025n

.meas tran vdout0_51ck950 FIND v(dout0_51) AT=480.025n

.meas tran vdout0_52ck950 FIND v(dout0_52) AT=480.025n

.meas tran vdout0_53ck950 FIND v(dout0_53) AT=480.025n

.meas tran vdout0_54ck950 FIND v(dout0_54) AT=480.025n

.meas tran vdout0_55ck950 FIND v(dout0_55) AT=480.025n

.meas tran vdout0_56ck950 FIND v(dout0_56) AT=480.025n

.meas tran vdout0_57ck950 FIND v(dout0_57) AT=480.025n

.meas tran vdout0_58ck950 FIND v(dout0_58) AT=480.025n

.meas tran vdout0_59ck950 FIND v(dout0_59) AT=480.025n

.meas tran vdout0_60ck950 FIND v(dout0_60) AT=480.025n

.meas tran vdout0_61ck950 FIND v(dout0_61) AT=480.025n

.meas tran vdout0_62ck950 FIND v(dout0_62) AT=480.025n

.meas tran vdout0_63ck950 FIND v(dout0_63) AT=480.025n

.meas tran vdout0_64ck950 FIND v(dout0_64) AT=480.025n

.meas tran vdout0_65ck950 FIND v(dout0_65) AT=480.025n

.meas tran vdout0_66ck950 FIND v(dout0_66) AT=480.025n

.meas tran vdout0_67ck950 FIND v(dout0_67) AT=480.025n

.meas tran vdout0_68ck950 FIND v(dout0_68) AT=480.025n

.meas tran vdout0_69ck950 FIND v(dout0_69) AT=480.025n

.meas tran vdout0_70ck950 FIND v(dout0_70) AT=480.025n

.meas tran vdout0_71ck950 FIND v(dout0_71) AT=480.025n

.meas tran vdout0_72ck950 FIND v(dout0_72) AT=480.025n

.meas tran vdout0_73ck950 FIND v(dout0_73) AT=480.025n

.meas tran vdout0_74ck950 FIND v(dout0_74) AT=480.025n

.meas tran vdout0_75ck950 FIND v(dout0_75) AT=480.025n

.meas tran vdout0_76ck950 FIND v(dout0_76) AT=480.025n

.meas tran vdout0_77ck950 FIND v(dout0_77) AT=480.025n

.meas tran vdout0_78ck950 FIND v(dout0_78) AT=480.025n

.meas tran vdout0_79ck950 FIND v(dout0_79) AT=480.025n

.meas tran vdout0_80ck950 FIND v(dout0_80) AT=480.025n

.meas tran vdout0_81ck950 FIND v(dout0_81) AT=480.025n

.meas tran vdout0_82ck950 FIND v(dout0_82) AT=480.025n

.meas tran vdout0_83ck950 FIND v(dout0_83) AT=480.025n

.meas tran vdout0_84ck950 FIND v(dout0_84) AT=480.025n

.meas tran vdout0_85ck950 FIND v(dout0_85) AT=480.025n

.meas tran vdout0_86ck950 FIND v(dout0_86) AT=480.025n

.meas tran vdout0_87ck950 FIND v(dout0_87) AT=480.025n

.meas tran vdout0_88ck950 FIND v(dout0_88) AT=480.025n

.meas tran vdout0_89ck950 FIND v(dout0_89) AT=480.025n

.meas tran vdout0_90ck950 FIND v(dout0_90) AT=480.025n

.meas tran vdout0_91ck950 FIND v(dout0_91) AT=480.025n

.meas tran vdout0_92ck950 FIND v(dout0_92) AT=480.025n

.meas tran vdout0_93ck950 FIND v(dout0_93) AT=480.025n

.meas tran vdout0_94ck950 FIND v(dout0_94) AT=480.025n

.meas tran vdout0_95ck950 FIND v(dout0_95) AT=480.025n

.meas tran vdout0_96ck950 FIND v(dout0_96) AT=480.025n

.meas tran vdout0_97ck950 FIND v(dout0_97) AT=480.025n

.meas tran vdout0_98ck950 FIND v(dout0_98) AT=480.025n

.meas tran vdout0_99ck950 FIND v(dout0_99) AT=480.025n

.meas tran vdout0_100ck950 FIND v(dout0_100) AT=480.025n

.meas tran vdout0_101ck950 FIND v(dout0_101) AT=480.025n

.meas tran vdout0_102ck950 FIND v(dout0_102) AT=480.025n

.meas tran vdout0_103ck950 FIND v(dout0_103) AT=480.025n

.meas tran vdout0_104ck950 FIND v(dout0_104) AT=480.025n

.meas tran vdout0_105ck950 FIND v(dout0_105) AT=480.025n

.meas tran vdout0_106ck950 FIND v(dout0_106) AT=480.025n

.meas tran vdout0_107ck950 FIND v(dout0_107) AT=480.025n

.meas tran vdout0_108ck950 FIND v(dout0_108) AT=480.025n

.meas tran vdout0_109ck950 FIND v(dout0_109) AT=480.025n

.meas tran vdout0_110ck950 FIND v(dout0_110) AT=480.025n

.meas tran vdout0_111ck950 FIND v(dout0_111) AT=480.025n

.meas tran vdout0_112ck950 FIND v(dout0_112) AT=480.025n

.meas tran vdout0_113ck950 FIND v(dout0_113) AT=480.025n

.meas tran vdout0_114ck950 FIND v(dout0_114) AT=480.025n

.meas tran vdout0_115ck950 FIND v(dout0_115) AT=480.025n

.meas tran vdout0_116ck950 FIND v(dout0_116) AT=480.025n

.meas tran vdout0_117ck950 FIND v(dout0_117) AT=480.025n

.meas tran vdout0_118ck950 FIND v(dout0_118) AT=480.025n

.meas tran vdout0_119ck950 FIND v(dout0_119) AT=480.025n

.meas tran vdout0_120ck950 FIND v(dout0_120) AT=480.025n

.meas tran vdout0_121ck950 FIND v(dout0_121) AT=480.025n

.meas tran vdout0_122ck950 FIND v(dout0_122) AT=480.025n

.meas tran vdout0_123ck950 FIND v(dout0_123) AT=480.025n

.meas tran vdout0_124ck950 FIND v(dout0_124) AT=480.025n

.meas tran vdout0_125ck950 FIND v(dout0_125) AT=480.025n

.meas tran vdout0_126ck950 FIND v(dout0_126) AT=480.025n

.meas tran vdout0_127ck950 FIND v(dout0_127) AT=480.025n

.meas tran vdout0_128ck950 FIND v(dout0_128) AT=480.025n

.meas tran vdout0_129ck950 FIND v(dout0_129) AT=480.025n

.meas tran vdout0_130ck950 FIND v(dout0_130) AT=480.025n

.meas tran vdout0_131ck950 FIND v(dout0_131) AT=480.025n

.meas tran vdout0_132ck950 FIND v(dout0_132) AT=480.025n

.meas tran vdout0_133ck950 FIND v(dout0_133) AT=480.025n

.meas tran vdout0_134ck950 FIND v(dout0_134) AT=480.025n

.meas tran vdout0_135ck950 FIND v(dout0_135) AT=480.025n

.meas tran vdout0_136ck950 FIND v(dout0_136) AT=480.025n

.meas tran vdout0_137ck950 FIND v(dout0_137) AT=480.025n

.meas tran vdout0_138ck950 FIND v(dout0_138) AT=480.025n

.meas tran vdout0_139ck950 FIND v(dout0_139) AT=480.025n

.meas tran vdout0_140ck950 FIND v(dout0_140) AT=480.025n

.meas tran vdout0_141ck950 FIND v(dout0_141) AT=480.025n

.meas tran vdout0_142ck950 FIND v(dout0_142) AT=480.025n

.meas tran vdout0_143ck950 FIND v(dout0_143) AT=480.025n

.meas tran vdout0_144ck950 FIND v(dout0_144) AT=480.025n

.meas tran vdout0_145ck950 FIND v(dout0_145) AT=480.025n

.meas tran vdout0_146ck950 FIND v(dout0_146) AT=480.025n

.meas tran vdout0_147ck950 FIND v(dout0_147) AT=480.025n

.meas tran vdout0_148ck950 FIND v(dout0_148) AT=480.025n

.meas tran vdout0_149ck950 FIND v(dout0_149) AT=480.025n

.meas tran vdout0_150ck950 FIND v(dout0_150) AT=480.025n

.meas tran vdout0_151ck950 FIND v(dout0_151) AT=480.025n

.meas tran vdout0_152ck950 FIND v(dout0_152) AT=480.025n

.meas tran vdout0_153ck950 FIND v(dout0_153) AT=480.025n

.meas tran vdout0_154ck950 FIND v(dout0_154) AT=480.025n

.meas tran vdout0_155ck950 FIND v(dout0_155) AT=480.025n

.meas tran vdout0_156ck950 FIND v(dout0_156) AT=480.025n

.meas tran vdout0_157ck950 FIND v(dout0_157) AT=480.025n

.meas tran vdout0_158ck950 FIND v(dout0_158) AT=480.025n

.meas tran vdout0_159ck950 FIND v(dout0_159) AT=480.025n

.meas tran vdout0_160ck950 FIND v(dout0_160) AT=480.025n

.meas tran vdout0_161ck950 FIND v(dout0_161) AT=480.025n

.meas tran vdout0_162ck950 FIND v(dout0_162) AT=480.025n

.meas tran vdout0_163ck950 FIND v(dout0_163) AT=480.025n

.meas tran vdout0_164ck950 FIND v(dout0_164) AT=480.025n

.meas tran vdout0_165ck950 FIND v(dout0_165) AT=480.025n

.meas tran vdout0_166ck950 FIND v(dout0_166) AT=480.025n

.meas tran vdout0_167ck950 FIND v(dout0_167) AT=480.025n

.meas tran vdout0_168ck950 FIND v(dout0_168) AT=480.025n

.meas tran vdout0_169ck950 FIND v(dout0_169) AT=480.025n

.meas tran vdout0_170ck950 FIND v(dout0_170) AT=480.025n

.meas tran vdout0_171ck950 FIND v(dout0_171) AT=480.025n

.meas tran vdout0_172ck950 FIND v(dout0_172) AT=480.025n

.meas tran vdout0_173ck950 FIND v(dout0_173) AT=480.025n

.meas tran vdout0_174ck950 FIND v(dout0_174) AT=480.025n

.meas tran vdout0_175ck950 FIND v(dout0_175) AT=480.025n

.meas tran vdout0_176ck950 FIND v(dout0_176) AT=480.025n

.meas tran vdout0_177ck950 FIND v(dout0_177) AT=480.025n

.meas tran vdout0_178ck950 FIND v(dout0_178) AT=480.025n

.meas tran vdout0_179ck950 FIND v(dout0_179) AT=480.025n

.meas tran vdout0_180ck950 FIND v(dout0_180) AT=480.025n

.meas tran vdout0_181ck950 FIND v(dout0_181) AT=480.025n

.meas tran vdout0_182ck950 FIND v(dout0_182) AT=480.025n

.meas tran vdout0_183ck950 FIND v(dout0_183) AT=480.025n

.meas tran vdout0_184ck950 FIND v(dout0_184) AT=480.025n

.meas tran vdout0_185ck950 FIND v(dout0_185) AT=480.025n

.meas tran vdout0_186ck950 FIND v(dout0_186) AT=480.025n

.meas tran vdout0_187ck950 FIND v(dout0_187) AT=480.025n

.meas tran vdout0_188ck950 FIND v(dout0_188) AT=480.025n

.meas tran vdout0_189ck950 FIND v(dout0_189) AT=480.025n

.meas tran vdout0_190ck950 FIND v(dout0_190) AT=480.025n

.meas tran vdout0_191ck950 FIND v(dout0_191) AT=480.025n

.meas tran vdout0_192ck950 FIND v(dout0_192) AT=480.025n

.meas tran vdout0_193ck950 FIND v(dout0_193) AT=480.025n

.meas tran vdout0_194ck950 FIND v(dout0_194) AT=480.025n

.meas tran vdout0_195ck950 FIND v(dout0_195) AT=480.025n

.meas tran vdout0_196ck950 FIND v(dout0_196) AT=480.025n

.meas tran vdout0_197ck950 FIND v(dout0_197) AT=480.025n

.meas tran vdout0_198ck950 FIND v(dout0_198) AT=480.025n

.meas tran vdout0_199ck950 FIND v(dout0_199) AT=480.025n

.meas tran vdout0_200ck950 FIND v(dout0_200) AT=480.025n

.meas tran vdout0_201ck950 FIND v(dout0_201) AT=480.025n

.meas tran vdout0_202ck950 FIND v(dout0_202) AT=480.025n

.meas tran vdout0_203ck950 FIND v(dout0_203) AT=480.025n

.meas tran vdout0_204ck950 FIND v(dout0_204) AT=480.025n

.meas tran vdout0_205ck950 FIND v(dout0_205) AT=480.025n

.meas tran vdout0_206ck950 FIND v(dout0_206) AT=480.025n

.meas tran vdout0_207ck950 FIND v(dout0_207) AT=480.025n

.meas tran vdout0_208ck950 FIND v(dout0_208) AT=480.025n

.meas tran vdout0_209ck950 FIND v(dout0_209) AT=480.025n

.meas tran vdout0_210ck950 FIND v(dout0_210) AT=480.025n

.meas tran vdout0_211ck950 FIND v(dout0_211) AT=480.025n

.meas tran vdout0_212ck950 FIND v(dout0_212) AT=480.025n

.meas tran vdout0_213ck950 FIND v(dout0_213) AT=480.025n

.meas tran vdout0_214ck950 FIND v(dout0_214) AT=480.025n

.meas tran vdout0_215ck950 FIND v(dout0_215) AT=480.025n

.meas tran vdout0_216ck950 FIND v(dout0_216) AT=480.025n

.meas tran vdout0_217ck950 FIND v(dout0_217) AT=480.025n

.meas tran vdout0_218ck950 FIND v(dout0_218) AT=480.025n

.meas tran vdout0_219ck950 FIND v(dout0_219) AT=480.025n

.meas tran vdout0_220ck950 FIND v(dout0_220) AT=480.025n

.meas tran vdout0_221ck950 FIND v(dout0_221) AT=480.025n

.meas tran vdout0_222ck950 FIND v(dout0_222) AT=480.025n

.meas tran vdout0_223ck950 FIND v(dout0_223) AT=480.025n

.meas tran vdout0_224ck950 FIND v(dout0_224) AT=480.025n

.meas tran vdout0_225ck950 FIND v(dout0_225) AT=480.025n

.meas tran vdout0_226ck950 FIND v(dout0_226) AT=480.025n

.meas tran vdout0_227ck950 FIND v(dout0_227) AT=480.025n

.meas tran vdout0_228ck950 FIND v(dout0_228) AT=480.025n

.meas tran vdout0_229ck950 FIND v(dout0_229) AT=480.025n

.meas tran vdout0_230ck950 FIND v(dout0_230) AT=480.025n

.meas tran vdout0_231ck950 FIND v(dout0_231) AT=480.025n

.meas tran vdout0_232ck950 FIND v(dout0_232) AT=480.025n

.meas tran vdout0_233ck950 FIND v(dout0_233) AT=480.025n

.meas tran vdout0_234ck950 FIND v(dout0_234) AT=480.025n

.meas tran vdout0_235ck950 FIND v(dout0_235) AT=480.025n

.meas tran vdout0_236ck950 FIND v(dout0_236) AT=480.025n

.meas tran vdout0_237ck950 FIND v(dout0_237) AT=480.025n

.meas tran vdout0_238ck950 FIND v(dout0_238) AT=480.025n

.meas tran vdout0_239ck950 FIND v(dout0_239) AT=480.025n

.meas tran vdout0_240ck950 FIND v(dout0_240) AT=480.025n

.meas tran vdout0_241ck950 FIND v(dout0_241) AT=480.025n

.meas tran vdout0_242ck950 FIND v(dout0_242) AT=480.025n

.meas tran vdout0_243ck950 FIND v(dout0_243) AT=480.025n

.meas tran vdout0_244ck950 FIND v(dout0_244) AT=480.025n

.meas tran vdout0_245ck950 FIND v(dout0_245) AT=480.025n

.meas tran vdout0_246ck950 FIND v(dout0_246) AT=480.025n

.meas tran vdout0_247ck950 FIND v(dout0_247) AT=480.025n

.meas tran vdout0_248ck950 FIND v(dout0_248) AT=480.025n

.meas tran vdout0_249ck950 FIND v(dout0_249) AT=480.025n

.meas tran vdout0_250ck950 FIND v(dout0_250) AT=480.025n

.meas tran vdout0_251ck950 FIND v(dout0_251) AT=480.025n

.meas tran vdout0_252ck950 FIND v(dout0_252) AT=480.025n

.meas tran vdout0_253ck950 FIND v(dout0_253) AT=480.025n

.meas tran vdout0_254ck950 FIND v(dout0_254) AT=480.025n

.meas tran vdout0_255ck950 FIND v(dout0_255) AT=480.025n

.meas tran vdout0_0ck960 FIND v(dout0_0) AT=485.025n

.meas tran vdout0_1ck960 FIND v(dout0_1) AT=485.025n

.meas tran vdout0_2ck960 FIND v(dout0_2) AT=485.025n

.meas tran vdout0_3ck960 FIND v(dout0_3) AT=485.025n

.meas tran vdout0_4ck960 FIND v(dout0_4) AT=485.025n

.meas tran vdout0_5ck960 FIND v(dout0_5) AT=485.025n

.meas tran vdout0_6ck960 FIND v(dout0_6) AT=485.025n

.meas tran vdout0_7ck960 FIND v(dout0_7) AT=485.025n

.meas tran vdout0_8ck960 FIND v(dout0_8) AT=485.025n

.meas tran vdout0_9ck960 FIND v(dout0_9) AT=485.025n

.meas tran vdout0_10ck960 FIND v(dout0_10) AT=485.025n

.meas tran vdout0_11ck960 FIND v(dout0_11) AT=485.025n

.meas tran vdout0_12ck960 FIND v(dout0_12) AT=485.025n

.meas tran vdout0_13ck960 FIND v(dout0_13) AT=485.025n

.meas tran vdout0_14ck960 FIND v(dout0_14) AT=485.025n

.meas tran vdout0_15ck960 FIND v(dout0_15) AT=485.025n

.meas tran vdout0_16ck960 FIND v(dout0_16) AT=485.025n

.meas tran vdout0_17ck960 FIND v(dout0_17) AT=485.025n

.meas tran vdout0_18ck960 FIND v(dout0_18) AT=485.025n

.meas tran vdout0_19ck960 FIND v(dout0_19) AT=485.025n

.meas tran vdout0_20ck960 FIND v(dout0_20) AT=485.025n

.meas tran vdout0_21ck960 FIND v(dout0_21) AT=485.025n

.meas tran vdout0_22ck960 FIND v(dout0_22) AT=485.025n

.meas tran vdout0_23ck960 FIND v(dout0_23) AT=485.025n

.meas tran vdout0_24ck960 FIND v(dout0_24) AT=485.025n

.meas tran vdout0_25ck960 FIND v(dout0_25) AT=485.025n

.meas tran vdout0_26ck960 FIND v(dout0_26) AT=485.025n

.meas tran vdout0_27ck960 FIND v(dout0_27) AT=485.025n

.meas tran vdout0_28ck960 FIND v(dout0_28) AT=485.025n

.meas tran vdout0_29ck960 FIND v(dout0_29) AT=485.025n

.meas tran vdout0_30ck960 FIND v(dout0_30) AT=485.025n

.meas tran vdout0_31ck960 FIND v(dout0_31) AT=485.025n

.meas tran vdout0_32ck960 FIND v(dout0_32) AT=485.025n

.meas tran vdout0_33ck960 FIND v(dout0_33) AT=485.025n

.meas tran vdout0_34ck960 FIND v(dout0_34) AT=485.025n

.meas tran vdout0_35ck960 FIND v(dout0_35) AT=485.025n

.meas tran vdout0_36ck960 FIND v(dout0_36) AT=485.025n

.meas tran vdout0_37ck960 FIND v(dout0_37) AT=485.025n

.meas tran vdout0_38ck960 FIND v(dout0_38) AT=485.025n

.meas tran vdout0_39ck960 FIND v(dout0_39) AT=485.025n

.meas tran vdout0_40ck960 FIND v(dout0_40) AT=485.025n

.meas tran vdout0_41ck960 FIND v(dout0_41) AT=485.025n

.meas tran vdout0_42ck960 FIND v(dout0_42) AT=485.025n

.meas tran vdout0_43ck960 FIND v(dout0_43) AT=485.025n

.meas tran vdout0_44ck960 FIND v(dout0_44) AT=485.025n

.meas tran vdout0_45ck960 FIND v(dout0_45) AT=485.025n

.meas tran vdout0_46ck960 FIND v(dout0_46) AT=485.025n

.meas tran vdout0_47ck960 FIND v(dout0_47) AT=485.025n

.meas tran vdout0_48ck960 FIND v(dout0_48) AT=485.025n

.meas tran vdout0_49ck960 FIND v(dout0_49) AT=485.025n

.meas tran vdout0_50ck960 FIND v(dout0_50) AT=485.025n

.meas tran vdout0_51ck960 FIND v(dout0_51) AT=485.025n

.meas tran vdout0_52ck960 FIND v(dout0_52) AT=485.025n

.meas tran vdout0_53ck960 FIND v(dout0_53) AT=485.025n

.meas tran vdout0_54ck960 FIND v(dout0_54) AT=485.025n

.meas tran vdout0_55ck960 FIND v(dout0_55) AT=485.025n

.meas tran vdout0_56ck960 FIND v(dout0_56) AT=485.025n

.meas tran vdout0_57ck960 FIND v(dout0_57) AT=485.025n

.meas tran vdout0_58ck960 FIND v(dout0_58) AT=485.025n

.meas tran vdout0_59ck960 FIND v(dout0_59) AT=485.025n

.meas tran vdout0_60ck960 FIND v(dout0_60) AT=485.025n

.meas tran vdout0_61ck960 FIND v(dout0_61) AT=485.025n

.meas tran vdout0_62ck960 FIND v(dout0_62) AT=485.025n

.meas tran vdout0_63ck960 FIND v(dout0_63) AT=485.025n

.meas tran vdout0_64ck960 FIND v(dout0_64) AT=485.025n

.meas tran vdout0_65ck960 FIND v(dout0_65) AT=485.025n

.meas tran vdout0_66ck960 FIND v(dout0_66) AT=485.025n

.meas tran vdout0_67ck960 FIND v(dout0_67) AT=485.025n

.meas tran vdout0_68ck960 FIND v(dout0_68) AT=485.025n

.meas tran vdout0_69ck960 FIND v(dout0_69) AT=485.025n

.meas tran vdout0_70ck960 FIND v(dout0_70) AT=485.025n

.meas tran vdout0_71ck960 FIND v(dout0_71) AT=485.025n

.meas tran vdout0_72ck960 FIND v(dout0_72) AT=485.025n

.meas tran vdout0_73ck960 FIND v(dout0_73) AT=485.025n

.meas tran vdout0_74ck960 FIND v(dout0_74) AT=485.025n

.meas tran vdout0_75ck960 FIND v(dout0_75) AT=485.025n

.meas tran vdout0_76ck960 FIND v(dout0_76) AT=485.025n

.meas tran vdout0_77ck960 FIND v(dout0_77) AT=485.025n

.meas tran vdout0_78ck960 FIND v(dout0_78) AT=485.025n

.meas tran vdout0_79ck960 FIND v(dout0_79) AT=485.025n

.meas tran vdout0_80ck960 FIND v(dout0_80) AT=485.025n

.meas tran vdout0_81ck960 FIND v(dout0_81) AT=485.025n

.meas tran vdout0_82ck960 FIND v(dout0_82) AT=485.025n

.meas tran vdout0_83ck960 FIND v(dout0_83) AT=485.025n

.meas tran vdout0_84ck960 FIND v(dout0_84) AT=485.025n

.meas tran vdout0_85ck960 FIND v(dout0_85) AT=485.025n

.meas tran vdout0_86ck960 FIND v(dout0_86) AT=485.025n

.meas tran vdout0_87ck960 FIND v(dout0_87) AT=485.025n

.meas tran vdout0_88ck960 FIND v(dout0_88) AT=485.025n

.meas tran vdout0_89ck960 FIND v(dout0_89) AT=485.025n

.meas tran vdout0_90ck960 FIND v(dout0_90) AT=485.025n

.meas tran vdout0_91ck960 FIND v(dout0_91) AT=485.025n

.meas tran vdout0_92ck960 FIND v(dout0_92) AT=485.025n

.meas tran vdout0_93ck960 FIND v(dout0_93) AT=485.025n

.meas tran vdout0_94ck960 FIND v(dout0_94) AT=485.025n

.meas tran vdout0_95ck960 FIND v(dout0_95) AT=485.025n

.meas tran vdout0_96ck960 FIND v(dout0_96) AT=485.025n

.meas tran vdout0_97ck960 FIND v(dout0_97) AT=485.025n

.meas tran vdout0_98ck960 FIND v(dout0_98) AT=485.025n

.meas tran vdout0_99ck960 FIND v(dout0_99) AT=485.025n

.meas tran vdout0_100ck960 FIND v(dout0_100) AT=485.025n

.meas tran vdout0_101ck960 FIND v(dout0_101) AT=485.025n

.meas tran vdout0_102ck960 FIND v(dout0_102) AT=485.025n

.meas tran vdout0_103ck960 FIND v(dout0_103) AT=485.025n

.meas tran vdout0_104ck960 FIND v(dout0_104) AT=485.025n

.meas tran vdout0_105ck960 FIND v(dout0_105) AT=485.025n

.meas tran vdout0_106ck960 FIND v(dout0_106) AT=485.025n

.meas tran vdout0_107ck960 FIND v(dout0_107) AT=485.025n

.meas tran vdout0_108ck960 FIND v(dout0_108) AT=485.025n

.meas tran vdout0_109ck960 FIND v(dout0_109) AT=485.025n

.meas tran vdout0_110ck960 FIND v(dout0_110) AT=485.025n

.meas tran vdout0_111ck960 FIND v(dout0_111) AT=485.025n

.meas tran vdout0_112ck960 FIND v(dout0_112) AT=485.025n

.meas tran vdout0_113ck960 FIND v(dout0_113) AT=485.025n

.meas tran vdout0_114ck960 FIND v(dout0_114) AT=485.025n

.meas tran vdout0_115ck960 FIND v(dout0_115) AT=485.025n

.meas tran vdout0_116ck960 FIND v(dout0_116) AT=485.025n

.meas tran vdout0_117ck960 FIND v(dout0_117) AT=485.025n

.meas tran vdout0_118ck960 FIND v(dout0_118) AT=485.025n

.meas tran vdout0_119ck960 FIND v(dout0_119) AT=485.025n

.meas tran vdout0_120ck960 FIND v(dout0_120) AT=485.025n

.meas tran vdout0_121ck960 FIND v(dout0_121) AT=485.025n

.meas tran vdout0_122ck960 FIND v(dout0_122) AT=485.025n

.meas tran vdout0_123ck960 FIND v(dout0_123) AT=485.025n

.meas tran vdout0_124ck960 FIND v(dout0_124) AT=485.025n

.meas tran vdout0_125ck960 FIND v(dout0_125) AT=485.025n

.meas tran vdout0_126ck960 FIND v(dout0_126) AT=485.025n

.meas tran vdout0_127ck960 FIND v(dout0_127) AT=485.025n

.meas tran vdout0_128ck960 FIND v(dout0_128) AT=485.025n

.meas tran vdout0_129ck960 FIND v(dout0_129) AT=485.025n

.meas tran vdout0_130ck960 FIND v(dout0_130) AT=485.025n

.meas tran vdout0_131ck960 FIND v(dout0_131) AT=485.025n

.meas tran vdout0_132ck960 FIND v(dout0_132) AT=485.025n

.meas tran vdout0_133ck960 FIND v(dout0_133) AT=485.025n

.meas tran vdout0_134ck960 FIND v(dout0_134) AT=485.025n

.meas tran vdout0_135ck960 FIND v(dout0_135) AT=485.025n

.meas tran vdout0_136ck960 FIND v(dout0_136) AT=485.025n

.meas tran vdout0_137ck960 FIND v(dout0_137) AT=485.025n

.meas tran vdout0_138ck960 FIND v(dout0_138) AT=485.025n

.meas tran vdout0_139ck960 FIND v(dout0_139) AT=485.025n

.meas tran vdout0_140ck960 FIND v(dout0_140) AT=485.025n

.meas tran vdout0_141ck960 FIND v(dout0_141) AT=485.025n

.meas tran vdout0_142ck960 FIND v(dout0_142) AT=485.025n

.meas tran vdout0_143ck960 FIND v(dout0_143) AT=485.025n

.meas tran vdout0_144ck960 FIND v(dout0_144) AT=485.025n

.meas tran vdout0_145ck960 FIND v(dout0_145) AT=485.025n

.meas tran vdout0_146ck960 FIND v(dout0_146) AT=485.025n

.meas tran vdout0_147ck960 FIND v(dout0_147) AT=485.025n

.meas tran vdout0_148ck960 FIND v(dout0_148) AT=485.025n

.meas tran vdout0_149ck960 FIND v(dout0_149) AT=485.025n

.meas tran vdout0_150ck960 FIND v(dout0_150) AT=485.025n

.meas tran vdout0_151ck960 FIND v(dout0_151) AT=485.025n

.meas tran vdout0_152ck960 FIND v(dout0_152) AT=485.025n

.meas tran vdout0_153ck960 FIND v(dout0_153) AT=485.025n

.meas tran vdout0_154ck960 FIND v(dout0_154) AT=485.025n

.meas tran vdout0_155ck960 FIND v(dout0_155) AT=485.025n

.meas tran vdout0_156ck960 FIND v(dout0_156) AT=485.025n

.meas tran vdout0_157ck960 FIND v(dout0_157) AT=485.025n

.meas tran vdout0_158ck960 FIND v(dout0_158) AT=485.025n

.meas tran vdout0_159ck960 FIND v(dout0_159) AT=485.025n

.meas tran vdout0_160ck960 FIND v(dout0_160) AT=485.025n

.meas tran vdout0_161ck960 FIND v(dout0_161) AT=485.025n

.meas tran vdout0_162ck960 FIND v(dout0_162) AT=485.025n

.meas tran vdout0_163ck960 FIND v(dout0_163) AT=485.025n

.meas tran vdout0_164ck960 FIND v(dout0_164) AT=485.025n

.meas tran vdout0_165ck960 FIND v(dout0_165) AT=485.025n

.meas tran vdout0_166ck960 FIND v(dout0_166) AT=485.025n

.meas tran vdout0_167ck960 FIND v(dout0_167) AT=485.025n

.meas tran vdout0_168ck960 FIND v(dout0_168) AT=485.025n

.meas tran vdout0_169ck960 FIND v(dout0_169) AT=485.025n

.meas tran vdout0_170ck960 FIND v(dout0_170) AT=485.025n

.meas tran vdout0_171ck960 FIND v(dout0_171) AT=485.025n

.meas tran vdout0_172ck960 FIND v(dout0_172) AT=485.025n

.meas tran vdout0_173ck960 FIND v(dout0_173) AT=485.025n

.meas tran vdout0_174ck960 FIND v(dout0_174) AT=485.025n

.meas tran vdout0_175ck960 FIND v(dout0_175) AT=485.025n

.meas tran vdout0_176ck960 FIND v(dout0_176) AT=485.025n

.meas tran vdout0_177ck960 FIND v(dout0_177) AT=485.025n

.meas tran vdout0_178ck960 FIND v(dout0_178) AT=485.025n

.meas tran vdout0_179ck960 FIND v(dout0_179) AT=485.025n

.meas tran vdout0_180ck960 FIND v(dout0_180) AT=485.025n

.meas tran vdout0_181ck960 FIND v(dout0_181) AT=485.025n

.meas tran vdout0_182ck960 FIND v(dout0_182) AT=485.025n

.meas tran vdout0_183ck960 FIND v(dout0_183) AT=485.025n

.meas tran vdout0_184ck960 FIND v(dout0_184) AT=485.025n

.meas tran vdout0_185ck960 FIND v(dout0_185) AT=485.025n

.meas tran vdout0_186ck960 FIND v(dout0_186) AT=485.025n

.meas tran vdout0_187ck960 FIND v(dout0_187) AT=485.025n

.meas tran vdout0_188ck960 FIND v(dout0_188) AT=485.025n

.meas tran vdout0_189ck960 FIND v(dout0_189) AT=485.025n

.meas tran vdout0_190ck960 FIND v(dout0_190) AT=485.025n

.meas tran vdout0_191ck960 FIND v(dout0_191) AT=485.025n

.meas tran vdout0_192ck960 FIND v(dout0_192) AT=485.025n

.meas tran vdout0_193ck960 FIND v(dout0_193) AT=485.025n

.meas tran vdout0_194ck960 FIND v(dout0_194) AT=485.025n

.meas tran vdout0_195ck960 FIND v(dout0_195) AT=485.025n

.meas tran vdout0_196ck960 FIND v(dout0_196) AT=485.025n

.meas tran vdout0_197ck960 FIND v(dout0_197) AT=485.025n

.meas tran vdout0_198ck960 FIND v(dout0_198) AT=485.025n

.meas tran vdout0_199ck960 FIND v(dout0_199) AT=485.025n

.meas tran vdout0_200ck960 FIND v(dout0_200) AT=485.025n

.meas tran vdout0_201ck960 FIND v(dout0_201) AT=485.025n

.meas tran vdout0_202ck960 FIND v(dout0_202) AT=485.025n

.meas tran vdout0_203ck960 FIND v(dout0_203) AT=485.025n

.meas tran vdout0_204ck960 FIND v(dout0_204) AT=485.025n

.meas tran vdout0_205ck960 FIND v(dout0_205) AT=485.025n

.meas tran vdout0_206ck960 FIND v(dout0_206) AT=485.025n

.meas tran vdout0_207ck960 FIND v(dout0_207) AT=485.025n

.meas tran vdout0_208ck960 FIND v(dout0_208) AT=485.025n

.meas tran vdout0_209ck960 FIND v(dout0_209) AT=485.025n

.meas tran vdout0_210ck960 FIND v(dout0_210) AT=485.025n

.meas tran vdout0_211ck960 FIND v(dout0_211) AT=485.025n

.meas tran vdout0_212ck960 FIND v(dout0_212) AT=485.025n

.meas tran vdout0_213ck960 FIND v(dout0_213) AT=485.025n

.meas tran vdout0_214ck960 FIND v(dout0_214) AT=485.025n

.meas tran vdout0_215ck960 FIND v(dout0_215) AT=485.025n

.meas tran vdout0_216ck960 FIND v(dout0_216) AT=485.025n

.meas tran vdout0_217ck960 FIND v(dout0_217) AT=485.025n

.meas tran vdout0_218ck960 FIND v(dout0_218) AT=485.025n

.meas tran vdout0_219ck960 FIND v(dout0_219) AT=485.025n

.meas tran vdout0_220ck960 FIND v(dout0_220) AT=485.025n

.meas tran vdout0_221ck960 FIND v(dout0_221) AT=485.025n

.meas tran vdout0_222ck960 FIND v(dout0_222) AT=485.025n

.meas tran vdout0_223ck960 FIND v(dout0_223) AT=485.025n

.meas tran vdout0_224ck960 FIND v(dout0_224) AT=485.025n

.meas tran vdout0_225ck960 FIND v(dout0_225) AT=485.025n

.meas tran vdout0_226ck960 FIND v(dout0_226) AT=485.025n

.meas tran vdout0_227ck960 FIND v(dout0_227) AT=485.025n

.meas tran vdout0_228ck960 FIND v(dout0_228) AT=485.025n

.meas tran vdout0_229ck960 FIND v(dout0_229) AT=485.025n

.meas tran vdout0_230ck960 FIND v(dout0_230) AT=485.025n

.meas tran vdout0_231ck960 FIND v(dout0_231) AT=485.025n

.meas tran vdout0_232ck960 FIND v(dout0_232) AT=485.025n

.meas tran vdout0_233ck960 FIND v(dout0_233) AT=485.025n

.meas tran vdout0_234ck960 FIND v(dout0_234) AT=485.025n

.meas tran vdout0_235ck960 FIND v(dout0_235) AT=485.025n

.meas tran vdout0_236ck960 FIND v(dout0_236) AT=485.025n

.meas tran vdout0_237ck960 FIND v(dout0_237) AT=485.025n

.meas tran vdout0_238ck960 FIND v(dout0_238) AT=485.025n

.meas tran vdout0_239ck960 FIND v(dout0_239) AT=485.025n

.meas tran vdout0_240ck960 FIND v(dout0_240) AT=485.025n

.meas tran vdout0_241ck960 FIND v(dout0_241) AT=485.025n

.meas tran vdout0_242ck960 FIND v(dout0_242) AT=485.025n

.meas tran vdout0_243ck960 FIND v(dout0_243) AT=485.025n

.meas tran vdout0_244ck960 FIND v(dout0_244) AT=485.025n

.meas tran vdout0_245ck960 FIND v(dout0_245) AT=485.025n

.meas tran vdout0_246ck960 FIND v(dout0_246) AT=485.025n

.meas tran vdout0_247ck960 FIND v(dout0_247) AT=485.025n

.meas tran vdout0_248ck960 FIND v(dout0_248) AT=485.025n

.meas tran vdout0_249ck960 FIND v(dout0_249) AT=485.025n

.meas tran vdout0_250ck960 FIND v(dout0_250) AT=485.025n

.meas tran vdout0_251ck960 FIND v(dout0_251) AT=485.025n

.meas tran vdout0_252ck960 FIND v(dout0_252) AT=485.025n

.meas tran vdout0_253ck960 FIND v(dout0_253) AT=485.025n

.meas tran vdout0_254ck960 FIND v(dout0_254) AT=485.025n

.meas tran vdout0_255ck960 FIND v(dout0_255) AT=485.025n

.meas tran vdout0_0ck980 FIND v(dout0_0) AT=495.025n

.meas tran vdout0_1ck980 FIND v(dout0_1) AT=495.025n

.meas tran vdout0_2ck980 FIND v(dout0_2) AT=495.025n

.meas tran vdout0_3ck980 FIND v(dout0_3) AT=495.025n

.meas tran vdout0_4ck980 FIND v(dout0_4) AT=495.025n

.meas tran vdout0_5ck980 FIND v(dout0_5) AT=495.025n

.meas tran vdout0_6ck980 FIND v(dout0_6) AT=495.025n

.meas tran vdout0_7ck980 FIND v(dout0_7) AT=495.025n

.meas tran vdout0_8ck980 FIND v(dout0_8) AT=495.025n

.meas tran vdout0_9ck980 FIND v(dout0_9) AT=495.025n

.meas tran vdout0_10ck980 FIND v(dout0_10) AT=495.025n

.meas tran vdout0_11ck980 FIND v(dout0_11) AT=495.025n

.meas tran vdout0_12ck980 FIND v(dout0_12) AT=495.025n

.meas tran vdout0_13ck980 FIND v(dout0_13) AT=495.025n

.meas tran vdout0_14ck980 FIND v(dout0_14) AT=495.025n

.meas tran vdout0_15ck980 FIND v(dout0_15) AT=495.025n

.meas tran vdout0_16ck980 FIND v(dout0_16) AT=495.025n

.meas tran vdout0_17ck980 FIND v(dout0_17) AT=495.025n

.meas tran vdout0_18ck980 FIND v(dout0_18) AT=495.025n

.meas tran vdout0_19ck980 FIND v(dout0_19) AT=495.025n

.meas tran vdout0_20ck980 FIND v(dout0_20) AT=495.025n

.meas tran vdout0_21ck980 FIND v(dout0_21) AT=495.025n

.meas tran vdout0_22ck980 FIND v(dout0_22) AT=495.025n

.meas tran vdout0_23ck980 FIND v(dout0_23) AT=495.025n

.meas tran vdout0_24ck980 FIND v(dout0_24) AT=495.025n

.meas tran vdout0_25ck980 FIND v(dout0_25) AT=495.025n

.meas tran vdout0_26ck980 FIND v(dout0_26) AT=495.025n

.meas tran vdout0_27ck980 FIND v(dout0_27) AT=495.025n

.meas tran vdout0_28ck980 FIND v(dout0_28) AT=495.025n

.meas tran vdout0_29ck980 FIND v(dout0_29) AT=495.025n

.meas tran vdout0_30ck980 FIND v(dout0_30) AT=495.025n

.meas tran vdout0_31ck980 FIND v(dout0_31) AT=495.025n

.meas tran vdout0_32ck980 FIND v(dout0_32) AT=495.025n

.meas tran vdout0_33ck980 FIND v(dout0_33) AT=495.025n

.meas tran vdout0_34ck980 FIND v(dout0_34) AT=495.025n

.meas tran vdout0_35ck980 FIND v(dout0_35) AT=495.025n

.meas tran vdout0_36ck980 FIND v(dout0_36) AT=495.025n

.meas tran vdout0_37ck980 FIND v(dout0_37) AT=495.025n

.meas tran vdout0_38ck980 FIND v(dout0_38) AT=495.025n

.meas tran vdout0_39ck980 FIND v(dout0_39) AT=495.025n

.meas tran vdout0_40ck980 FIND v(dout0_40) AT=495.025n

.meas tran vdout0_41ck980 FIND v(dout0_41) AT=495.025n

.meas tran vdout0_42ck980 FIND v(dout0_42) AT=495.025n

.meas tran vdout0_43ck980 FIND v(dout0_43) AT=495.025n

.meas tran vdout0_44ck980 FIND v(dout0_44) AT=495.025n

.meas tran vdout0_45ck980 FIND v(dout0_45) AT=495.025n

.meas tran vdout0_46ck980 FIND v(dout0_46) AT=495.025n

.meas tran vdout0_47ck980 FIND v(dout0_47) AT=495.025n

.meas tran vdout0_48ck980 FIND v(dout0_48) AT=495.025n

.meas tran vdout0_49ck980 FIND v(dout0_49) AT=495.025n

.meas tran vdout0_50ck980 FIND v(dout0_50) AT=495.025n

.meas tran vdout0_51ck980 FIND v(dout0_51) AT=495.025n

.meas tran vdout0_52ck980 FIND v(dout0_52) AT=495.025n

.meas tran vdout0_53ck980 FIND v(dout0_53) AT=495.025n

.meas tran vdout0_54ck980 FIND v(dout0_54) AT=495.025n

.meas tran vdout0_55ck980 FIND v(dout0_55) AT=495.025n

.meas tran vdout0_56ck980 FIND v(dout0_56) AT=495.025n

.meas tran vdout0_57ck980 FIND v(dout0_57) AT=495.025n

.meas tran vdout0_58ck980 FIND v(dout0_58) AT=495.025n

.meas tran vdout0_59ck980 FIND v(dout0_59) AT=495.025n

.meas tran vdout0_60ck980 FIND v(dout0_60) AT=495.025n

.meas tran vdout0_61ck980 FIND v(dout0_61) AT=495.025n

.meas tran vdout0_62ck980 FIND v(dout0_62) AT=495.025n

.meas tran vdout0_63ck980 FIND v(dout0_63) AT=495.025n

.meas tran vdout0_64ck980 FIND v(dout0_64) AT=495.025n

.meas tran vdout0_65ck980 FIND v(dout0_65) AT=495.025n

.meas tran vdout0_66ck980 FIND v(dout0_66) AT=495.025n

.meas tran vdout0_67ck980 FIND v(dout0_67) AT=495.025n

.meas tran vdout0_68ck980 FIND v(dout0_68) AT=495.025n

.meas tran vdout0_69ck980 FIND v(dout0_69) AT=495.025n

.meas tran vdout0_70ck980 FIND v(dout0_70) AT=495.025n

.meas tran vdout0_71ck980 FIND v(dout0_71) AT=495.025n

.meas tran vdout0_72ck980 FIND v(dout0_72) AT=495.025n

.meas tran vdout0_73ck980 FIND v(dout0_73) AT=495.025n

.meas tran vdout0_74ck980 FIND v(dout0_74) AT=495.025n

.meas tran vdout0_75ck980 FIND v(dout0_75) AT=495.025n

.meas tran vdout0_76ck980 FIND v(dout0_76) AT=495.025n

.meas tran vdout0_77ck980 FIND v(dout0_77) AT=495.025n

.meas tran vdout0_78ck980 FIND v(dout0_78) AT=495.025n

.meas tran vdout0_79ck980 FIND v(dout0_79) AT=495.025n

.meas tran vdout0_80ck980 FIND v(dout0_80) AT=495.025n

.meas tran vdout0_81ck980 FIND v(dout0_81) AT=495.025n

.meas tran vdout0_82ck980 FIND v(dout0_82) AT=495.025n

.meas tran vdout0_83ck980 FIND v(dout0_83) AT=495.025n

.meas tran vdout0_84ck980 FIND v(dout0_84) AT=495.025n

.meas tran vdout0_85ck980 FIND v(dout0_85) AT=495.025n

.meas tran vdout0_86ck980 FIND v(dout0_86) AT=495.025n

.meas tran vdout0_87ck980 FIND v(dout0_87) AT=495.025n

.meas tran vdout0_88ck980 FIND v(dout0_88) AT=495.025n

.meas tran vdout0_89ck980 FIND v(dout0_89) AT=495.025n

.meas tran vdout0_90ck980 FIND v(dout0_90) AT=495.025n

.meas tran vdout0_91ck980 FIND v(dout0_91) AT=495.025n

.meas tran vdout0_92ck980 FIND v(dout0_92) AT=495.025n

.meas tran vdout0_93ck980 FIND v(dout0_93) AT=495.025n

.meas tran vdout0_94ck980 FIND v(dout0_94) AT=495.025n

.meas tran vdout0_95ck980 FIND v(dout0_95) AT=495.025n

.meas tran vdout0_96ck980 FIND v(dout0_96) AT=495.025n

.meas tran vdout0_97ck980 FIND v(dout0_97) AT=495.025n

.meas tran vdout0_98ck980 FIND v(dout0_98) AT=495.025n

.meas tran vdout0_99ck980 FIND v(dout0_99) AT=495.025n

.meas tran vdout0_100ck980 FIND v(dout0_100) AT=495.025n

.meas tran vdout0_101ck980 FIND v(dout0_101) AT=495.025n

.meas tran vdout0_102ck980 FIND v(dout0_102) AT=495.025n

.meas tran vdout0_103ck980 FIND v(dout0_103) AT=495.025n

.meas tran vdout0_104ck980 FIND v(dout0_104) AT=495.025n

.meas tran vdout0_105ck980 FIND v(dout0_105) AT=495.025n

.meas tran vdout0_106ck980 FIND v(dout0_106) AT=495.025n

.meas tran vdout0_107ck980 FIND v(dout0_107) AT=495.025n

.meas tran vdout0_108ck980 FIND v(dout0_108) AT=495.025n

.meas tran vdout0_109ck980 FIND v(dout0_109) AT=495.025n

.meas tran vdout0_110ck980 FIND v(dout0_110) AT=495.025n

.meas tran vdout0_111ck980 FIND v(dout0_111) AT=495.025n

.meas tran vdout0_112ck980 FIND v(dout0_112) AT=495.025n

.meas tran vdout0_113ck980 FIND v(dout0_113) AT=495.025n

.meas tran vdout0_114ck980 FIND v(dout0_114) AT=495.025n

.meas tran vdout0_115ck980 FIND v(dout0_115) AT=495.025n

.meas tran vdout0_116ck980 FIND v(dout0_116) AT=495.025n

.meas tran vdout0_117ck980 FIND v(dout0_117) AT=495.025n

.meas tran vdout0_118ck980 FIND v(dout0_118) AT=495.025n

.meas tran vdout0_119ck980 FIND v(dout0_119) AT=495.025n

.meas tran vdout0_120ck980 FIND v(dout0_120) AT=495.025n

.meas tran vdout0_121ck980 FIND v(dout0_121) AT=495.025n

.meas tran vdout0_122ck980 FIND v(dout0_122) AT=495.025n

.meas tran vdout0_123ck980 FIND v(dout0_123) AT=495.025n

.meas tran vdout0_124ck980 FIND v(dout0_124) AT=495.025n

.meas tran vdout0_125ck980 FIND v(dout0_125) AT=495.025n

.meas tran vdout0_126ck980 FIND v(dout0_126) AT=495.025n

.meas tran vdout0_127ck980 FIND v(dout0_127) AT=495.025n

.meas tran vdout0_128ck980 FIND v(dout0_128) AT=495.025n

.meas tran vdout0_129ck980 FIND v(dout0_129) AT=495.025n

.meas tran vdout0_130ck980 FIND v(dout0_130) AT=495.025n

.meas tran vdout0_131ck980 FIND v(dout0_131) AT=495.025n

.meas tran vdout0_132ck980 FIND v(dout0_132) AT=495.025n

.meas tran vdout0_133ck980 FIND v(dout0_133) AT=495.025n

.meas tran vdout0_134ck980 FIND v(dout0_134) AT=495.025n

.meas tran vdout0_135ck980 FIND v(dout0_135) AT=495.025n

.meas tran vdout0_136ck980 FIND v(dout0_136) AT=495.025n

.meas tran vdout0_137ck980 FIND v(dout0_137) AT=495.025n

.meas tran vdout0_138ck980 FIND v(dout0_138) AT=495.025n

.meas tran vdout0_139ck980 FIND v(dout0_139) AT=495.025n

.meas tran vdout0_140ck980 FIND v(dout0_140) AT=495.025n

.meas tran vdout0_141ck980 FIND v(dout0_141) AT=495.025n

.meas tran vdout0_142ck980 FIND v(dout0_142) AT=495.025n

.meas tran vdout0_143ck980 FIND v(dout0_143) AT=495.025n

.meas tran vdout0_144ck980 FIND v(dout0_144) AT=495.025n

.meas tran vdout0_145ck980 FIND v(dout0_145) AT=495.025n

.meas tran vdout0_146ck980 FIND v(dout0_146) AT=495.025n

.meas tran vdout0_147ck980 FIND v(dout0_147) AT=495.025n

.meas tran vdout0_148ck980 FIND v(dout0_148) AT=495.025n

.meas tran vdout0_149ck980 FIND v(dout0_149) AT=495.025n

.meas tran vdout0_150ck980 FIND v(dout0_150) AT=495.025n

.meas tran vdout0_151ck980 FIND v(dout0_151) AT=495.025n

.meas tran vdout0_152ck980 FIND v(dout0_152) AT=495.025n

.meas tran vdout0_153ck980 FIND v(dout0_153) AT=495.025n

.meas tran vdout0_154ck980 FIND v(dout0_154) AT=495.025n

.meas tran vdout0_155ck980 FIND v(dout0_155) AT=495.025n

.meas tran vdout0_156ck980 FIND v(dout0_156) AT=495.025n

.meas tran vdout0_157ck980 FIND v(dout0_157) AT=495.025n

.meas tran vdout0_158ck980 FIND v(dout0_158) AT=495.025n

.meas tran vdout0_159ck980 FIND v(dout0_159) AT=495.025n

.meas tran vdout0_160ck980 FIND v(dout0_160) AT=495.025n

.meas tran vdout0_161ck980 FIND v(dout0_161) AT=495.025n

.meas tran vdout0_162ck980 FIND v(dout0_162) AT=495.025n

.meas tran vdout0_163ck980 FIND v(dout0_163) AT=495.025n

.meas tran vdout0_164ck980 FIND v(dout0_164) AT=495.025n

.meas tran vdout0_165ck980 FIND v(dout0_165) AT=495.025n

.meas tran vdout0_166ck980 FIND v(dout0_166) AT=495.025n

.meas tran vdout0_167ck980 FIND v(dout0_167) AT=495.025n

.meas tran vdout0_168ck980 FIND v(dout0_168) AT=495.025n

.meas tran vdout0_169ck980 FIND v(dout0_169) AT=495.025n

.meas tran vdout0_170ck980 FIND v(dout0_170) AT=495.025n

.meas tran vdout0_171ck980 FIND v(dout0_171) AT=495.025n

.meas tran vdout0_172ck980 FIND v(dout0_172) AT=495.025n

.meas tran vdout0_173ck980 FIND v(dout0_173) AT=495.025n

.meas tran vdout0_174ck980 FIND v(dout0_174) AT=495.025n

.meas tran vdout0_175ck980 FIND v(dout0_175) AT=495.025n

.meas tran vdout0_176ck980 FIND v(dout0_176) AT=495.025n

.meas tran vdout0_177ck980 FIND v(dout0_177) AT=495.025n

.meas tran vdout0_178ck980 FIND v(dout0_178) AT=495.025n

.meas tran vdout0_179ck980 FIND v(dout0_179) AT=495.025n

.meas tran vdout0_180ck980 FIND v(dout0_180) AT=495.025n

.meas tran vdout0_181ck980 FIND v(dout0_181) AT=495.025n

.meas tran vdout0_182ck980 FIND v(dout0_182) AT=495.025n

.meas tran vdout0_183ck980 FIND v(dout0_183) AT=495.025n

.meas tran vdout0_184ck980 FIND v(dout0_184) AT=495.025n

.meas tran vdout0_185ck980 FIND v(dout0_185) AT=495.025n

.meas tran vdout0_186ck980 FIND v(dout0_186) AT=495.025n

.meas tran vdout0_187ck980 FIND v(dout0_187) AT=495.025n

.meas tran vdout0_188ck980 FIND v(dout0_188) AT=495.025n

.meas tran vdout0_189ck980 FIND v(dout0_189) AT=495.025n

.meas tran vdout0_190ck980 FIND v(dout0_190) AT=495.025n

.meas tran vdout0_191ck980 FIND v(dout0_191) AT=495.025n

.meas tran vdout0_192ck980 FIND v(dout0_192) AT=495.025n

.meas tran vdout0_193ck980 FIND v(dout0_193) AT=495.025n

.meas tran vdout0_194ck980 FIND v(dout0_194) AT=495.025n

.meas tran vdout0_195ck980 FIND v(dout0_195) AT=495.025n

.meas tran vdout0_196ck980 FIND v(dout0_196) AT=495.025n

.meas tran vdout0_197ck980 FIND v(dout0_197) AT=495.025n

.meas tran vdout0_198ck980 FIND v(dout0_198) AT=495.025n

.meas tran vdout0_199ck980 FIND v(dout0_199) AT=495.025n

.meas tran vdout0_200ck980 FIND v(dout0_200) AT=495.025n

.meas tran vdout0_201ck980 FIND v(dout0_201) AT=495.025n

.meas tran vdout0_202ck980 FIND v(dout0_202) AT=495.025n

.meas tran vdout0_203ck980 FIND v(dout0_203) AT=495.025n

.meas tran vdout0_204ck980 FIND v(dout0_204) AT=495.025n

.meas tran vdout0_205ck980 FIND v(dout0_205) AT=495.025n

.meas tran vdout0_206ck980 FIND v(dout0_206) AT=495.025n

.meas tran vdout0_207ck980 FIND v(dout0_207) AT=495.025n

.meas tran vdout0_208ck980 FIND v(dout0_208) AT=495.025n

.meas tran vdout0_209ck980 FIND v(dout0_209) AT=495.025n

.meas tran vdout0_210ck980 FIND v(dout0_210) AT=495.025n

.meas tran vdout0_211ck980 FIND v(dout0_211) AT=495.025n

.meas tran vdout0_212ck980 FIND v(dout0_212) AT=495.025n

.meas tran vdout0_213ck980 FIND v(dout0_213) AT=495.025n

.meas tran vdout0_214ck980 FIND v(dout0_214) AT=495.025n

.meas tran vdout0_215ck980 FIND v(dout0_215) AT=495.025n

.meas tran vdout0_216ck980 FIND v(dout0_216) AT=495.025n

.meas tran vdout0_217ck980 FIND v(dout0_217) AT=495.025n

.meas tran vdout0_218ck980 FIND v(dout0_218) AT=495.025n

.meas tran vdout0_219ck980 FIND v(dout0_219) AT=495.025n

.meas tran vdout0_220ck980 FIND v(dout0_220) AT=495.025n

.meas tran vdout0_221ck980 FIND v(dout0_221) AT=495.025n

.meas tran vdout0_222ck980 FIND v(dout0_222) AT=495.025n

.meas tran vdout0_223ck980 FIND v(dout0_223) AT=495.025n

.meas tran vdout0_224ck980 FIND v(dout0_224) AT=495.025n

.meas tran vdout0_225ck980 FIND v(dout0_225) AT=495.025n

.meas tran vdout0_226ck980 FIND v(dout0_226) AT=495.025n

.meas tran vdout0_227ck980 FIND v(dout0_227) AT=495.025n

.meas tran vdout0_228ck980 FIND v(dout0_228) AT=495.025n

.meas tran vdout0_229ck980 FIND v(dout0_229) AT=495.025n

.meas tran vdout0_230ck980 FIND v(dout0_230) AT=495.025n

.meas tran vdout0_231ck980 FIND v(dout0_231) AT=495.025n

.meas tran vdout0_232ck980 FIND v(dout0_232) AT=495.025n

.meas tran vdout0_233ck980 FIND v(dout0_233) AT=495.025n

.meas tran vdout0_234ck980 FIND v(dout0_234) AT=495.025n

.meas tran vdout0_235ck980 FIND v(dout0_235) AT=495.025n

.meas tran vdout0_236ck980 FIND v(dout0_236) AT=495.025n

.meas tran vdout0_237ck980 FIND v(dout0_237) AT=495.025n

.meas tran vdout0_238ck980 FIND v(dout0_238) AT=495.025n

.meas tran vdout0_239ck980 FIND v(dout0_239) AT=495.025n

.meas tran vdout0_240ck980 FIND v(dout0_240) AT=495.025n

.meas tran vdout0_241ck980 FIND v(dout0_241) AT=495.025n

.meas tran vdout0_242ck980 FIND v(dout0_242) AT=495.025n

.meas tran vdout0_243ck980 FIND v(dout0_243) AT=495.025n

.meas tran vdout0_244ck980 FIND v(dout0_244) AT=495.025n

.meas tran vdout0_245ck980 FIND v(dout0_245) AT=495.025n

.meas tran vdout0_246ck980 FIND v(dout0_246) AT=495.025n

.meas tran vdout0_247ck980 FIND v(dout0_247) AT=495.025n

.meas tran vdout0_248ck980 FIND v(dout0_248) AT=495.025n

.meas tran vdout0_249ck980 FIND v(dout0_249) AT=495.025n

.meas tran vdout0_250ck980 FIND v(dout0_250) AT=495.025n

.meas tran vdout0_251ck980 FIND v(dout0_251) AT=495.025n

.meas tran vdout0_252ck980 FIND v(dout0_252) AT=495.025n

.meas tran vdout0_253ck980 FIND v(dout0_253) AT=495.025n

.meas tran vdout0_254ck980 FIND v(dout0_254) AT=495.025n

.meas tran vdout0_255ck980 FIND v(dout0_255) AT=495.025n

.meas tran vdout0_0ck1010 FIND v(dout0_0) AT=510.025n

.meas tran vdout0_1ck1010 FIND v(dout0_1) AT=510.025n

.meas tran vdout0_2ck1010 FIND v(dout0_2) AT=510.025n

.meas tran vdout0_3ck1010 FIND v(dout0_3) AT=510.025n

.meas tran vdout0_4ck1010 FIND v(dout0_4) AT=510.025n

.meas tran vdout0_5ck1010 FIND v(dout0_5) AT=510.025n

.meas tran vdout0_6ck1010 FIND v(dout0_6) AT=510.025n

.meas tran vdout0_7ck1010 FIND v(dout0_7) AT=510.025n

.meas tran vdout0_8ck1010 FIND v(dout0_8) AT=510.025n

.meas tran vdout0_9ck1010 FIND v(dout0_9) AT=510.025n

.meas tran vdout0_10ck1010 FIND v(dout0_10) AT=510.025n

.meas tran vdout0_11ck1010 FIND v(dout0_11) AT=510.025n

.meas tran vdout0_12ck1010 FIND v(dout0_12) AT=510.025n

.meas tran vdout0_13ck1010 FIND v(dout0_13) AT=510.025n

.meas tran vdout0_14ck1010 FIND v(dout0_14) AT=510.025n

.meas tran vdout0_15ck1010 FIND v(dout0_15) AT=510.025n

.meas tran vdout0_16ck1010 FIND v(dout0_16) AT=510.025n

.meas tran vdout0_17ck1010 FIND v(dout0_17) AT=510.025n

.meas tran vdout0_18ck1010 FIND v(dout0_18) AT=510.025n

.meas tran vdout0_19ck1010 FIND v(dout0_19) AT=510.025n

.meas tran vdout0_20ck1010 FIND v(dout0_20) AT=510.025n

.meas tran vdout0_21ck1010 FIND v(dout0_21) AT=510.025n

.meas tran vdout0_22ck1010 FIND v(dout0_22) AT=510.025n

.meas tran vdout0_23ck1010 FIND v(dout0_23) AT=510.025n

.meas tran vdout0_24ck1010 FIND v(dout0_24) AT=510.025n

.meas tran vdout0_25ck1010 FIND v(dout0_25) AT=510.025n

.meas tran vdout0_26ck1010 FIND v(dout0_26) AT=510.025n

.meas tran vdout0_27ck1010 FIND v(dout0_27) AT=510.025n

.meas tran vdout0_28ck1010 FIND v(dout0_28) AT=510.025n

.meas tran vdout0_29ck1010 FIND v(dout0_29) AT=510.025n

.meas tran vdout0_30ck1010 FIND v(dout0_30) AT=510.025n

.meas tran vdout0_31ck1010 FIND v(dout0_31) AT=510.025n

.meas tran vdout0_32ck1010 FIND v(dout0_32) AT=510.025n

.meas tran vdout0_33ck1010 FIND v(dout0_33) AT=510.025n

.meas tran vdout0_34ck1010 FIND v(dout0_34) AT=510.025n

.meas tran vdout0_35ck1010 FIND v(dout0_35) AT=510.025n

.meas tran vdout0_36ck1010 FIND v(dout0_36) AT=510.025n

.meas tran vdout0_37ck1010 FIND v(dout0_37) AT=510.025n

.meas tran vdout0_38ck1010 FIND v(dout0_38) AT=510.025n

.meas tran vdout0_39ck1010 FIND v(dout0_39) AT=510.025n

.meas tran vdout0_40ck1010 FIND v(dout0_40) AT=510.025n

.meas tran vdout0_41ck1010 FIND v(dout0_41) AT=510.025n

.meas tran vdout0_42ck1010 FIND v(dout0_42) AT=510.025n

.meas tran vdout0_43ck1010 FIND v(dout0_43) AT=510.025n

.meas tran vdout0_44ck1010 FIND v(dout0_44) AT=510.025n

.meas tran vdout0_45ck1010 FIND v(dout0_45) AT=510.025n

.meas tran vdout0_46ck1010 FIND v(dout0_46) AT=510.025n

.meas tran vdout0_47ck1010 FIND v(dout0_47) AT=510.025n

.meas tran vdout0_48ck1010 FIND v(dout0_48) AT=510.025n

.meas tran vdout0_49ck1010 FIND v(dout0_49) AT=510.025n

.meas tran vdout0_50ck1010 FIND v(dout0_50) AT=510.025n

.meas tran vdout0_51ck1010 FIND v(dout0_51) AT=510.025n

.meas tran vdout0_52ck1010 FIND v(dout0_52) AT=510.025n

.meas tran vdout0_53ck1010 FIND v(dout0_53) AT=510.025n

.meas tran vdout0_54ck1010 FIND v(dout0_54) AT=510.025n

.meas tran vdout0_55ck1010 FIND v(dout0_55) AT=510.025n

.meas tran vdout0_56ck1010 FIND v(dout0_56) AT=510.025n

.meas tran vdout0_57ck1010 FIND v(dout0_57) AT=510.025n

.meas tran vdout0_58ck1010 FIND v(dout0_58) AT=510.025n

.meas tran vdout0_59ck1010 FIND v(dout0_59) AT=510.025n

.meas tran vdout0_60ck1010 FIND v(dout0_60) AT=510.025n

.meas tran vdout0_61ck1010 FIND v(dout0_61) AT=510.025n

.meas tran vdout0_62ck1010 FIND v(dout0_62) AT=510.025n

.meas tran vdout0_63ck1010 FIND v(dout0_63) AT=510.025n

.meas tran vdout0_64ck1010 FIND v(dout0_64) AT=510.025n

.meas tran vdout0_65ck1010 FIND v(dout0_65) AT=510.025n

.meas tran vdout0_66ck1010 FIND v(dout0_66) AT=510.025n

.meas tran vdout0_67ck1010 FIND v(dout0_67) AT=510.025n

.meas tran vdout0_68ck1010 FIND v(dout0_68) AT=510.025n

.meas tran vdout0_69ck1010 FIND v(dout0_69) AT=510.025n

.meas tran vdout0_70ck1010 FIND v(dout0_70) AT=510.025n

.meas tran vdout0_71ck1010 FIND v(dout0_71) AT=510.025n

.meas tran vdout0_72ck1010 FIND v(dout0_72) AT=510.025n

.meas tran vdout0_73ck1010 FIND v(dout0_73) AT=510.025n

.meas tran vdout0_74ck1010 FIND v(dout0_74) AT=510.025n

.meas tran vdout0_75ck1010 FIND v(dout0_75) AT=510.025n

.meas tran vdout0_76ck1010 FIND v(dout0_76) AT=510.025n

.meas tran vdout0_77ck1010 FIND v(dout0_77) AT=510.025n

.meas tran vdout0_78ck1010 FIND v(dout0_78) AT=510.025n

.meas tran vdout0_79ck1010 FIND v(dout0_79) AT=510.025n

.meas tran vdout0_80ck1010 FIND v(dout0_80) AT=510.025n

.meas tran vdout0_81ck1010 FIND v(dout0_81) AT=510.025n

.meas tran vdout0_82ck1010 FIND v(dout0_82) AT=510.025n

.meas tran vdout0_83ck1010 FIND v(dout0_83) AT=510.025n

.meas tran vdout0_84ck1010 FIND v(dout0_84) AT=510.025n

.meas tran vdout0_85ck1010 FIND v(dout0_85) AT=510.025n

.meas tran vdout0_86ck1010 FIND v(dout0_86) AT=510.025n

.meas tran vdout0_87ck1010 FIND v(dout0_87) AT=510.025n

.meas tran vdout0_88ck1010 FIND v(dout0_88) AT=510.025n

.meas tran vdout0_89ck1010 FIND v(dout0_89) AT=510.025n

.meas tran vdout0_90ck1010 FIND v(dout0_90) AT=510.025n

.meas tran vdout0_91ck1010 FIND v(dout0_91) AT=510.025n

.meas tran vdout0_92ck1010 FIND v(dout0_92) AT=510.025n

.meas tran vdout0_93ck1010 FIND v(dout0_93) AT=510.025n

.meas tran vdout0_94ck1010 FIND v(dout0_94) AT=510.025n

.meas tran vdout0_95ck1010 FIND v(dout0_95) AT=510.025n

.meas tran vdout0_96ck1010 FIND v(dout0_96) AT=510.025n

.meas tran vdout0_97ck1010 FIND v(dout0_97) AT=510.025n

.meas tran vdout0_98ck1010 FIND v(dout0_98) AT=510.025n

.meas tran vdout0_99ck1010 FIND v(dout0_99) AT=510.025n

.meas tran vdout0_100ck1010 FIND v(dout0_100) AT=510.025n

.meas tran vdout0_101ck1010 FIND v(dout0_101) AT=510.025n

.meas tran vdout0_102ck1010 FIND v(dout0_102) AT=510.025n

.meas tran vdout0_103ck1010 FIND v(dout0_103) AT=510.025n

.meas tran vdout0_104ck1010 FIND v(dout0_104) AT=510.025n

.meas tran vdout0_105ck1010 FIND v(dout0_105) AT=510.025n

.meas tran vdout0_106ck1010 FIND v(dout0_106) AT=510.025n

.meas tran vdout0_107ck1010 FIND v(dout0_107) AT=510.025n

.meas tran vdout0_108ck1010 FIND v(dout0_108) AT=510.025n

.meas tran vdout0_109ck1010 FIND v(dout0_109) AT=510.025n

.meas tran vdout0_110ck1010 FIND v(dout0_110) AT=510.025n

.meas tran vdout0_111ck1010 FIND v(dout0_111) AT=510.025n

.meas tran vdout0_112ck1010 FIND v(dout0_112) AT=510.025n

.meas tran vdout0_113ck1010 FIND v(dout0_113) AT=510.025n

.meas tran vdout0_114ck1010 FIND v(dout0_114) AT=510.025n

.meas tran vdout0_115ck1010 FIND v(dout0_115) AT=510.025n

.meas tran vdout0_116ck1010 FIND v(dout0_116) AT=510.025n

.meas tran vdout0_117ck1010 FIND v(dout0_117) AT=510.025n

.meas tran vdout0_118ck1010 FIND v(dout0_118) AT=510.025n

.meas tran vdout0_119ck1010 FIND v(dout0_119) AT=510.025n

.meas tran vdout0_120ck1010 FIND v(dout0_120) AT=510.025n

.meas tran vdout0_121ck1010 FIND v(dout0_121) AT=510.025n

.meas tran vdout0_122ck1010 FIND v(dout0_122) AT=510.025n

.meas tran vdout0_123ck1010 FIND v(dout0_123) AT=510.025n

.meas tran vdout0_124ck1010 FIND v(dout0_124) AT=510.025n

.meas tran vdout0_125ck1010 FIND v(dout0_125) AT=510.025n

.meas tran vdout0_126ck1010 FIND v(dout0_126) AT=510.025n

.meas tran vdout0_127ck1010 FIND v(dout0_127) AT=510.025n

.meas tran vdout0_128ck1010 FIND v(dout0_128) AT=510.025n

.meas tran vdout0_129ck1010 FIND v(dout0_129) AT=510.025n

.meas tran vdout0_130ck1010 FIND v(dout0_130) AT=510.025n

.meas tran vdout0_131ck1010 FIND v(dout0_131) AT=510.025n

.meas tran vdout0_132ck1010 FIND v(dout0_132) AT=510.025n

.meas tran vdout0_133ck1010 FIND v(dout0_133) AT=510.025n

.meas tran vdout0_134ck1010 FIND v(dout0_134) AT=510.025n

.meas tran vdout0_135ck1010 FIND v(dout0_135) AT=510.025n

.meas tran vdout0_136ck1010 FIND v(dout0_136) AT=510.025n

.meas tran vdout0_137ck1010 FIND v(dout0_137) AT=510.025n

.meas tran vdout0_138ck1010 FIND v(dout0_138) AT=510.025n

.meas tran vdout0_139ck1010 FIND v(dout0_139) AT=510.025n

.meas tran vdout0_140ck1010 FIND v(dout0_140) AT=510.025n

.meas tran vdout0_141ck1010 FIND v(dout0_141) AT=510.025n

.meas tran vdout0_142ck1010 FIND v(dout0_142) AT=510.025n

.meas tran vdout0_143ck1010 FIND v(dout0_143) AT=510.025n

.meas tran vdout0_144ck1010 FIND v(dout0_144) AT=510.025n

.meas tran vdout0_145ck1010 FIND v(dout0_145) AT=510.025n

.meas tran vdout0_146ck1010 FIND v(dout0_146) AT=510.025n

.meas tran vdout0_147ck1010 FIND v(dout0_147) AT=510.025n

.meas tran vdout0_148ck1010 FIND v(dout0_148) AT=510.025n

.meas tran vdout0_149ck1010 FIND v(dout0_149) AT=510.025n

.meas tran vdout0_150ck1010 FIND v(dout0_150) AT=510.025n

.meas tran vdout0_151ck1010 FIND v(dout0_151) AT=510.025n

.meas tran vdout0_152ck1010 FIND v(dout0_152) AT=510.025n

.meas tran vdout0_153ck1010 FIND v(dout0_153) AT=510.025n

.meas tran vdout0_154ck1010 FIND v(dout0_154) AT=510.025n

.meas tran vdout0_155ck1010 FIND v(dout0_155) AT=510.025n

.meas tran vdout0_156ck1010 FIND v(dout0_156) AT=510.025n

.meas tran vdout0_157ck1010 FIND v(dout0_157) AT=510.025n

.meas tran vdout0_158ck1010 FIND v(dout0_158) AT=510.025n

.meas tran vdout0_159ck1010 FIND v(dout0_159) AT=510.025n

.meas tran vdout0_160ck1010 FIND v(dout0_160) AT=510.025n

.meas tran vdout0_161ck1010 FIND v(dout0_161) AT=510.025n

.meas tran vdout0_162ck1010 FIND v(dout0_162) AT=510.025n

.meas tran vdout0_163ck1010 FIND v(dout0_163) AT=510.025n

.meas tran vdout0_164ck1010 FIND v(dout0_164) AT=510.025n

.meas tran vdout0_165ck1010 FIND v(dout0_165) AT=510.025n

.meas tran vdout0_166ck1010 FIND v(dout0_166) AT=510.025n

.meas tran vdout0_167ck1010 FIND v(dout0_167) AT=510.025n

.meas tran vdout0_168ck1010 FIND v(dout0_168) AT=510.025n

.meas tran vdout0_169ck1010 FIND v(dout0_169) AT=510.025n

.meas tran vdout0_170ck1010 FIND v(dout0_170) AT=510.025n

.meas tran vdout0_171ck1010 FIND v(dout0_171) AT=510.025n

.meas tran vdout0_172ck1010 FIND v(dout0_172) AT=510.025n

.meas tran vdout0_173ck1010 FIND v(dout0_173) AT=510.025n

.meas tran vdout0_174ck1010 FIND v(dout0_174) AT=510.025n

.meas tran vdout0_175ck1010 FIND v(dout0_175) AT=510.025n

.meas tran vdout0_176ck1010 FIND v(dout0_176) AT=510.025n

.meas tran vdout0_177ck1010 FIND v(dout0_177) AT=510.025n

.meas tran vdout0_178ck1010 FIND v(dout0_178) AT=510.025n

.meas tran vdout0_179ck1010 FIND v(dout0_179) AT=510.025n

.meas tran vdout0_180ck1010 FIND v(dout0_180) AT=510.025n

.meas tran vdout0_181ck1010 FIND v(dout0_181) AT=510.025n

.meas tran vdout0_182ck1010 FIND v(dout0_182) AT=510.025n

.meas tran vdout0_183ck1010 FIND v(dout0_183) AT=510.025n

.meas tran vdout0_184ck1010 FIND v(dout0_184) AT=510.025n

.meas tran vdout0_185ck1010 FIND v(dout0_185) AT=510.025n

.meas tran vdout0_186ck1010 FIND v(dout0_186) AT=510.025n

.meas tran vdout0_187ck1010 FIND v(dout0_187) AT=510.025n

.meas tran vdout0_188ck1010 FIND v(dout0_188) AT=510.025n

.meas tran vdout0_189ck1010 FIND v(dout0_189) AT=510.025n

.meas tran vdout0_190ck1010 FIND v(dout0_190) AT=510.025n

.meas tran vdout0_191ck1010 FIND v(dout0_191) AT=510.025n

.meas tran vdout0_192ck1010 FIND v(dout0_192) AT=510.025n

.meas tran vdout0_193ck1010 FIND v(dout0_193) AT=510.025n

.meas tran vdout0_194ck1010 FIND v(dout0_194) AT=510.025n

.meas tran vdout0_195ck1010 FIND v(dout0_195) AT=510.025n

.meas tran vdout0_196ck1010 FIND v(dout0_196) AT=510.025n

.meas tran vdout0_197ck1010 FIND v(dout0_197) AT=510.025n

.meas tran vdout0_198ck1010 FIND v(dout0_198) AT=510.025n

.meas tran vdout0_199ck1010 FIND v(dout0_199) AT=510.025n

.meas tran vdout0_200ck1010 FIND v(dout0_200) AT=510.025n

.meas tran vdout0_201ck1010 FIND v(dout0_201) AT=510.025n

.meas tran vdout0_202ck1010 FIND v(dout0_202) AT=510.025n

.meas tran vdout0_203ck1010 FIND v(dout0_203) AT=510.025n

.meas tran vdout0_204ck1010 FIND v(dout0_204) AT=510.025n

.meas tran vdout0_205ck1010 FIND v(dout0_205) AT=510.025n

.meas tran vdout0_206ck1010 FIND v(dout0_206) AT=510.025n

.meas tran vdout0_207ck1010 FIND v(dout0_207) AT=510.025n

.meas tran vdout0_208ck1010 FIND v(dout0_208) AT=510.025n

.meas tran vdout0_209ck1010 FIND v(dout0_209) AT=510.025n

.meas tran vdout0_210ck1010 FIND v(dout0_210) AT=510.025n

.meas tran vdout0_211ck1010 FIND v(dout0_211) AT=510.025n

.meas tran vdout0_212ck1010 FIND v(dout0_212) AT=510.025n

.meas tran vdout0_213ck1010 FIND v(dout0_213) AT=510.025n

.meas tran vdout0_214ck1010 FIND v(dout0_214) AT=510.025n

.meas tran vdout0_215ck1010 FIND v(dout0_215) AT=510.025n

.meas tran vdout0_216ck1010 FIND v(dout0_216) AT=510.025n

.meas tran vdout0_217ck1010 FIND v(dout0_217) AT=510.025n

.meas tran vdout0_218ck1010 FIND v(dout0_218) AT=510.025n

.meas tran vdout0_219ck1010 FIND v(dout0_219) AT=510.025n

.meas tran vdout0_220ck1010 FIND v(dout0_220) AT=510.025n

.meas tran vdout0_221ck1010 FIND v(dout0_221) AT=510.025n

.meas tran vdout0_222ck1010 FIND v(dout0_222) AT=510.025n

.meas tran vdout0_223ck1010 FIND v(dout0_223) AT=510.025n

.meas tran vdout0_224ck1010 FIND v(dout0_224) AT=510.025n

.meas tran vdout0_225ck1010 FIND v(dout0_225) AT=510.025n

.meas tran vdout0_226ck1010 FIND v(dout0_226) AT=510.025n

.meas tran vdout0_227ck1010 FIND v(dout0_227) AT=510.025n

.meas tran vdout0_228ck1010 FIND v(dout0_228) AT=510.025n

.meas tran vdout0_229ck1010 FIND v(dout0_229) AT=510.025n

.meas tran vdout0_230ck1010 FIND v(dout0_230) AT=510.025n

.meas tran vdout0_231ck1010 FIND v(dout0_231) AT=510.025n

.meas tran vdout0_232ck1010 FIND v(dout0_232) AT=510.025n

.meas tran vdout0_233ck1010 FIND v(dout0_233) AT=510.025n

.meas tran vdout0_234ck1010 FIND v(dout0_234) AT=510.025n

.meas tran vdout0_235ck1010 FIND v(dout0_235) AT=510.025n

.meas tran vdout0_236ck1010 FIND v(dout0_236) AT=510.025n

.meas tran vdout0_237ck1010 FIND v(dout0_237) AT=510.025n

.meas tran vdout0_238ck1010 FIND v(dout0_238) AT=510.025n

.meas tran vdout0_239ck1010 FIND v(dout0_239) AT=510.025n

.meas tran vdout0_240ck1010 FIND v(dout0_240) AT=510.025n

.meas tran vdout0_241ck1010 FIND v(dout0_241) AT=510.025n

.meas tran vdout0_242ck1010 FIND v(dout0_242) AT=510.025n

.meas tran vdout0_243ck1010 FIND v(dout0_243) AT=510.025n

.meas tran vdout0_244ck1010 FIND v(dout0_244) AT=510.025n

.meas tran vdout0_245ck1010 FIND v(dout0_245) AT=510.025n

.meas tran vdout0_246ck1010 FIND v(dout0_246) AT=510.025n

.meas tran vdout0_247ck1010 FIND v(dout0_247) AT=510.025n

.meas tran vdout0_248ck1010 FIND v(dout0_248) AT=510.025n

.meas tran vdout0_249ck1010 FIND v(dout0_249) AT=510.025n

.meas tran vdout0_250ck1010 FIND v(dout0_250) AT=510.025n

.meas tran vdout0_251ck1010 FIND v(dout0_251) AT=510.025n

.meas tran vdout0_252ck1010 FIND v(dout0_252) AT=510.025n

.meas tran vdout0_253ck1010 FIND v(dout0_253) AT=510.025n

.meas tran vdout0_254ck1010 FIND v(dout0_254) AT=510.025n

.meas tran vdout0_255ck1010 FIND v(dout0_255) AT=510.025n

.meas tran vdout0_0ck1020 FIND v(dout0_0) AT=515.025n

.meas tran vdout0_1ck1020 FIND v(dout0_1) AT=515.025n

.meas tran vdout0_2ck1020 FIND v(dout0_2) AT=515.025n

.meas tran vdout0_3ck1020 FIND v(dout0_3) AT=515.025n

.meas tran vdout0_4ck1020 FIND v(dout0_4) AT=515.025n

.meas tran vdout0_5ck1020 FIND v(dout0_5) AT=515.025n

.meas tran vdout0_6ck1020 FIND v(dout0_6) AT=515.025n

.meas tran vdout0_7ck1020 FIND v(dout0_7) AT=515.025n

.meas tran vdout0_8ck1020 FIND v(dout0_8) AT=515.025n

.meas tran vdout0_9ck1020 FIND v(dout0_9) AT=515.025n

.meas tran vdout0_10ck1020 FIND v(dout0_10) AT=515.025n

.meas tran vdout0_11ck1020 FIND v(dout0_11) AT=515.025n

.meas tran vdout0_12ck1020 FIND v(dout0_12) AT=515.025n

.meas tran vdout0_13ck1020 FIND v(dout0_13) AT=515.025n

.meas tran vdout0_14ck1020 FIND v(dout0_14) AT=515.025n

.meas tran vdout0_15ck1020 FIND v(dout0_15) AT=515.025n

.meas tran vdout0_16ck1020 FIND v(dout0_16) AT=515.025n

.meas tran vdout0_17ck1020 FIND v(dout0_17) AT=515.025n

.meas tran vdout0_18ck1020 FIND v(dout0_18) AT=515.025n

.meas tran vdout0_19ck1020 FIND v(dout0_19) AT=515.025n

.meas tran vdout0_20ck1020 FIND v(dout0_20) AT=515.025n

.meas tran vdout0_21ck1020 FIND v(dout0_21) AT=515.025n

.meas tran vdout0_22ck1020 FIND v(dout0_22) AT=515.025n

.meas tran vdout0_23ck1020 FIND v(dout0_23) AT=515.025n

.meas tran vdout0_24ck1020 FIND v(dout0_24) AT=515.025n

.meas tran vdout0_25ck1020 FIND v(dout0_25) AT=515.025n

.meas tran vdout0_26ck1020 FIND v(dout0_26) AT=515.025n

.meas tran vdout0_27ck1020 FIND v(dout0_27) AT=515.025n

.meas tran vdout0_28ck1020 FIND v(dout0_28) AT=515.025n

.meas tran vdout0_29ck1020 FIND v(dout0_29) AT=515.025n

.meas tran vdout0_30ck1020 FIND v(dout0_30) AT=515.025n

.meas tran vdout0_31ck1020 FIND v(dout0_31) AT=515.025n

.meas tran vdout0_32ck1020 FIND v(dout0_32) AT=515.025n

.meas tran vdout0_33ck1020 FIND v(dout0_33) AT=515.025n

.meas tran vdout0_34ck1020 FIND v(dout0_34) AT=515.025n

.meas tran vdout0_35ck1020 FIND v(dout0_35) AT=515.025n

.meas tran vdout0_36ck1020 FIND v(dout0_36) AT=515.025n

.meas tran vdout0_37ck1020 FIND v(dout0_37) AT=515.025n

.meas tran vdout0_38ck1020 FIND v(dout0_38) AT=515.025n

.meas tran vdout0_39ck1020 FIND v(dout0_39) AT=515.025n

.meas tran vdout0_40ck1020 FIND v(dout0_40) AT=515.025n

.meas tran vdout0_41ck1020 FIND v(dout0_41) AT=515.025n

.meas tran vdout0_42ck1020 FIND v(dout0_42) AT=515.025n

.meas tran vdout0_43ck1020 FIND v(dout0_43) AT=515.025n

.meas tran vdout0_44ck1020 FIND v(dout0_44) AT=515.025n

.meas tran vdout0_45ck1020 FIND v(dout0_45) AT=515.025n

.meas tran vdout0_46ck1020 FIND v(dout0_46) AT=515.025n

.meas tran vdout0_47ck1020 FIND v(dout0_47) AT=515.025n

.meas tran vdout0_48ck1020 FIND v(dout0_48) AT=515.025n

.meas tran vdout0_49ck1020 FIND v(dout0_49) AT=515.025n

.meas tran vdout0_50ck1020 FIND v(dout0_50) AT=515.025n

.meas tran vdout0_51ck1020 FIND v(dout0_51) AT=515.025n

.meas tran vdout0_52ck1020 FIND v(dout0_52) AT=515.025n

.meas tran vdout0_53ck1020 FIND v(dout0_53) AT=515.025n

.meas tran vdout0_54ck1020 FIND v(dout0_54) AT=515.025n

.meas tran vdout0_55ck1020 FIND v(dout0_55) AT=515.025n

.meas tran vdout0_56ck1020 FIND v(dout0_56) AT=515.025n

.meas tran vdout0_57ck1020 FIND v(dout0_57) AT=515.025n

.meas tran vdout0_58ck1020 FIND v(dout0_58) AT=515.025n

.meas tran vdout0_59ck1020 FIND v(dout0_59) AT=515.025n

.meas tran vdout0_60ck1020 FIND v(dout0_60) AT=515.025n

.meas tran vdout0_61ck1020 FIND v(dout0_61) AT=515.025n

.meas tran vdout0_62ck1020 FIND v(dout0_62) AT=515.025n

.meas tran vdout0_63ck1020 FIND v(dout0_63) AT=515.025n

.meas tran vdout0_64ck1020 FIND v(dout0_64) AT=515.025n

.meas tran vdout0_65ck1020 FIND v(dout0_65) AT=515.025n

.meas tran vdout0_66ck1020 FIND v(dout0_66) AT=515.025n

.meas tran vdout0_67ck1020 FIND v(dout0_67) AT=515.025n

.meas tran vdout0_68ck1020 FIND v(dout0_68) AT=515.025n

.meas tran vdout0_69ck1020 FIND v(dout0_69) AT=515.025n

.meas tran vdout0_70ck1020 FIND v(dout0_70) AT=515.025n

.meas tran vdout0_71ck1020 FIND v(dout0_71) AT=515.025n

.meas tran vdout0_72ck1020 FIND v(dout0_72) AT=515.025n

.meas tran vdout0_73ck1020 FIND v(dout0_73) AT=515.025n

.meas tran vdout0_74ck1020 FIND v(dout0_74) AT=515.025n

.meas tran vdout0_75ck1020 FIND v(dout0_75) AT=515.025n

.meas tran vdout0_76ck1020 FIND v(dout0_76) AT=515.025n

.meas tran vdout0_77ck1020 FIND v(dout0_77) AT=515.025n

.meas tran vdout0_78ck1020 FIND v(dout0_78) AT=515.025n

.meas tran vdout0_79ck1020 FIND v(dout0_79) AT=515.025n

.meas tran vdout0_80ck1020 FIND v(dout0_80) AT=515.025n

.meas tran vdout0_81ck1020 FIND v(dout0_81) AT=515.025n

.meas tran vdout0_82ck1020 FIND v(dout0_82) AT=515.025n

.meas tran vdout0_83ck1020 FIND v(dout0_83) AT=515.025n

.meas tran vdout0_84ck1020 FIND v(dout0_84) AT=515.025n

.meas tran vdout0_85ck1020 FIND v(dout0_85) AT=515.025n

.meas tran vdout0_86ck1020 FIND v(dout0_86) AT=515.025n

.meas tran vdout0_87ck1020 FIND v(dout0_87) AT=515.025n

.meas tran vdout0_88ck1020 FIND v(dout0_88) AT=515.025n

.meas tran vdout0_89ck1020 FIND v(dout0_89) AT=515.025n

.meas tran vdout0_90ck1020 FIND v(dout0_90) AT=515.025n

.meas tran vdout0_91ck1020 FIND v(dout0_91) AT=515.025n

.meas tran vdout0_92ck1020 FIND v(dout0_92) AT=515.025n

.meas tran vdout0_93ck1020 FIND v(dout0_93) AT=515.025n

.meas tran vdout0_94ck1020 FIND v(dout0_94) AT=515.025n

.meas tran vdout0_95ck1020 FIND v(dout0_95) AT=515.025n

.meas tran vdout0_96ck1020 FIND v(dout0_96) AT=515.025n

.meas tran vdout0_97ck1020 FIND v(dout0_97) AT=515.025n

.meas tran vdout0_98ck1020 FIND v(dout0_98) AT=515.025n

.meas tran vdout0_99ck1020 FIND v(dout0_99) AT=515.025n

.meas tran vdout0_100ck1020 FIND v(dout0_100) AT=515.025n

.meas tran vdout0_101ck1020 FIND v(dout0_101) AT=515.025n

.meas tran vdout0_102ck1020 FIND v(dout0_102) AT=515.025n

.meas tran vdout0_103ck1020 FIND v(dout0_103) AT=515.025n

.meas tran vdout0_104ck1020 FIND v(dout0_104) AT=515.025n

.meas tran vdout0_105ck1020 FIND v(dout0_105) AT=515.025n

.meas tran vdout0_106ck1020 FIND v(dout0_106) AT=515.025n

.meas tran vdout0_107ck1020 FIND v(dout0_107) AT=515.025n

.meas tran vdout0_108ck1020 FIND v(dout0_108) AT=515.025n

.meas tran vdout0_109ck1020 FIND v(dout0_109) AT=515.025n

.meas tran vdout0_110ck1020 FIND v(dout0_110) AT=515.025n

.meas tran vdout0_111ck1020 FIND v(dout0_111) AT=515.025n

.meas tran vdout0_112ck1020 FIND v(dout0_112) AT=515.025n

.meas tran vdout0_113ck1020 FIND v(dout0_113) AT=515.025n

.meas tran vdout0_114ck1020 FIND v(dout0_114) AT=515.025n

.meas tran vdout0_115ck1020 FIND v(dout0_115) AT=515.025n

.meas tran vdout0_116ck1020 FIND v(dout0_116) AT=515.025n

.meas tran vdout0_117ck1020 FIND v(dout0_117) AT=515.025n

.meas tran vdout0_118ck1020 FIND v(dout0_118) AT=515.025n

.meas tran vdout0_119ck1020 FIND v(dout0_119) AT=515.025n

.meas tran vdout0_120ck1020 FIND v(dout0_120) AT=515.025n

.meas tran vdout0_121ck1020 FIND v(dout0_121) AT=515.025n

.meas tran vdout0_122ck1020 FIND v(dout0_122) AT=515.025n

.meas tran vdout0_123ck1020 FIND v(dout0_123) AT=515.025n

.meas tran vdout0_124ck1020 FIND v(dout0_124) AT=515.025n

.meas tran vdout0_125ck1020 FIND v(dout0_125) AT=515.025n

.meas tran vdout0_126ck1020 FIND v(dout0_126) AT=515.025n

.meas tran vdout0_127ck1020 FIND v(dout0_127) AT=515.025n

.meas tran vdout0_128ck1020 FIND v(dout0_128) AT=515.025n

.meas tran vdout0_129ck1020 FIND v(dout0_129) AT=515.025n

.meas tran vdout0_130ck1020 FIND v(dout0_130) AT=515.025n

.meas tran vdout0_131ck1020 FIND v(dout0_131) AT=515.025n

.meas tran vdout0_132ck1020 FIND v(dout0_132) AT=515.025n

.meas tran vdout0_133ck1020 FIND v(dout0_133) AT=515.025n

.meas tran vdout0_134ck1020 FIND v(dout0_134) AT=515.025n

.meas tran vdout0_135ck1020 FIND v(dout0_135) AT=515.025n

.meas tran vdout0_136ck1020 FIND v(dout0_136) AT=515.025n

.meas tran vdout0_137ck1020 FIND v(dout0_137) AT=515.025n

.meas tran vdout0_138ck1020 FIND v(dout0_138) AT=515.025n

.meas tran vdout0_139ck1020 FIND v(dout0_139) AT=515.025n

.meas tran vdout0_140ck1020 FIND v(dout0_140) AT=515.025n

.meas tran vdout0_141ck1020 FIND v(dout0_141) AT=515.025n

.meas tran vdout0_142ck1020 FIND v(dout0_142) AT=515.025n

.meas tran vdout0_143ck1020 FIND v(dout0_143) AT=515.025n

.meas tran vdout0_144ck1020 FIND v(dout0_144) AT=515.025n

.meas tran vdout0_145ck1020 FIND v(dout0_145) AT=515.025n

.meas tran vdout0_146ck1020 FIND v(dout0_146) AT=515.025n

.meas tran vdout0_147ck1020 FIND v(dout0_147) AT=515.025n

.meas tran vdout0_148ck1020 FIND v(dout0_148) AT=515.025n

.meas tran vdout0_149ck1020 FIND v(dout0_149) AT=515.025n

.meas tran vdout0_150ck1020 FIND v(dout0_150) AT=515.025n

.meas tran vdout0_151ck1020 FIND v(dout0_151) AT=515.025n

.meas tran vdout0_152ck1020 FIND v(dout0_152) AT=515.025n

.meas tran vdout0_153ck1020 FIND v(dout0_153) AT=515.025n

.meas tran vdout0_154ck1020 FIND v(dout0_154) AT=515.025n

.meas tran vdout0_155ck1020 FIND v(dout0_155) AT=515.025n

.meas tran vdout0_156ck1020 FIND v(dout0_156) AT=515.025n

.meas tran vdout0_157ck1020 FIND v(dout0_157) AT=515.025n

.meas tran vdout0_158ck1020 FIND v(dout0_158) AT=515.025n

.meas tran vdout0_159ck1020 FIND v(dout0_159) AT=515.025n

.meas tran vdout0_160ck1020 FIND v(dout0_160) AT=515.025n

.meas tran vdout0_161ck1020 FIND v(dout0_161) AT=515.025n

.meas tran vdout0_162ck1020 FIND v(dout0_162) AT=515.025n

.meas tran vdout0_163ck1020 FIND v(dout0_163) AT=515.025n

.meas tran vdout0_164ck1020 FIND v(dout0_164) AT=515.025n

.meas tran vdout0_165ck1020 FIND v(dout0_165) AT=515.025n

.meas tran vdout0_166ck1020 FIND v(dout0_166) AT=515.025n

.meas tran vdout0_167ck1020 FIND v(dout0_167) AT=515.025n

.meas tran vdout0_168ck1020 FIND v(dout0_168) AT=515.025n

.meas tran vdout0_169ck1020 FIND v(dout0_169) AT=515.025n

.meas tran vdout0_170ck1020 FIND v(dout0_170) AT=515.025n

.meas tran vdout0_171ck1020 FIND v(dout0_171) AT=515.025n

.meas tran vdout0_172ck1020 FIND v(dout0_172) AT=515.025n

.meas tran vdout0_173ck1020 FIND v(dout0_173) AT=515.025n

.meas tran vdout0_174ck1020 FIND v(dout0_174) AT=515.025n

.meas tran vdout0_175ck1020 FIND v(dout0_175) AT=515.025n

.meas tran vdout0_176ck1020 FIND v(dout0_176) AT=515.025n

.meas tran vdout0_177ck1020 FIND v(dout0_177) AT=515.025n

.meas tran vdout0_178ck1020 FIND v(dout0_178) AT=515.025n

.meas tran vdout0_179ck1020 FIND v(dout0_179) AT=515.025n

.meas tran vdout0_180ck1020 FIND v(dout0_180) AT=515.025n

.meas tran vdout0_181ck1020 FIND v(dout0_181) AT=515.025n

.meas tran vdout0_182ck1020 FIND v(dout0_182) AT=515.025n

.meas tran vdout0_183ck1020 FIND v(dout0_183) AT=515.025n

.meas tran vdout0_184ck1020 FIND v(dout0_184) AT=515.025n

.meas tran vdout0_185ck1020 FIND v(dout0_185) AT=515.025n

.meas tran vdout0_186ck1020 FIND v(dout0_186) AT=515.025n

.meas tran vdout0_187ck1020 FIND v(dout0_187) AT=515.025n

.meas tran vdout0_188ck1020 FIND v(dout0_188) AT=515.025n

.meas tran vdout0_189ck1020 FIND v(dout0_189) AT=515.025n

.meas tran vdout0_190ck1020 FIND v(dout0_190) AT=515.025n

.meas tran vdout0_191ck1020 FIND v(dout0_191) AT=515.025n

.meas tran vdout0_192ck1020 FIND v(dout0_192) AT=515.025n

.meas tran vdout0_193ck1020 FIND v(dout0_193) AT=515.025n

.meas tran vdout0_194ck1020 FIND v(dout0_194) AT=515.025n

.meas tran vdout0_195ck1020 FIND v(dout0_195) AT=515.025n

.meas tran vdout0_196ck1020 FIND v(dout0_196) AT=515.025n

.meas tran vdout0_197ck1020 FIND v(dout0_197) AT=515.025n

.meas tran vdout0_198ck1020 FIND v(dout0_198) AT=515.025n

.meas tran vdout0_199ck1020 FIND v(dout0_199) AT=515.025n

.meas tran vdout0_200ck1020 FIND v(dout0_200) AT=515.025n

.meas tran vdout0_201ck1020 FIND v(dout0_201) AT=515.025n

.meas tran vdout0_202ck1020 FIND v(dout0_202) AT=515.025n

.meas tran vdout0_203ck1020 FIND v(dout0_203) AT=515.025n

.meas tran vdout0_204ck1020 FIND v(dout0_204) AT=515.025n

.meas tran vdout0_205ck1020 FIND v(dout0_205) AT=515.025n

.meas tran vdout0_206ck1020 FIND v(dout0_206) AT=515.025n

.meas tran vdout0_207ck1020 FIND v(dout0_207) AT=515.025n

.meas tran vdout0_208ck1020 FIND v(dout0_208) AT=515.025n

.meas tran vdout0_209ck1020 FIND v(dout0_209) AT=515.025n

.meas tran vdout0_210ck1020 FIND v(dout0_210) AT=515.025n

.meas tran vdout0_211ck1020 FIND v(dout0_211) AT=515.025n

.meas tran vdout0_212ck1020 FIND v(dout0_212) AT=515.025n

.meas tran vdout0_213ck1020 FIND v(dout0_213) AT=515.025n

.meas tran vdout0_214ck1020 FIND v(dout0_214) AT=515.025n

.meas tran vdout0_215ck1020 FIND v(dout0_215) AT=515.025n

.meas tran vdout0_216ck1020 FIND v(dout0_216) AT=515.025n

.meas tran vdout0_217ck1020 FIND v(dout0_217) AT=515.025n

.meas tran vdout0_218ck1020 FIND v(dout0_218) AT=515.025n

.meas tran vdout0_219ck1020 FIND v(dout0_219) AT=515.025n

.meas tran vdout0_220ck1020 FIND v(dout0_220) AT=515.025n

.meas tran vdout0_221ck1020 FIND v(dout0_221) AT=515.025n

.meas tran vdout0_222ck1020 FIND v(dout0_222) AT=515.025n

.meas tran vdout0_223ck1020 FIND v(dout0_223) AT=515.025n

.meas tran vdout0_224ck1020 FIND v(dout0_224) AT=515.025n

.meas tran vdout0_225ck1020 FIND v(dout0_225) AT=515.025n

.meas tran vdout0_226ck1020 FIND v(dout0_226) AT=515.025n

.meas tran vdout0_227ck1020 FIND v(dout0_227) AT=515.025n

.meas tran vdout0_228ck1020 FIND v(dout0_228) AT=515.025n

.meas tran vdout0_229ck1020 FIND v(dout0_229) AT=515.025n

.meas tran vdout0_230ck1020 FIND v(dout0_230) AT=515.025n

.meas tran vdout0_231ck1020 FIND v(dout0_231) AT=515.025n

.meas tran vdout0_232ck1020 FIND v(dout0_232) AT=515.025n

.meas tran vdout0_233ck1020 FIND v(dout0_233) AT=515.025n

.meas tran vdout0_234ck1020 FIND v(dout0_234) AT=515.025n

.meas tran vdout0_235ck1020 FIND v(dout0_235) AT=515.025n

.meas tran vdout0_236ck1020 FIND v(dout0_236) AT=515.025n

.meas tran vdout0_237ck1020 FIND v(dout0_237) AT=515.025n

.meas tran vdout0_238ck1020 FIND v(dout0_238) AT=515.025n

.meas tran vdout0_239ck1020 FIND v(dout0_239) AT=515.025n

.meas tran vdout0_240ck1020 FIND v(dout0_240) AT=515.025n

.meas tran vdout0_241ck1020 FIND v(dout0_241) AT=515.025n

.meas tran vdout0_242ck1020 FIND v(dout0_242) AT=515.025n

.meas tran vdout0_243ck1020 FIND v(dout0_243) AT=515.025n

.meas tran vdout0_244ck1020 FIND v(dout0_244) AT=515.025n

.meas tran vdout0_245ck1020 FIND v(dout0_245) AT=515.025n

.meas tran vdout0_246ck1020 FIND v(dout0_246) AT=515.025n

.meas tran vdout0_247ck1020 FIND v(dout0_247) AT=515.025n

.meas tran vdout0_248ck1020 FIND v(dout0_248) AT=515.025n

.meas tran vdout0_249ck1020 FIND v(dout0_249) AT=515.025n

.meas tran vdout0_250ck1020 FIND v(dout0_250) AT=515.025n

.meas tran vdout0_251ck1020 FIND v(dout0_251) AT=515.025n

.meas tran vdout0_252ck1020 FIND v(dout0_252) AT=515.025n

.meas tran vdout0_253ck1020 FIND v(dout0_253) AT=515.025n

.meas tran vdout0_254ck1020 FIND v(dout0_254) AT=515.025n

.meas tran vdout0_255ck1020 FIND v(dout0_255) AT=515.025n

.meas tran vdout0_0ck1040 FIND v(dout0_0) AT=525.025n

.meas tran vdout0_1ck1040 FIND v(dout0_1) AT=525.025n

.meas tran vdout0_2ck1040 FIND v(dout0_2) AT=525.025n

.meas tran vdout0_3ck1040 FIND v(dout0_3) AT=525.025n

.meas tran vdout0_4ck1040 FIND v(dout0_4) AT=525.025n

.meas tran vdout0_5ck1040 FIND v(dout0_5) AT=525.025n

.meas tran vdout0_6ck1040 FIND v(dout0_6) AT=525.025n

.meas tran vdout0_7ck1040 FIND v(dout0_7) AT=525.025n

.meas tran vdout0_8ck1040 FIND v(dout0_8) AT=525.025n

.meas tran vdout0_9ck1040 FIND v(dout0_9) AT=525.025n

.meas tran vdout0_10ck1040 FIND v(dout0_10) AT=525.025n

.meas tran vdout0_11ck1040 FIND v(dout0_11) AT=525.025n

.meas tran vdout0_12ck1040 FIND v(dout0_12) AT=525.025n

.meas tran vdout0_13ck1040 FIND v(dout0_13) AT=525.025n

.meas tran vdout0_14ck1040 FIND v(dout0_14) AT=525.025n

.meas tran vdout0_15ck1040 FIND v(dout0_15) AT=525.025n

.meas tran vdout0_16ck1040 FIND v(dout0_16) AT=525.025n

.meas tran vdout0_17ck1040 FIND v(dout0_17) AT=525.025n

.meas tran vdout0_18ck1040 FIND v(dout0_18) AT=525.025n

.meas tran vdout0_19ck1040 FIND v(dout0_19) AT=525.025n

.meas tran vdout0_20ck1040 FIND v(dout0_20) AT=525.025n

.meas tran vdout0_21ck1040 FIND v(dout0_21) AT=525.025n

.meas tran vdout0_22ck1040 FIND v(dout0_22) AT=525.025n

.meas tran vdout0_23ck1040 FIND v(dout0_23) AT=525.025n

.meas tran vdout0_24ck1040 FIND v(dout0_24) AT=525.025n

.meas tran vdout0_25ck1040 FIND v(dout0_25) AT=525.025n

.meas tran vdout0_26ck1040 FIND v(dout0_26) AT=525.025n

.meas tran vdout0_27ck1040 FIND v(dout0_27) AT=525.025n

.meas tran vdout0_28ck1040 FIND v(dout0_28) AT=525.025n

.meas tran vdout0_29ck1040 FIND v(dout0_29) AT=525.025n

.meas tran vdout0_30ck1040 FIND v(dout0_30) AT=525.025n

.meas tran vdout0_31ck1040 FIND v(dout0_31) AT=525.025n

.meas tran vdout0_32ck1040 FIND v(dout0_32) AT=525.025n

.meas tran vdout0_33ck1040 FIND v(dout0_33) AT=525.025n

.meas tran vdout0_34ck1040 FIND v(dout0_34) AT=525.025n

.meas tran vdout0_35ck1040 FIND v(dout0_35) AT=525.025n

.meas tran vdout0_36ck1040 FIND v(dout0_36) AT=525.025n

.meas tran vdout0_37ck1040 FIND v(dout0_37) AT=525.025n

.meas tran vdout0_38ck1040 FIND v(dout0_38) AT=525.025n

.meas tran vdout0_39ck1040 FIND v(dout0_39) AT=525.025n

.meas tran vdout0_40ck1040 FIND v(dout0_40) AT=525.025n

.meas tran vdout0_41ck1040 FIND v(dout0_41) AT=525.025n

.meas tran vdout0_42ck1040 FIND v(dout0_42) AT=525.025n

.meas tran vdout0_43ck1040 FIND v(dout0_43) AT=525.025n

.meas tran vdout0_44ck1040 FIND v(dout0_44) AT=525.025n

.meas tran vdout0_45ck1040 FIND v(dout0_45) AT=525.025n

.meas tran vdout0_46ck1040 FIND v(dout0_46) AT=525.025n

.meas tran vdout0_47ck1040 FIND v(dout0_47) AT=525.025n

.meas tran vdout0_48ck1040 FIND v(dout0_48) AT=525.025n

.meas tran vdout0_49ck1040 FIND v(dout0_49) AT=525.025n

.meas tran vdout0_50ck1040 FIND v(dout0_50) AT=525.025n

.meas tran vdout0_51ck1040 FIND v(dout0_51) AT=525.025n

.meas tran vdout0_52ck1040 FIND v(dout0_52) AT=525.025n

.meas tran vdout0_53ck1040 FIND v(dout0_53) AT=525.025n

.meas tran vdout0_54ck1040 FIND v(dout0_54) AT=525.025n

.meas tran vdout0_55ck1040 FIND v(dout0_55) AT=525.025n

.meas tran vdout0_56ck1040 FIND v(dout0_56) AT=525.025n

.meas tran vdout0_57ck1040 FIND v(dout0_57) AT=525.025n

.meas tran vdout0_58ck1040 FIND v(dout0_58) AT=525.025n

.meas tran vdout0_59ck1040 FIND v(dout0_59) AT=525.025n

.meas tran vdout0_60ck1040 FIND v(dout0_60) AT=525.025n

.meas tran vdout0_61ck1040 FIND v(dout0_61) AT=525.025n

.meas tran vdout0_62ck1040 FIND v(dout0_62) AT=525.025n

.meas tran vdout0_63ck1040 FIND v(dout0_63) AT=525.025n

.meas tran vdout0_64ck1040 FIND v(dout0_64) AT=525.025n

.meas tran vdout0_65ck1040 FIND v(dout0_65) AT=525.025n

.meas tran vdout0_66ck1040 FIND v(dout0_66) AT=525.025n

.meas tran vdout0_67ck1040 FIND v(dout0_67) AT=525.025n

.meas tran vdout0_68ck1040 FIND v(dout0_68) AT=525.025n

.meas tran vdout0_69ck1040 FIND v(dout0_69) AT=525.025n

.meas tran vdout0_70ck1040 FIND v(dout0_70) AT=525.025n

.meas tran vdout0_71ck1040 FIND v(dout0_71) AT=525.025n

.meas tran vdout0_72ck1040 FIND v(dout0_72) AT=525.025n

.meas tran vdout0_73ck1040 FIND v(dout0_73) AT=525.025n

.meas tran vdout0_74ck1040 FIND v(dout0_74) AT=525.025n

.meas tran vdout0_75ck1040 FIND v(dout0_75) AT=525.025n

.meas tran vdout0_76ck1040 FIND v(dout0_76) AT=525.025n

.meas tran vdout0_77ck1040 FIND v(dout0_77) AT=525.025n

.meas tran vdout0_78ck1040 FIND v(dout0_78) AT=525.025n

.meas tran vdout0_79ck1040 FIND v(dout0_79) AT=525.025n

.meas tran vdout0_80ck1040 FIND v(dout0_80) AT=525.025n

.meas tran vdout0_81ck1040 FIND v(dout0_81) AT=525.025n

.meas tran vdout0_82ck1040 FIND v(dout0_82) AT=525.025n

.meas tran vdout0_83ck1040 FIND v(dout0_83) AT=525.025n

.meas tran vdout0_84ck1040 FIND v(dout0_84) AT=525.025n

.meas tran vdout0_85ck1040 FIND v(dout0_85) AT=525.025n

.meas tran vdout0_86ck1040 FIND v(dout0_86) AT=525.025n

.meas tran vdout0_87ck1040 FIND v(dout0_87) AT=525.025n

.meas tran vdout0_88ck1040 FIND v(dout0_88) AT=525.025n

.meas tran vdout0_89ck1040 FIND v(dout0_89) AT=525.025n

.meas tran vdout0_90ck1040 FIND v(dout0_90) AT=525.025n

.meas tran vdout0_91ck1040 FIND v(dout0_91) AT=525.025n

.meas tran vdout0_92ck1040 FIND v(dout0_92) AT=525.025n

.meas tran vdout0_93ck1040 FIND v(dout0_93) AT=525.025n

.meas tran vdout0_94ck1040 FIND v(dout0_94) AT=525.025n

.meas tran vdout0_95ck1040 FIND v(dout0_95) AT=525.025n

.meas tran vdout0_96ck1040 FIND v(dout0_96) AT=525.025n

.meas tran vdout0_97ck1040 FIND v(dout0_97) AT=525.025n

.meas tran vdout0_98ck1040 FIND v(dout0_98) AT=525.025n

.meas tran vdout0_99ck1040 FIND v(dout0_99) AT=525.025n

.meas tran vdout0_100ck1040 FIND v(dout0_100) AT=525.025n

.meas tran vdout0_101ck1040 FIND v(dout0_101) AT=525.025n

.meas tran vdout0_102ck1040 FIND v(dout0_102) AT=525.025n

.meas tran vdout0_103ck1040 FIND v(dout0_103) AT=525.025n

.meas tran vdout0_104ck1040 FIND v(dout0_104) AT=525.025n

.meas tran vdout0_105ck1040 FIND v(dout0_105) AT=525.025n

.meas tran vdout0_106ck1040 FIND v(dout0_106) AT=525.025n

.meas tran vdout0_107ck1040 FIND v(dout0_107) AT=525.025n

.meas tran vdout0_108ck1040 FIND v(dout0_108) AT=525.025n

.meas tran vdout0_109ck1040 FIND v(dout0_109) AT=525.025n

.meas tran vdout0_110ck1040 FIND v(dout0_110) AT=525.025n

.meas tran vdout0_111ck1040 FIND v(dout0_111) AT=525.025n

.meas tran vdout0_112ck1040 FIND v(dout0_112) AT=525.025n

.meas tran vdout0_113ck1040 FIND v(dout0_113) AT=525.025n

.meas tran vdout0_114ck1040 FIND v(dout0_114) AT=525.025n

.meas tran vdout0_115ck1040 FIND v(dout0_115) AT=525.025n

.meas tran vdout0_116ck1040 FIND v(dout0_116) AT=525.025n

.meas tran vdout0_117ck1040 FIND v(dout0_117) AT=525.025n

.meas tran vdout0_118ck1040 FIND v(dout0_118) AT=525.025n

.meas tran vdout0_119ck1040 FIND v(dout0_119) AT=525.025n

.meas tran vdout0_120ck1040 FIND v(dout0_120) AT=525.025n

.meas tran vdout0_121ck1040 FIND v(dout0_121) AT=525.025n

.meas tran vdout0_122ck1040 FIND v(dout0_122) AT=525.025n

.meas tran vdout0_123ck1040 FIND v(dout0_123) AT=525.025n

.meas tran vdout0_124ck1040 FIND v(dout0_124) AT=525.025n

.meas tran vdout0_125ck1040 FIND v(dout0_125) AT=525.025n

.meas tran vdout0_126ck1040 FIND v(dout0_126) AT=525.025n

.meas tran vdout0_127ck1040 FIND v(dout0_127) AT=525.025n

.meas tran vdout0_128ck1040 FIND v(dout0_128) AT=525.025n

.meas tran vdout0_129ck1040 FIND v(dout0_129) AT=525.025n

.meas tran vdout0_130ck1040 FIND v(dout0_130) AT=525.025n

.meas tran vdout0_131ck1040 FIND v(dout0_131) AT=525.025n

.meas tran vdout0_132ck1040 FIND v(dout0_132) AT=525.025n

.meas tran vdout0_133ck1040 FIND v(dout0_133) AT=525.025n

.meas tran vdout0_134ck1040 FIND v(dout0_134) AT=525.025n

.meas tran vdout0_135ck1040 FIND v(dout0_135) AT=525.025n

.meas tran vdout0_136ck1040 FIND v(dout0_136) AT=525.025n

.meas tran vdout0_137ck1040 FIND v(dout0_137) AT=525.025n

.meas tran vdout0_138ck1040 FIND v(dout0_138) AT=525.025n

.meas tran vdout0_139ck1040 FIND v(dout0_139) AT=525.025n

.meas tran vdout0_140ck1040 FIND v(dout0_140) AT=525.025n

.meas tran vdout0_141ck1040 FIND v(dout0_141) AT=525.025n

.meas tran vdout0_142ck1040 FIND v(dout0_142) AT=525.025n

.meas tran vdout0_143ck1040 FIND v(dout0_143) AT=525.025n

.meas tran vdout0_144ck1040 FIND v(dout0_144) AT=525.025n

.meas tran vdout0_145ck1040 FIND v(dout0_145) AT=525.025n

.meas tran vdout0_146ck1040 FIND v(dout0_146) AT=525.025n

.meas tran vdout0_147ck1040 FIND v(dout0_147) AT=525.025n

.meas tran vdout0_148ck1040 FIND v(dout0_148) AT=525.025n

.meas tran vdout0_149ck1040 FIND v(dout0_149) AT=525.025n

.meas tran vdout0_150ck1040 FIND v(dout0_150) AT=525.025n

.meas tran vdout0_151ck1040 FIND v(dout0_151) AT=525.025n

.meas tran vdout0_152ck1040 FIND v(dout0_152) AT=525.025n

.meas tran vdout0_153ck1040 FIND v(dout0_153) AT=525.025n

.meas tran vdout0_154ck1040 FIND v(dout0_154) AT=525.025n

.meas tran vdout0_155ck1040 FIND v(dout0_155) AT=525.025n

.meas tran vdout0_156ck1040 FIND v(dout0_156) AT=525.025n

.meas tran vdout0_157ck1040 FIND v(dout0_157) AT=525.025n

.meas tran vdout0_158ck1040 FIND v(dout0_158) AT=525.025n

.meas tran vdout0_159ck1040 FIND v(dout0_159) AT=525.025n

.meas tran vdout0_160ck1040 FIND v(dout0_160) AT=525.025n

.meas tran vdout0_161ck1040 FIND v(dout0_161) AT=525.025n

.meas tran vdout0_162ck1040 FIND v(dout0_162) AT=525.025n

.meas tran vdout0_163ck1040 FIND v(dout0_163) AT=525.025n

.meas tran vdout0_164ck1040 FIND v(dout0_164) AT=525.025n

.meas tran vdout0_165ck1040 FIND v(dout0_165) AT=525.025n

.meas tran vdout0_166ck1040 FIND v(dout0_166) AT=525.025n

.meas tran vdout0_167ck1040 FIND v(dout0_167) AT=525.025n

.meas tran vdout0_168ck1040 FIND v(dout0_168) AT=525.025n

.meas tran vdout0_169ck1040 FIND v(dout0_169) AT=525.025n

.meas tran vdout0_170ck1040 FIND v(dout0_170) AT=525.025n

.meas tran vdout0_171ck1040 FIND v(dout0_171) AT=525.025n

.meas tran vdout0_172ck1040 FIND v(dout0_172) AT=525.025n

.meas tran vdout0_173ck1040 FIND v(dout0_173) AT=525.025n

.meas tran vdout0_174ck1040 FIND v(dout0_174) AT=525.025n

.meas tran vdout0_175ck1040 FIND v(dout0_175) AT=525.025n

.meas tran vdout0_176ck1040 FIND v(dout0_176) AT=525.025n

.meas tran vdout0_177ck1040 FIND v(dout0_177) AT=525.025n

.meas tran vdout0_178ck1040 FIND v(dout0_178) AT=525.025n

.meas tran vdout0_179ck1040 FIND v(dout0_179) AT=525.025n

.meas tran vdout0_180ck1040 FIND v(dout0_180) AT=525.025n

.meas tran vdout0_181ck1040 FIND v(dout0_181) AT=525.025n

.meas tran vdout0_182ck1040 FIND v(dout0_182) AT=525.025n

.meas tran vdout0_183ck1040 FIND v(dout0_183) AT=525.025n

.meas tran vdout0_184ck1040 FIND v(dout0_184) AT=525.025n

.meas tran vdout0_185ck1040 FIND v(dout0_185) AT=525.025n

.meas tran vdout0_186ck1040 FIND v(dout0_186) AT=525.025n

.meas tran vdout0_187ck1040 FIND v(dout0_187) AT=525.025n

.meas tran vdout0_188ck1040 FIND v(dout0_188) AT=525.025n

.meas tran vdout0_189ck1040 FIND v(dout0_189) AT=525.025n

.meas tran vdout0_190ck1040 FIND v(dout0_190) AT=525.025n

.meas tran vdout0_191ck1040 FIND v(dout0_191) AT=525.025n

.meas tran vdout0_192ck1040 FIND v(dout0_192) AT=525.025n

.meas tran vdout0_193ck1040 FIND v(dout0_193) AT=525.025n

.meas tran vdout0_194ck1040 FIND v(dout0_194) AT=525.025n

.meas tran vdout0_195ck1040 FIND v(dout0_195) AT=525.025n

.meas tran vdout0_196ck1040 FIND v(dout0_196) AT=525.025n

.meas tran vdout0_197ck1040 FIND v(dout0_197) AT=525.025n

.meas tran vdout0_198ck1040 FIND v(dout0_198) AT=525.025n

.meas tran vdout0_199ck1040 FIND v(dout0_199) AT=525.025n

.meas tran vdout0_200ck1040 FIND v(dout0_200) AT=525.025n

.meas tran vdout0_201ck1040 FIND v(dout0_201) AT=525.025n

.meas tran vdout0_202ck1040 FIND v(dout0_202) AT=525.025n

.meas tran vdout0_203ck1040 FIND v(dout0_203) AT=525.025n

.meas tran vdout0_204ck1040 FIND v(dout0_204) AT=525.025n

.meas tran vdout0_205ck1040 FIND v(dout0_205) AT=525.025n

.meas tran vdout0_206ck1040 FIND v(dout0_206) AT=525.025n

.meas tran vdout0_207ck1040 FIND v(dout0_207) AT=525.025n

.meas tran vdout0_208ck1040 FIND v(dout0_208) AT=525.025n

.meas tran vdout0_209ck1040 FIND v(dout0_209) AT=525.025n

.meas tran vdout0_210ck1040 FIND v(dout0_210) AT=525.025n

.meas tran vdout0_211ck1040 FIND v(dout0_211) AT=525.025n

.meas tran vdout0_212ck1040 FIND v(dout0_212) AT=525.025n

.meas tran vdout0_213ck1040 FIND v(dout0_213) AT=525.025n

.meas tran vdout0_214ck1040 FIND v(dout0_214) AT=525.025n

.meas tran vdout0_215ck1040 FIND v(dout0_215) AT=525.025n

.meas tran vdout0_216ck1040 FIND v(dout0_216) AT=525.025n

.meas tran vdout0_217ck1040 FIND v(dout0_217) AT=525.025n

.meas tran vdout0_218ck1040 FIND v(dout0_218) AT=525.025n

.meas tran vdout0_219ck1040 FIND v(dout0_219) AT=525.025n

.meas tran vdout0_220ck1040 FIND v(dout0_220) AT=525.025n

.meas tran vdout0_221ck1040 FIND v(dout0_221) AT=525.025n

.meas tran vdout0_222ck1040 FIND v(dout0_222) AT=525.025n

.meas tran vdout0_223ck1040 FIND v(dout0_223) AT=525.025n

.meas tran vdout0_224ck1040 FIND v(dout0_224) AT=525.025n

.meas tran vdout0_225ck1040 FIND v(dout0_225) AT=525.025n

.meas tran vdout0_226ck1040 FIND v(dout0_226) AT=525.025n

.meas tran vdout0_227ck1040 FIND v(dout0_227) AT=525.025n

.meas tran vdout0_228ck1040 FIND v(dout0_228) AT=525.025n

.meas tran vdout0_229ck1040 FIND v(dout0_229) AT=525.025n

.meas tran vdout0_230ck1040 FIND v(dout0_230) AT=525.025n

.meas tran vdout0_231ck1040 FIND v(dout0_231) AT=525.025n

.meas tran vdout0_232ck1040 FIND v(dout0_232) AT=525.025n

.meas tran vdout0_233ck1040 FIND v(dout0_233) AT=525.025n

.meas tran vdout0_234ck1040 FIND v(dout0_234) AT=525.025n

.meas tran vdout0_235ck1040 FIND v(dout0_235) AT=525.025n

.meas tran vdout0_236ck1040 FIND v(dout0_236) AT=525.025n

.meas tran vdout0_237ck1040 FIND v(dout0_237) AT=525.025n

.meas tran vdout0_238ck1040 FIND v(dout0_238) AT=525.025n

.meas tran vdout0_239ck1040 FIND v(dout0_239) AT=525.025n

.meas tran vdout0_240ck1040 FIND v(dout0_240) AT=525.025n

.meas tran vdout0_241ck1040 FIND v(dout0_241) AT=525.025n

.meas tran vdout0_242ck1040 FIND v(dout0_242) AT=525.025n

.meas tran vdout0_243ck1040 FIND v(dout0_243) AT=525.025n

.meas tran vdout0_244ck1040 FIND v(dout0_244) AT=525.025n

.meas tran vdout0_245ck1040 FIND v(dout0_245) AT=525.025n

.meas tran vdout0_246ck1040 FIND v(dout0_246) AT=525.025n

.meas tran vdout0_247ck1040 FIND v(dout0_247) AT=525.025n

.meas tran vdout0_248ck1040 FIND v(dout0_248) AT=525.025n

.meas tran vdout0_249ck1040 FIND v(dout0_249) AT=525.025n

.meas tran vdout0_250ck1040 FIND v(dout0_250) AT=525.025n

.meas tran vdout0_251ck1040 FIND v(dout0_251) AT=525.025n

.meas tran vdout0_252ck1040 FIND v(dout0_252) AT=525.025n

.meas tran vdout0_253ck1040 FIND v(dout0_253) AT=525.025n

.meas tran vdout0_254ck1040 FIND v(dout0_254) AT=525.025n

.meas tran vdout0_255ck1040 FIND v(dout0_255) AT=525.025n

.meas tran vdout0_0ck1110 FIND v(dout0_0) AT=560.025n

.meas tran vdout0_1ck1110 FIND v(dout0_1) AT=560.025n

.meas tran vdout0_2ck1110 FIND v(dout0_2) AT=560.025n

.meas tran vdout0_3ck1110 FIND v(dout0_3) AT=560.025n

.meas tran vdout0_4ck1110 FIND v(dout0_4) AT=560.025n

.meas tran vdout0_5ck1110 FIND v(dout0_5) AT=560.025n

.meas tran vdout0_6ck1110 FIND v(dout0_6) AT=560.025n

.meas tran vdout0_7ck1110 FIND v(dout0_7) AT=560.025n

.meas tran vdout0_8ck1110 FIND v(dout0_8) AT=560.025n

.meas tran vdout0_9ck1110 FIND v(dout0_9) AT=560.025n

.meas tran vdout0_10ck1110 FIND v(dout0_10) AT=560.025n

.meas tran vdout0_11ck1110 FIND v(dout0_11) AT=560.025n

.meas tran vdout0_12ck1110 FIND v(dout0_12) AT=560.025n

.meas tran vdout0_13ck1110 FIND v(dout0_13) AT=560.025n

.meas tran vdout0_14ck1110 FIND v(dout0_14) AT=560.025n

.meas tran vdout0_15ck1110 FIND v(dout0_15) AT=560.025n

.meas tran vdout0_16ck1110 FIND v(dout0_16) AT=560.025n

.meas tran vdout0_17ck1110 FIND v(dout0_17) AT=560.025n

.meas tran vdout0_18ck1110 FIND v(dout0_18) AT=560.025n

.meas tran vdout0_19ck1110 FIND v(dout0_19) AT=560.025n

.meas tran vdout0_20ck1110 FIND v(dout0_20) AT=560.025n

.meas tran vdout0_21ck1110 FIND v(dout0_21) AT=560.025n

.meas tran vdout0_22ck1110 FIND v(dout0_22) AT=560.025n

.meas tran vdout0_23ck1110 FIND v(dout0_23) AT=560.025n

.meas tran vdout0_24ck1110 FIND v(dout0_24) AT=560.025n

.meas tran vdout0_25ck1110 FIND v(dout0_25) AT=560.025n

.meas tran vdout0_26ck1110 FIND v(dout0_26) AT=560.025n

.meas tran vdout0_27ck1110 FIND v(dout0_27) AT=560.025n

.meas tran vdout0_28ck1110 FIND v(dout0_28) AT=560.025n

.meas tran vdout0_29ck1110 FIND v(dout0_29) AT=560.025n

.meas tran vdout0_30ck1110 FIND v(dout0_30) AT=560.025n

.meas tran vdout0_31ck1110 FIND v(dout0_31) AT=560.025n

.meas tran vdout0_32ck1110 FIND v(dout0_32) AT=560.025n

.meas tran vdout0_33ck1110 FIND v(dout0_33) AT=560.025n

.meas tran vdout0_34ck1110 FIND v(dout0_34) AT=560.025n

.meas tran vdout0_35ck1110 FIND v(dout0_35) AT=560.025n

.meas tran vdout0_36ck1110 FIND v(dout0_36) AT=560.025n

.meas tran vdout0_37ck1110 FIND v(dout0_37) AT=560.025n

.meas tran vdout0_38ck1110 FIND v(dout0_38) AT=560.025n

.meas tran vdout0_39ck1110 FIND v(dout0_39) AT=560.025n

.meas tran vdout0_40ck1110 FIND v(dout0_40) AT=560.025n

.meas tran vdout0_41ck1110 FIND v(dout0_41) AT=560.025n

.meas tran vdout0_42ck1110 FIND v(dout0_42) AT=560.025n

.meas tran vdout0_43ck1110 FIND v(dout0_43) AT=560.025n

.meas tran vdout0_44ck1110 FIND v(dout0_44) AT=560.025n

.meas tran vdout0_45ck1110 FIND v(dout0_45) AT=560.025n

.meas tran vdout0_46ck1110 FIND v(dout0_46) AT=560.025n

.meas tran vdout0_47ck1110 FIND v(dout0_47) AT=560.025n

.meas tran vdout0_48ck1110 FIND v(dout0_48) AT=560.025n

.meas tran vdout0_49ck1110 FIND v(dout0_49) AT=560.025n

.meas tran vdout0_50ck1110 FIND v(dout0_50) AT=560.025n

.meas tran vdout0_51ck1110 FIND v(dout0_51) AT=560.025n

.meas tran vdout0_52ck1110 FIND v(dout0_52) AT=560.025n

.meas tran vdout0_53ck1110 FIND v(dout0_53) AT=560.025n

.meas tran vdout0_54ck1110 FIND v(dout0_54) AT=560.025n

.meas tran vdout0_55ck1110 FIND v(dout0_55) AT=560.025n

.meas tran vdout0_56ck1110 FIND v(dout0_56) AT=560.025n

.meas tran vdout0_57ck1110 FIND v(dout0_57) AT=560.025n

.meas tran vdout0_58ck1110 FIND v(dout0_58) AT=560.025n

.meas tran vdout0_59ck1110 FIND v(dout0_59) AT=560.025n

.meas tran vdout0_60ck1110 FIND v(dout0_60) AT=560.025n

.meas tran vdout0_61ck1110 FIND v(dout0_61) AT=560.025n

.meas tran vdout0_62ck1110 FIND v(dout0_62) AT=560.025n

.meas tran vdout0_63ck1110 FIND v(dout0_63) AT=560.025n

.meas tran vdout0_64ck1110 FIND v(dout0_64) AT=560.025n

.meas tran vdout0_65ck1110 FIND v(dout0_65) AT=560.025n

.meas tran vdout0_66ck1110 FIND v(dout0_66) AT=560.025n

.meas tran vdout0_67ck1110 FIND v(dout0_67) AT=560.025n

.meas tran vdout0_68ck1110 FIND v(dout0_68) AT=560.025n

.meas tran vdout0_69ck1110 FIND v(dout0_69) AT=560.025n

.meas tran vdout0_70ck1110 FIND v(dout0_70) AT=560.025n

.meas tran vdout0_71ck1110 FIND v(dout0_71) AT=560.025n

.meas tran vdout0_72ck1110 FIND v(dout0_72) AT=560.025n

.meas tran vdout0_73ck1110 FIND v(dout0_73) AT=560.025n

.meas tran vdout0_74ck1110 FIND v(dout0_74) AT=560.025n

.meas tran vdout0_75ck1110 FIND v(dout0_75) AT=560.025n

.meas tran vdout0_76ck1110 FIND v(dout0_76) AT=560.025n

.meas tran vdout0_77ck1110 FIND v(dout0_77) AT=560.025n

.meas tran vdout0_78ck1110 FIND v(dout0_78) AT=560.025n

.meas tran vdout0_79ck1110 FIND v(dout0_79) AT=560.025n

.meas tran vdout0_80ck1110 FIND v(dout0_80) AT=560.025n

.meas tran vdout0_81ck1110 FIND v(dout0_81) AT=560.025n

.meas tran vdout0_82ck1110 FIND v(dout0_82) AT=560.025n

.meas tran vdout0_83ck1110 FIND v(dout0_83) AT=560.025n

.meas tran vdout0_84ck1110 FIND v(dout0_84) AT=560.025n

.meas tran vdout0_85ck1110 FIND v(dout0_85) AT=560.025n

.meas tran vdout0_86ck1110 FIND v(dout0_86) AT=560.025n

.meas tran vdout0_87ck1110 FIND v(dout0_87) AT=560.025n

.meas tran vdout0_88ck1110 FIND v(dout0_88) AT=560.025n

.meas tran vdout0_89ck1110 FIND v(dout0_89) AT=560.025n

.meas tran vdout0_90ck1110 FIND v(dout0_90) AT=560.025n

.meas tran vdout0_91ck1110 FIND v(dout0_91) AT=560.025n

.meas tran vdout0_92ck1110 FIND v(dout0_92) AT=560.025n

.meas tran vdout0_93ck1110 FIND v(dout0_93) AT=560.025n

.meas tran vdout0_94ck1110 FIND v(dout0_94) AT=560.025n

.meas tran vdout0_95ck1110 FIND v(dout0_95) AT=560.025n

.meas tran vdout0_96ck1110 FIND v(dout0_96) AT=560.025n

.meas tran vdout0_97ck1110 FIND v(dout0_97) AT=560.025n

.meas tran vdout0_98ck1110 FIND v(dout0_98) AT=560.025n

.meas tran vdout0_99ck1110 FIND v(dout0_99) AT=560.025n

.meas tran vdout0_100ck1110 FIND v(dout0_100) AT=560.025n

.meas tran vdout0_101ck1110 FIND v(dout0_101) AT=560.025n

.meas tran vdout0_102ck1110 FIND v(dout0_102) AT=560.025n

.meas tran vdout0_103ck1110 FIND v(dout0_103) AT=560.025n

.meas tran vdout0_104ck1110 FIND v(dout0_104) AT=560.025n

.meas tran vdout0_105ck1110 FIND v(dout0_105) AT=560.025n

.meas tran vdout0_106ck1110 FIND v(dout0_106) AT=560.025n

.meas tran vdout0_107ck1110 FIND v(dout0_107) AT=560.025n

.meas tran vdout0_108ck1110 FIND v(dout0_108) AT=560.025n

.meas tran vdout0_109ck1110 FIND v(dout0_109) AT=560.025n

.meas tran vdout0_110ck1110 FIND v(dout0_110) AT=560.025n

.meas tran vdout0_111ck1110 FIND v(dout0_111) AT=560.025n

.meas tran vdout0_112ck1110 FIND v(dout0_112) AT=560.025n

.meas tran vdout0_113ck1110 FIND v(dout0_113) AT=560.025n

.meas tran vdout0_114ck1110 FIND v(dout0_114) AT=560.025n

.meas tran vdout0_115ck1110 FIND v(dout0_115) AT=560.025n

.meas tran vdout0_116ck1110 FIND v(dout0_116) AT=560.025n

.meas tran vdout0_117ck1110 FIND v(dout0_117) AT=560.025n

.meas tran vdout0_118ck1110 FIND v(dout0_118) AT=560.025n

.meas tran vdout0_119ck1110 FIND v(dout0_119) AT=560.025n

.meas tran vdout0_120ck1110 FIND v(dout0_120) AT=560.025n

.meas tran vdout0_121ck1110 FIND v(dout0_121) AT=560.025n

.meas tran vdout0_122ck1110 FIND v(dout0_122) AT=560.025n

.meas tran vdout0_123ck1110 FIND v(dout0_123) AT=560.025n

.meas tran vdout0_124ck1110 FIND v(dout0_124) AT=560.025n

.meas tran vdout0_125ck1110 FIND v(dout0_125) AT=560.025n

.meas tran vdout0_126ck1110 FIND v(dout0_126) AT=560.025n

.meas tran vdout0_127ck1110 FIND v(dout0_127) AT=560.025n

.meas tran vdout0_128ck1110 FIND v(dout0_128) AT=560.025n

.meas tran vdout0_129ck1110 FIND v(dout0_129) AT=560.025n

.meas tran vdout0_130ck1110 FIND v(dout0_130) AT=560.025n

.meas tran vdout0_131ck1110 FIND v(dout0_131) AT=560.025n

.meas tran vdout0_132ck1110 FIND v(dout0_132) AT=560.025n

.meas tran vdout0_133ck1110 FIND v(dout0_133) AT=560.025n

.meas tran vdout0_134ck1110 FIND v(dout0_134) AT=560.025n

.meas tran vdout0_135ck1110 FIND v(dout0_135) AT=560.025n

.meas tran vdout0_136ck1110 FIND v(dout0_136) AT=560.025n

.meas tran vdout0_137ck1110 FIND v(dout0_137) AT=560.025n

.meas tran vdout0_138ck1110 FIND v(dout0_138) AT=560.025n

.meas tran vdout0_139ck1110 FIND v(dout0_139) AT=560.025n

.meas tran vdout0_140ck1110 FIND v(dout0_140) AT=560.025n

.meas tran vdout0_141ck1110 FIND v(dout0_141) AT=560.025n

.meas tran vdout0_142ck1110 FIND v(dout0_142) AT=560.025n

.meas tran vdout0_143ck1110 FIND v(dout0_143) AT=560.025n

.meas tran vdout0_144ck1110 FIND v(dout0_144) AT=560.025n

.meas tran vdout0_145ck1110 FIND v(dout0_145) AT=560.025n

.meas tran vdout0_146ck1110 FIND v(dout0_146) AT=560.025n

.meas tran vdout0_147ck1110 FIND v(dout0_147) AT=560.025n

.meas tran vdout0_148ck1110 FIND v(dout0_148) AT=560.025n

.meas tran vdout0_149ck1110 FIND v(dout0_149) AT=560.025n

.meas tran vdout0_150ck1110 FIND v(dout0_150) AT=560.025n

.meas tran vdout0_151ck1110 FIND v(dout0_151) AT=560.025n

.meas tran vdout0_152ck1110 FIND v(dout0_152) AT=560.025n

.meas tran vdout0_153ck1110 FIND v(dout0_153) AT=560.025n

.meas tran vdout0_154ck1110 FIND v(dout0_154) AT=560.025n

.meas tran vdout0_155ck1110 FIND v(dout0_155) AT=560.025n

.meas tran vdout0_156ck1110 FIND v(dout0_156) AT=560.025n

.meas tran vdout0_157ck1110 FIND v(dout0_157) AT=560.025n

.meas tran vdout0_158ck1110 FIND v(dout0_158) AT=560.025n

.meas tran vdout0_159ck1110 FIND v(dout0_159) AT=560.025n

.meas tran vdout0_160ck1110 FIND v(dout0_160) AT=560.025n

.meas tran vdout0_161ck1110 FIND v(dout0_161) AT=560.025n

.meas tran vdout0_162ck1110 FIND v(dout0_162) AT=560.025n

.meas tran vdout0_163ck1110 FIND v(dout0_163) AT=560.025n

.meas tran vdout0_164ck1110 FIND v(dout0_164) AT=560.025n

.meas tran vdout0_165ck1110 FIND v(dout0_165) AT=560.025n

.meas tran vdout0_166ck1110 FIND v(dout0_166) AT=560.025n

.meas tran vdout0_167ck1110 FIND v(dout0_167) AT=560.025n

.meas tran vdout0_168ck1110 FIND v(dout0_168) AT=560.025n

.meas tran vdout0_169ck1110 FIND v(dout0_169) AT=560.025n

.meas tran vdout0_170ck1110 FIND v(dout0_170) AT=560.025n

.meas tran vdout0_171ck1110 FIND v(dout0_171) AT=560.025n

.meas tran vdout0_172ck1110 FIND v(dout0_172) AT=560.025n

.meas tran vdout0_173ck1110 FIND v(dout0_173) AT=560.025n

.meas tran vdout0_174ck1110 FIND v(dout0_174) AT=560.025n

.meas tran vdout0_175ck1110 FIND v(dout0_175) AT=560.025n

.meas tran vdout0_176ck1110 FIND v(dout0_176) AT=560.025n

.meas tran vdout0_177ck1110 FIND v(dout0_177) AT=560.025n

.meas tran vdout0_178ck1110 FIND v(dout0_178) AT=560.025n

.meas tran vdout0_179ck1110 FIND v(dout0_179) AT=560.025n

.meas tran vdout0_180ck1110 FIND v(dout0_180) AT=560.025n

.meas tran vdout0_181ck1110 FIND v(dout0_181) AT=560.025n

.meas tran vdout0_182ck1110 FIND v(dout0_182) AT=560.025n

.meas tran vdout0_183ck1110 FIND v(dout0_183) AT=560.025n

.meas tran vdout0_184ck1110 FIND v(dout0_184) AT=560.025n

.meas tran vdout0_185ck1110 FIND v(dout0_185) AT=560.025n

.meas tran vdout0_186ck1110 FIND v(dout0_186) AT=560.025n

.meas tran vdout0_187ck1110 FIND v(dout0_187) AT=560.025n

.meas tran vdout0_188ck1110 FIND v(dout0_188) AT=560.025n

.meas tran vdout0_189ck1110 FIND v(dout0_189) AT=560.025n

.meas tran vdout0_190ck1110 FIND v(dout0_190) AT=560.025n

.meas tran vdout0_191ck1110 FIND v(dout0_191) AT=560.025n

.meas tran vdout0_192ck1110 FIND v(dout0_192) AT=560.025n

.meas tran vdout0_193ck1110 FIND v(dout0_193) AT=560.025n

.meas tran vdout0_194ck1110 FIND v(dout0_194) AT=560.025n

.meas tran vdout0_195ck1110 FIND v(dout0_195) AT=560.025n

.meas tran vdout0_196ck1110 FIND v(dout0_196) AT=560.025n

.meas tran vdout0_197ck1110 FIND v(dout0_197) AT=560.025n

.meas tran vdout0_198ck1110 FIND v(dout0_198) AT=560.025n

.meas tran vdout0_199ck1110 FIND v(dout0_199) AT=560.025n

.meas tran vdout0_200ck1110 FIND v(dout0_200) AT=560.025n

.meas tran vdout0_201ck1110 FIND v(dout0_201) AT=560.025n

.meas tran vdout0_202ck1110 FIND v(dout0_202) AT=560.025n

.meas tran vdout0_203ck1110 FIND v(dout0_203) AT=560.025n

.meas tran vdout0_204ck1110 FIND v(dout0_204) AT=560.025n

.meas tran vdout0_205ck1110 FIND v(dout0_205) AT=560.025n

.meas tran vdout0_206ck1110 FIND v(dout0_206) AT=560.025n

.meas tran vdout0_207ck1110 FIND v(dout0_207) AT=560.025n

.meas tran vdout0_208ck1110 FIND v(dout0_208) AT=560.025n

.meas tran vdout0_209ck1110 FIND v(dout0_209) AT=560.025n

.meas tran vdout0_210ck1110 FIND v(dout0_210) AT=560.025n

.meas tran vdout0_211ck1110 FIND v(dout0_211) AT=560.025n

.meas tran vdout0_212ck1110 FIND v(dout0_212) AT=560.025n

.meas tran vdout0_213ck1110 FIND v(dout0_213) AT=560.025n

.meas tran vdout0_214ck1110 FIND v(dout0_214) AT=560.025n

.meas tran vdout0_215ck1110 FIND v(dout0_215) AT=560.025n

.meas tran vdout0_216ck1110 FIND v(dout0_216) AT=560.025n

.meas tran vdout0_217ck1110 FIND v(dout0_217) AT=560.025n

.meas tran vdout0_218ck1110 FIND v(dout0_218) AT=560.025n

.meas tran vdout0_219ck1110 FIND v(dout0_219) AT=560.025n

.meas tran vdout0_220ck1110 FIND v(dout0_220) AT=560.025n

.meas tran vdout0_221ck1110 FIND v(dout0_221) AT=560.025n

.meas tran vdout0_222ck1110 FIND v(dout0_222) AT=560.025n

.meas tran vdout0_223ck1110 FIND v(dout0_223) AT=560.025n

.meas tran vdout0_224ck1110 FIND v(dout0_224) AT=560.025n

.meas tran vdout0_225ck1110 FIND v(dout0_225) AT=560.025n

.meas tran vdout0_226ck1110 FIND v(dout0_226) AT=560.025n

.meas tran vdout0_227ck1110 FIND v(dout0_227) AT=560.025n

.meas tran vdout0_228ck1110 FIND v(dout0_228) AT=560.025n

.meas tran vdout0_229ck1110 FIND v(dout0_229) AT=560.025n

.meas tran vdout0_230ck1110 FIND v(dout0_230) AT=560.025n

.meas tran vdout0_231ck1110 FIND v(dout0_231) AT=560.025n

.meas tran vdout0_232ck1110 FIND v(dout0_232) AT=560.025n

.meas tran vdout0_233ck1110 FIND v(dout0_233) AT=560.025n

.meas tran vdout0_234ck1110 FIND v(dout0_234) AT=560.025n

.meas tran vdout0_235ck1110 FIND v(dout0_235) AT=560.025n

.meas tran vdout0_236ck1110 FIND v(dout0_236) AT=560.025n

.meas tran vdout0_237ck1110 FIND v(dout0_237) AT=560.025n

.meas tran vdout0_238ck1110 FIND v(dout0_238) AT=560.025n

.meas tran vdout0_239ck1110 FIND v(dout0_239) AT=560.025n

.meas tran vdout0_240ck1110 FIND v(dout0_240) AT=560.025n

.meas tran vdout0_241ck1110 FIND v(dout0_241) AT=560.025n

.meas tran vdout0_242ck1110 FIND v(dout0_242) AT=560.025n

.meas tran vdout0_243ck1110 FIND v(dout0_243) AT=560.025n

.meas tran vdout0_244ck1110 FIND v(dout0_244) AT=560.025n

.meas tran vdout0_245ck1110 FIND v(dout0_245) AT=560.025n

.meas tran vdout0_246ck1110 FIND v(dout0_246) AT=560.025n

.meas tran vdout0_247ck1110 FIND v(dout0_247) AT=560.025n

.meas tran vdout0_248ck1110 FIND v(dout0_248) AT=560.025n

.meas tran vdout0_249ck1110 FIND v(dout0_249) AT=560.025n

.meas tran vdout0_250ck1110 FIND v(dout0_250) AT=560.025n

.meas tran vdout0_251ck1110 FIND v(dout0_251) AT=560.025n

.meas tran vdout0_252ck1110 FIND v(dout0_252) AT=560.025n

.meas tran vdout0_253ck1110 FIND v(dout0_253) AT=560.025n

.meas tran vdout0_254ck1110 FIND v(dout0_254) AT=560.025n

.meas tran vdout0_255ck1110 FIND v(dout0_255) AT=560.025n

.meas tran vdout0_0ck1130 FIND v(dout0_0) AT=570.025n

.meas tran vdout0_1ck1130 FIND v(dout0_1) AT=570.025n

.meas tran vdout0_2ck1130 FIND v(dout0_2) AT=570.025n

.meas tran vdout0_3ck1130 FIND v(dout0_3) AT=570.025n

.meas tran vdout0_4ck1130 FIND v(dout0_4) AT=570.025n

.meas tran vdout0_5ck1130 FIND v(dout0_5) AT=570.025n

.meas tran vdout0_6ck1130 FIND v(dout0_6) AT=570.025n

.meas tran vdout0_7ck1130 FIND v(dout0_7) AT=570.025n

.meas tran vdout0_8ck1130 FIND v(dout0_8) AT=570.025n

.meas tran vdout0_9ck1130 FIND v(dout0_9) AT=570.025n

.meas tran vdout0_10ck1130 FIND v(dout0_10) AT=570.025n

.meas tran vdout0_11ck1130 FIND v(dout0_11) AT=570.025n

.meas tran vdout0_12ck1130 FIND v(dout0_12) AT=570.025n

.meas tran vdout0_13ck1130 FIND v(dout0_13) AT=570.025n

.meas tran vdout0_14ck1130 FIND v(dout0_14) AT=570.025n

.meas tran vdout0_15ck1130 FIND v(dout0_15) AT=570.025n

.meas tran vdout0_16ck1130 FIND v(dout0_16) AT=570.025n

.meas tran vdout0_17ck1130 FIND v(dout0_17) AT=570.025n

.meas tran vdout0_18ck1130 FIND v(dout0_18) AT=570.025n

.meas tran vdout0_19ck1130 FIND v(dout0_19) AT=570.025n

.meas tran vdout0_20ck1130 FIND v(dout0_20) AT=570.025n

.meas tran vdout0_21ck1130 FIND v(dout0_21) AT=570.025n

.meas tran vdout0_22ck1130 FIND v(dout0_22) AT=570.025n

.meas tran vdout0_23ck1130 FIND v(dout0_23) AT=570.025n

.meas tran vdout0_24ck1130 FIND v(dout0_24) AT=570.025n

.meas tran vdout0_25ck1130 FIND v(dout0_25) AT=570.025n

.meas tran vdout0_26ck1130 FIND v(dout0_26) AT=570.025n

.meas tran vdout0_27ck1130 FIND v(dout0_27) AT=570.025n

.meas tran vdout0_28ck1130 FIND v(dout0_28) AT=570.025n

.meas tran vdout0_29ck1130 FIND v(dout0_29) AT=570.025n

.meas tran vdout0_30ck1130 FIND v(dout0_30) AT=570.025n

.meas tran vdout0_31ck1130 FIND v(dout0_31) AT=570.025n

.meas tran vdout0_32ck1130 FIND v(dout0_32) AT=570.025n

.meas tran vdout0_33ck1130 FIND v(dout0_33) AT=570.025n

.meas tran vdout0_34ck1130 FIND v(dout0_34) AT=570.025n

.meas tran vdout0_35ck1130 FIND v(dout0_35) AT=570.025n

.meas tran vdout0_36ck1130 FIND v(dout0_36) AT=570.025n

.meas tran vdout0_37ck1130 FIND v(dout0_37) AT=570.025n

.meas tran vdout0_38ck1130 FIND v(dout0_38) AT=570.025n

.meas tran vdout0_39ck1130 FIND v(dout0_39) AT=570.025n

.meas tran vdout0_40ck1130 FIND v(dout0_40) AT=570.025n

.meas tran vdout0_41ck1130 FIND v(dout0_41) AT=570.025n

.meas tran vdout0_42ck1130 FIND v(dout0_42) AT=570.025n

.meas tran vdout0_43ck1130 FIND v(dout0_43) AT=570.025n

.meas tran vdout0_44ck1130 FIND v(dout0_44) AT=570.025n

.meas tran vdout0_45ck1130 FIND v(dout0_45) AT=570.025n

.meas tran vdout0_46ck1130 FIND v(dout0_46) AT=570.025n

.meas tran vdout0_47ck1130 FIND v(dout0_47) AT=570.025n

.meas tran vdout0_48ck1130 FIND v(dout0_48) AT=570.025n

.meas tran vdout0_49ck1130 FIND v(dout0_49) AT=570.025n

.meas tran vdout0_50ck1130 FIND v(dout0_50) AT=570.025n

.meas tran vdout0_51ck1130 FIND v(dout0_51) AT=570.025n

.meas tran vdout0_52ck1130 FIND v(dout0_52) AT=570.025n

.meas tran vdout0_53ck1130 FIND v(dout0_53) AT=570.025n

.meas tran vdout0_54ck1130 FIND v(dout0_54) AT=570.025n

.meas tran vdout0_55ck1130 FIND v(dout0_55) AT=570.025n

.meas tran vdout0_56ck1130 FIND v(dout0_56) AT=570.025n

.meas tran vdout0_57ck1130 FIND v(dout0_57) AT=570.025n

.meas tran vdout0_58ck1130 FIND v(dout0_58) AT=570.025n

.meas tran vdout0_59ck1130 FIND v(dout0_59) AT=570.025n

.meas tran vdout0_60ck1130 FIND v(dout0_60) AT=570.025n

.meas tran vdout0_61ck1130 FIND v(dout0_61) AT=570.025n

.meas tran vdout0_62ck1130 FIND v(dout0_62) AT=570.025n

.meas tran vdout0_63ck1130 FIND v(dout0_63) AT=570.025n

.meas tran vdout0_64ck1130 FIND v(dout0_64) AT=570.025n

.meas tran vdout0_65ck1130 FIND v(dout0_65) AT=570.025n

.meas tran vdout0_66ck1130 FIND v(dout0_66) AT=570.025n

.meas tran vdout0_67ck1130 FIND v(dout0_67) AT=570.025n

.meas tran vdout0_68ck1130 FIND v(dout0_68) AT=570.025n

.meas tran vdout0_69ck1130 FIND v(dout0_69) AT=570.025n

.meas tran vdout0_70ck1130 FIND v(dout0_70) AT=570.025n

.meas tran vdout0_71ck1130 FIND v(dout0_71) AT=570.025n

.meas tran vdout0_72ck1130 FIND v(dout0_72) AT=570.025n

.meas tran vdout0_73ck1130 FIND v(dout0_73) AT=570.025n

.meas tran vdout0_74ck1130 FIND v(dout0_74) AT=570.025n

.meas tran vdout0_75ck1130 FIND v(dout0_75) AT=570.025n

.meas tran vdout0_76ck1130 FIND v(dout0_76) AT=570.025n

.meas tran vdout0_77ck1130 FIND v(dout0_77) AT=570.025n

.meas tran vdout0_78ck1130 FIND v(dout0_78) AT=570.025n

.meas tran vdout0_79ck1130 FIND v(dout0_79) AT=570.025n

.meas tran vdout0_80ck1130 FIND v(dout0_80) AT=570.025n

.meas tran vdout0_81ck1130 FIND v(dout0_81) AT=570.025n

.meas tran vdout0_82ck1130 FIND v(dout0_82) AT=570.025n

.meas tran vdout0_83ck1130 FIND v(dout0_83) AT=570.025n

.meas tran vdout0_84ck1130 FIND v(dout0_84) AT=570.025n

.meas tran vdout0_85ck1130 FIND v(dout0_85) AT=570.025n

.meas tran vdout0_86ck1130 FIND v(dout0_86) AT=570.025n

.meas tran vdout0_87ck1130 FIND v(dout0_87) AT=570.025n

.meas tran vdout0_88ck1130 FIND v(dout0_88) AT=570.025n

.meas tran vdout0_89ck1130 FIND v(dout0_89) AT=570.025n

.meas tran vdout0_90ck1130 FIND v(dout0_90) AT=570.025n

.meas tran vdout0_91ck1130 FIND v(dout0_91) AT=570.025n

.meas tran vdout0_92ck1130 FIND v(dout0_92) AT=570.025n

.meas tran vdout0_93ck1130 FIND v(dout0_93) AT=570.025n

.meas tran vdout0_94ck1130 FIND v(dout0_94) AT=570.025n

.meas tran vdout0_95ck1130 FIND v(dout0_95) AT=570.025n

.meas tran vdout0_96ck1130 FIND v(dout0_96) AT=570.025n

.meas tran vdout0_97ck1130 FIND v(dout0_97) AT=570.025n

.meas tran vdout0_98ck1130 FIND v(dout0_98) AT=570.025n

.meas tran vdout0_99ck1130 FIND v(dout0_99) AT=570.025n

.meas tran vdout0_100ck1130 FIND v(dout0_100) AT=570.025n

.meas tran vdout0_101ck1130 FIND v(dout0_101) AT=570.025n

.meas tran vdout0_102ck1130 FIND v(dout0_102) AT=570.025n

.meas tran vdout0_103ck1130 FIND v(dout0_103) AT=570.025n

.meas tran vdout0_104ck1130 FIND v(dout0_104) AT=570.025n

.meas tran vdout0_105ck1130 FIND v(dout0_105) AT=570.025n

.meas tran vdout0_106ck1130 FIND v(dout0_106) AT=570.025n

.meas tran vdout0_107ck1130 FIND v(dout0_107) AT=570.025n

.meas tran vdout0_108ck1130 FIND v(dout0_108) AT=570.025n

.meas tran vdout0_109ck1130 FIND v(dout0_109) AT=570.025n

.meas tran vdout0_110ck1130 FIND v(dout0_110) AT=570.025n

.meas tran vdout0_111ck1130 FIND v(dout0_111) AT=570.025n

.meas tran vdout0_112ck1130 FIND v(dout0_112) AT=570.025n

.meas tran vdout0_113ck1130 FIND v(dout0_113) AT=570.025n

.meas tran vdout0_114ck1130 FIND v(dout0_114) AT=570.025n

.meas tran vdout0_115ck1130 FIND v(dout0_115) AT=570.025n

.meas tran vdout0_116ck1130 FIND v(dout0_116) AT=570.025n

.meas tran vdout0_117ck1130 FIND v(dout0_117) AT=570.025n

.meas tran vdout0_118ck1130 FIND v(dout0_118) AT=570.025n

.meas tran vdout0_119ck1130 FIND v(dout0_119) AT=570.025n

.meas tran vdout0_120ck1130 FIND v(dout0_120) AT=570.025n

.meas tran vdout0_121ck1130 FIND v(dout0_121) AT=570.025n

.meas tran vdout0_122ck1130 FIND v(dout0_122) AT=570.025n

.meas tran vdout0_123ck1130 FIND v(dout0_123) AT=570.025n

.meas tran vdout0_124ck1130 FIND v(dout0_124) AT=570.025n

.meas tran vdout0_125ck1130 FIND v(dout0_125) AT=570.025n

.meas tran vdout0_126ck1130 FIND v(dout0_126) AT=570.025n

.meas tran vdout0_127ck1130 FIND v(dout0_127) AT=570.025n

.meas tran vdout0_128ck1130 FIND v(dout0_128) AT=570.025n

.meas tran vdout0_129ck1130 FIND v(dout0_129) AT=570.025n

.meas tran vdout0_130ck1130 FIND v(dout0_130) AT=570.025n

.meas tran vdout0_131ck1130 FIND v(dout0_131) AT=570.025n

.meas tran vdout0_132ck1130 FIND v(dout0_132) AT=570.025n

.meas tran vdout0_133ck1130 FIND v(dout0_133) AT=570.025n

.meas tran vdout0_134ck1130 FIND v(dout0_134) AT=570.025n

.meas tran vdout0_135ck1130 FIND v(dout0_135) AT=570.025n

.meas tran vdout0_136ck1130 FIND v(dout0_136) AT=570.025n

.meas tran vdout0_137ck1130 FIND v(dout0_137) AT=570.025n

.meas tran vdout0_138ck1130 FIND v(dout0_138) AT=570.025n

.meas tran vdout0_139ck1130 FIND v(dout0_139) AT=570.025n

.meas tran vdout0_140ck1130 FIND v(dout0_140) AT=570.025n

.meas tran vdout0_141ck1130 FIND v(dout0_141) AT=570.025n

.meas tran vdout0_142ck1130 FIND v(dout0_142) AT=570.025n

.meas tran vdout0_143ck1130 FIND v(dout0_143) AT=570.025n

.meas tran vdout0_144ck1130 FIND v(dout0_144) AT=570.025n

.meas tran vdout0_145ck1130 FIND v(dout0_145) AT=570.025n

.meas tran vdout0_146ck1130 FIND v(dout0_146) AT=570.025n

.meas tran vdout0_147ck1130 FIND v(dout0_147) AT=570.025n

.meas tran vdout0_148ck1130 FIND v(dout0_148) AT=570.025n

.meas tran vdout0_149ck1130 FIND v(dout0_149) AT=570.025n

.meas tran vdout0_150ck1130 FIND v(dout0_150) AT=570.025n

.meas tran vdout0_151ck1130 FIND v(dout0_151) AT=570.025n

.meas tran vdout0_152ck1130 FIND v(dout0_152) AT=570.025n

.meas tran vdout0_153ck1130 FIND v(dout0_153) AT=570.025n

.meas tran vdout0_154ck1130 FIND v(dout0_154) AT=570.025n

.meas tran vdout0_155ck1130 FIND v(dout0_155) AT=570.025n

.meas tran vdout0_156ck1130 FIND v(dout0_156) AT=570.025n

.meas tran vdout0_157ck1130 FIND v(dout0_157) AT=570.025n

.meas tran vdout0_158ck1130 FIND v(dout0_158) AT=570.025n

.meas tran vdout0_159ck1130 FIND v(dout0_159) AT=570.025n

.meas tran vdout0_160ck1130 FIND v(dout0_160) AT=570.025n

.meas tran vdout0_161ck1130 FIND v(dout0_161) AT=570.025n

.meas tran vdout0_162ck1130 FIND v(dout0_162) AT=570.025n

.meas tran vdout0_163ck1130 FIND v(dout0_163) AT=570.025n

.meas tran vdout0_164ck1130 FIND v(dout0_164) AT=570.025n

.meas tran vdout0_165ck1130 FIND v(dout0_165) AT=570.025n

.meas tran vdout0_166ck1130 FIND v(dout0_166) AT=570.025n

.meas tran vdout0_167ck1130 FIND v(dout0_167) AT=570.025n

.meas tran vdout0_168ck1130 FIND v(dout0_168) AT=570.025n

.meas tran vdout0_169ck1130 FIND v(dout0_169) AT=570.025n

.meas tran vdout0_170ck1130 FIND v(dout0_170) AT=570.025n

.meas tran vdout0_171ck1130 FIND v(dout0_171) AT=570.025n

.meas tran vdout0_172ck1130 FIND v(dout0_172) AT=570.025n

.meas tran vdout0_173ck1130 FIND v(dout0_173) AT=570.025n

.meas tran vdout0_174ck1130 FIND v(dout0_174) AT=570.025n

.meas tran vdout0_175ck1130 FIND v(dout0_175) AT=570.025n

.meas tran vdout0_176ck1130 FIND v(dout0_176) AT=570.025n

.meas tran vdout0_177ck1130 FIND v(dout0_177) AT=570.025n

.meas tran vdout0_178ck1130 FIND v(dout0_178) AT=570.025n

.meas tran vdout0_179ck1130 FIND v(dout0_179) AT=570.025n

.meas tran vdout0_180ck1130 FIND v(dout0_180) AT=570.025n

.meas tran vdout0_181ck1130 FIND v(dout0_181) AT=570.025n

.meas tran vdout0_182ck1130 FIND v(dout0_182) AT=570.025n

.meas tran vdout0_183ck1130 FIND v(dout0_183) AT=570.025n

.meas tran vdout0_184ck1130 FIND v(dout0_184) AT=570.025n

.meas tran vdout0_185ck1130 FIND v(dout0_185) AT=570.025n

.meas tran vdout0_186ck1130 FIND v(dout0_186) AT=570.025n

.meas tran vdout0_187ck1130 FIND v(dout0_187) AT=570.025n

.meas tran vdout0_188ck1130 FIND v(dout0_188) AT=570.025n

.meas tran vdout0_189ck1130 FIND v(dout0_189) AT=570.025n

.meas tran vdout0_190ck1130 FIND v(dout0_190) AT=570.025n

.meas tran vdout0_191ck1130 FIND v(dout0_191) AT=570.025n

.meas tran vdout0_192ck1130 FIND v(dout0_192) AT=570.025n

.meas tran vdout0_193ck1130 FIND v(dout0_193) AT=570.025n

.meas tran vdout0_194ck1130 FIND v(dout0_194) AT=570.025n

.meas tran vdout0_195ck1130 FIND v(dout0_195) AT=570.025n

.meas tran vdout0_196ck1130 FIND v(dout0_196) AT=570.025n

.meas tran vdout0_197ck1130 FIND v(dout0_197) AT=570.025n

.meas tran vdout0_198ck1130 FIND v(dout0_198) AT=570.025n

.meas tran vdout0_199ck1130 FIND v(dout0_199) AT=570.025n

.meas tran vdout0_200ck1130 FIND v(dout0_200) AT=570.025n

.meas tran vdout0_201ck1130 FIND v(dout0_201) AT=570.025n

.meas tran vdout0_202ck1130 FIND v(dout0_202) AT=570.025n

.meas tran vdout0_203ck1130 FIND v(dout0_203) AT=570.025n

.meas tran vdout0_204ck1130 FIND v(dout0_204) AT=570.025n

.meas tran vdout0_205ck1130 FIND v(dout0_205) AT=570.025n

.meas tran vdout0_206ck1130 FIND v(dout0_206) AT=570.025n

.meas tran vdout0_207ck1130 FIND v(dout0_207) AT=570.025n

.meas tran vdout0_208ck1130 FIND v(dout0_208) AT=570.025n

.meas tran vdout0_209ck1130 FIND v(dout0_209) AT=570.025n

.meas tran vdout0_210ck1130 FIND v(dout0_210) AT=570.025n

.meas tran vdout0_211ck1130 FIND v(dout0_211) AT=570.025n

.meas tran vdout0_212ck1130 FIND v(dout0_212) AT=570.025n

.meas tran vdout0_213ck1130 FIND v(dout0_213) AT=570.025n

.meas tran vdout0_214ck1130 FIND v(dout0_214) AT=570.025n

.meas tran vdout0_215ck1130 FIND v(dout0_215) AT=570.025n

.meas tran vdout0_216ck1130 FIND v(dout0_216) AT=570.025n

.meas tran vdout0_217ck1130 FIND v(dout0_217) AT=570.025n

.meas tran vdout0_218ck1130 FIND v(dout0_218) AT=570.025n

.meas tran vdout0_219ck1130 FIND v(dout0_219) AT=570.025n

.meas tran vdout0_220ck1130 FIND v(dout0_220) AT=570.025n

.meas tran vdout0_221ck1130 FIND v(dout0_221) AT=570.025n

.meas tran vdout0_222ck1130 FIND v(dout0_222) AT=570.025n

.meas tran vdout0_223ck1130 FIND v(dout0_223) AT=570.025n

.meas tran vdout0_224ck1130 FIND v(dout0_224) AT=570.025n

.meas tran vdout0_225ck1130 FIND v(dout0_225) AT=570.025n

.meas tran vdout0_226ck1130 FIND v(dout0_226) AT=570.025n

.meas tran vdout0_227ck1130 FIND v(dout0_227) AT=570.025n

.meas tran vdout0_228ck1130 FIND v(dout0_228) AT=570.025n

.meas tran vdout0_229ck1130 FIND v(dout0_229) AT=570.025n

.meas tran vdout0_230ck1130 FIND v(dout0_230) AT=570.025n

.meas tran vdout0_231ck1130 FIND v(dout0_231) AT=570.025n

.meas tran vdout0_232ck1130 FIND v(dout0_232) AT=570.025n

.meas tran vdout0_233ck1130 FIND v(dout0_233) AT=570.025n

.meas tran vdout0_234ck1130 FIND v(dout0_234) AT=570.025n

.meas tran vdout0_235ck1130 FIND v(dout0_235) AT=570.025n

.meas tran vdout0_236ck1130 FIND v(dout0_236) AT=570.025n

.meas tran vdout0_237ck1130 FIND v(dout0_237) AT=570.025n

.meas tran vdout0_238ck1130 FIND v(dout0_238) AT=570.025n

.meas tran vdout0_239ck1130 FIND v(dout0_239) AT=570.025n

.meas tran vdout0_240ck1130 FIND v(dout0_240) AT=570.025n

.meas tran vdout0_241ck1130 FIND v(dout0_241) AT=570.025n

.meas tran vdout0_242ck1130 FIND v(dout0_242) AT=570.025n

.meas tran vdout0_243ck1130 FIND v(dout0_243) AT=570.025n

.meas tran vdout0_244ck1130 FIND v(dout0_244) AT=570.025n

.meas tran vdout0_245ck1130 FIND v(dout0_245) AT=570.025n

.meas tran vdout0_246ck1130 FIND v(dout0_246) AT=570.025n

.meas tran vdout0_247ck1130 FIND v(dout0_247) AT=570.025n

.meas tran vdout0_248ck1130 FIND v(dout0_248) AT=570.025n

.meas tran vdout0_249ck1130 FIND v(dout0_249) AT=570.025n

.meas tran vdout0_250ck1130 FIND v(dout0_250) AT=570.025n

.meas tran vdout0_251ck1130 FIND v(dout0_251) AT=570.025n

.meas tran vdout0_252ck1130 FIND v(dout0_252) AT=570.025n

.meas tran vdout0_253ck1130 FIND v(dout0_253) AT=570.025n

.meas tran vdout0_254ck1130 FIND v(dout0_254) AT=570.025n

.meas tran vdout0_255ck1130 FIND v(dout0_255) AT=570.025n

.meas tran vdout0_0ck1160 FIND v(dout0_0) AT=585.025n

.meas tran vdout0_1ck1160 FIND v(dout0_1) AT=585.025n

.meas tran vdout0_2ck1160 FIND v(dout0_2) AT=585.025n

.meas tran vdout0_3ck1160 FIND v(dout0_3) AT=585.025n

.meas tran vdout0_4ck1160 FIND v(dout0_4) AT=585.025n

.meas tran vdout0_5ck1160 FIND v(dout0_5) AT=585.025n

.meas tran vdout0_6ck1160 FIND v(dout0_6) AT=585.025n

.meas tran vdout0_7ck1160 FIND v(dout0_7) AT=585.025n

.meas tran vdout0_8ck1160 FIND v(dout0_8) AT=585.025n

.meas tran vdout0_9ck1160 FIND v(dout0_9) AT=585.025n

.meas tran vdout0_10ck1160 FIND v(dout0_10) AT=585.025n

.meas tran vdout0_11ck1160 FIND v(dout0_11) AT=585.025n

.meas tran vdout0_12ck1160 FIND v(dout0_12) AT=585.025n

.meas tran vdout0_13ck1160 FIND v(dout0_13) AT=585.025n

.meas tran vdout0_14ck1160 FIND v(dout0_14) AT=585.025n

.meas tran vdout0_15ck1160 FIND v(dout0_15) AT=585.025n

.meas tran vdout0_16ck1160 FIND v(dout0_16) AT=585.025n

.meas tran vdout0_17ck1160 FIND v(dout0_17) AT=585.025n

.meas tran vdout0_18ck1160 FIND v(dout0_18) AT=585.025n

.meas tran vdout0_19ck1160 FIND v(dout0_19) AT=585.025n

.meas tran vdout0_20ck1160 FIND v(dout0_20) AT=585.025n

.meas tran vdout0_21ck1160 FIND v(dout0_21) AT=585.025n

.meas tran vdout0_22ck1160 FIND v(dout0_22) AT=585.025n

.meas tran vdout0_23ck1160 FIND v(dout0_23) AT=585.025n

.meas tran vdout0_24ck1160 FIND v(dout0_24) AT=585.025n

.meas tran vdout0_25ck1160 FIND v(dout0_25) AT=585.025n

.meas tran vdout0_26ck1160 FIND v(dout0_26) AT=585.025n

.meas tran vdout0_27ck1160 FIND v(dout0_27) AT=585.025n

.meas tran vdout0_28ck1160 FIND v(dout0_28) AT=585.025n

.meas tran vdout0_29ck1160 FIND v(dout0_29) AT=585.025n

.meas tran vdout0_30ck1160 FIND v(dout0_30) AT=585.025n

.meas tran vdout0_31ck1160 FIND v(dout0_31) AT=585.025n

.meas tran vdout0_32ck1160 FIND v(dout0_32) AT=585.025n

.meas tran vdout0_33ck1160 FIND v(dout0_33) AT=585.025n

.meas tran vdout0_34ck1160 FIND v(dout0_34) AT=585.025n

.meas tran vdout0_35ck1160 FIND v(dout0_35) AT=585.025n

.meas tran vdout0_36ck1160 FIND v(dout0_36) AT=585.025n

.meas tran vdout0_37ck1160 FIND v(dout0_37) AT=585.025n

.meas tran vdout0_38ck1160 FIND v(dout0_38) AT=585.025n

.meas tran vdout0_39ck1160 FIND v(dout0_39) AT=585.025n

.meas tran vdout0_40ck1160 FIND v(dout0_40) AT=585.025n

.meas tran vdout0_41ck1160 FIND v(dout0_41) AT=585.025n

.meas tran vdout0_42ck1160 FIND v(dout0_42) AT=585.025n

.meas tran vdout0_43ck1160 FIND v(dout0_43) AT=585.025n

.meas tran vdout0_44ck1160 FIND v(dout0_44) AT=585.025n

.meas tran vdout0_45ck1160 FIND v(dout0_45) AT=585.025n

.meas tran vdout0_46ck1160 FIND v(dout0_46) AT=585.025n

.meas tran vdout0_47ck1160 FIND v(dout0_47) AT=585.025n

.meas tran vdout0_48ck1160 FIND v(dout0_48) AT=585.025n

.meas tran vdout0_49ck1160 FIND v(dout0_49) AT=585.025n

.meas tran vdout0_50ck1160 FIND v(dout0_50) AT=585.025n

.meas tran vdout0_51ck1160 FIND v(dout0_51) AT=585.025n

.meas tran vdout0_52ck1160 FIND v(dout0_52) AT=585.025n

.meas tran vdout0_53ck1160 FIND v(dout0_53) AT=585.025n

.meas tran vdout0_54ck1160 FIND v(dout0_54) AT=585.025n

.meas tran vdout0_55ck1160 FIND v(dout0_55) AT=585.025n

.meas tran vdout0_56ck1160 FIND v(dout0_56) AT=585.025n

.meas tran vdout0_57ck1160 FIND v(dout0_57) AT=585.025n

.meas tran vdout0_58ck1160 FIND v(dout0_58) AT=585.025n

.meas tran vdout0_59ck1160 FIND v(dout0_59) AT=585.025n

.meas tran vdout0_60ck1160 FIND v(dout0_60) AT=585.025n

.meas tran vdout0_61ck1160 FIND v(dout0_61) AT=585.025n

.meas tran vdout0_62ck1160 FIND v(dout0_62) AT=585.025n

.meas tran vdout0_63ck1160 FIND v(dout0_63) AT=585.025n

.meas tran vdout0_64ck1160 FIND v(dout0_64) AT=585.025n

.meas tran vdout0_65ck1160 FIND v(dout0_65) AT=585.025n

.meas tran vdout0_66ck1160 FIND v(dout0_66) AT=585.025n

.meas tran vdout0_67ck1160 FIND v(dout0_67) AT=585.025n

.meas tran vdout0_68ck1160 FIND v(dout0_68) AT=585.025n

.meas tran vdout0_69ck1160 FIND v(dout0_69) AT=585.025n

.meas tran vdout0_70ck1160 FIND v(dout0_70) AT=585.025n

.meas tran vdout0_71ck1160 FIND v(dout0_71) AT=585.025n

.meas tran vdout0_72ck1160 FIND v(dout0_72) AT=585.025n

.meas tran vdout0_73ck1160 FIND v(dout0_73) AT=585.025n

.meas tran vdout0_74ck1160 FIND v(dout0_74) AT=585.025n

.meas tran vdout0_75ck1160 FIND v(dout0_75) AT=585.025n

.meas tran vdout0_76ck1160 FIND v(dout0_76) AT=585.025n

.meas tran vdout0_77ck1160 FIND v(dout0_77) AT=585.025n

.meas tran vdout0_78ck1160 FIND v(dout0_78) AT=585.025n

.meas tran vdout0_79ck1160 FIND v(dout0_79) AT=585.025n

.meas tran vdout0_80ck1160 FIND v(dout0_80) AT=585.025n

.meas tran vdout0_81ck1160 FIND v(dout0_81) AT=585.025n

.meas tran vdout0_82ck1160 FIND v(dout0_82) AT=585.025n

.meas tran vdout0_83ck1160 FIND v(dout0_83) AT=585.025n

.meas tran vdout0_84ck1160 FIND v(dout0_84) AT=585.025n

.meas tran vdout0_85ck1160 FIND v(dout0_85) AT=585.025n

.meas tran vdout0_86ck1160 FIND v(dout0_86) AT=585.025n

.meas tran vdout0_87ck1160 FIND v(dout0_87) AT=585.025n

.meas tran vdout0_88ck1160 FIND v(dout0_88) AT=585.025n

.meas tran vdout0_89ck1160 FIND v(dout0_89) AT=585.025n

.meas tran vdout0_90ck1160 FIND v(dout0_90) AT=585.025n

.meas tran vdout0_91ck1160 FIND v(dout0_91) AT=585.025n

.meas tran vdout0_92ck1160 FIND v(dout0_92) AT=585.025n

.meas tran vdout0_93ck1160 FIND v(dout0_93) AT=585.025n

.meas tran vdout0_94ck1160 FIND v(dout0_94) AT=585.025n

.meas tran vdout0_95ck1160 FIND v(dout0_95) AT=585.025n

.meas tran vdout0_96ck1160 FIND v(dout0_96) AT=585.025n

.meas tran vdout0_97ck1160 FIND v(dout0_97) AT=585.025n

.meas tran vdout0_98ck1160 FIND v(dout0_98) AT=585.025n

.meas tran vdout0_99ck1160 FIND v(dout0_99) AT=585.025n

.meas tran vdout0_100ck1160 FIND v(dout0_100) AT=585.025n

.meas tran vdout0_101ck1160 FIND v(dout0_101) AT=585.025n

.meas tran vdout0_102ck1160 FIND v(dout0_102) AT=585.025n

.meas tran vdout0_103ck1160 FIND v(dout0_103) AT=585.025n

.meas tran vdout0_104ck1160 FIND v(dout0_104) AT=585.025n

.meas tran vdout0_105ck1160 FIND v(dout0_105) AT=585.025n

.meas tran vdout0_106ck1160 FIND v(dout0_106) AT=585.025n

.meas tran vdout0_107ck1160 FIND v(dout0_107) AT=585.025n

.meas tran vdout0_108ck1160 FIND v(dout0_108) AT=585.025n

.meas tran vdout0_109ck1160 FIND v(dout0_109) AT=585.025n

.meas tran vdout0_110ck1160 FIND v(dout0_110) AT=585.025n

.meas tran vdout0_111ck1160 FIND v(dout0_111) AT=585.025n

.meas tran vdout0_112ck1160 FIND v(dout0_112) AT=585.025n

.meas tran vdout0_113ck1160 FIND v(dout0_113) AT=585.025n

.meas tran vdout0_114ck1160 FIND v(dout0_114) AT=585.025n

.meas tran vdout0_115ck1160 FIND v(dout0_115) AT=585.025n

.meas tran vdout0_116ck1160 FIND v(dout0_116) AT=585.025n

.meas tran vdout0_117ck1160 FIND v(dout0_117) AT=585.025n

.meas tran vdout0_118ck1160 FIND v(dout0_118) AT=585.025n

.meas tran vdout0_119ck1160 FIND v(dout0_119) AT=585.025n

.meas tran vdout0_120ck1160 FIND v(dout0_120) AT=585.025n

.meas tran vdout0_121ck1160 FIND v(dout0_121) AT=585.025n

.meas tran vdout0_122ck1160 FIND v(dout0_122) AT=585.025n

.meas tran vdout0_123ck1160 FIND v(dout0_123) AT=585.025n

.meas tran vdout0_124ck1160 FIND v(dout0_124) AT=585.025n

.meas tran vdout0_125ck1160 FIND v(dout0_125) AT=585.025n

.meas tran vdout0_126ck1160 FIND v(dout0_126) AT=585.025n

.meas tran vdout0_127ck1160 FIND v(dout0_127) AT=585.025n

.meas tran vdout0_128ck1160 FIND v(dout0_128) AT=585.025n

.meas tran vdout0_129ck1160 FIND v(dout0_129) AT=585.025n

.meas tran vdout0_130ck1160 FIND v(dout0_130) AT=585.025n

.meas tran vdout0_131ck1160 FIND v(dout0_131) AT=585.025n

.meas tran vdout0_132ck1160 FIND v(dout0_132) AT=585.025n

.meas tran vdout0_133ck1160 FIND v(dout0_133) AT=585.025n

.meas tran vdout0_134ck1160 FIND v(dout0_134) AT=585.025n

.meas tran vdout0_135ck1160 FIND v(dout0_135) AT=585.025n

.meas tran vdout0_136ck1160 FIND v(dout0_136) AT=585.025n

.meas tran vdout0_137ck1160 FIND v(dout0_137) AT=585.025n

.meas tran vdout0_138ck1160 FIND v(dout0_138) AT=585.025n

.meas tran vdout0_139ck1160 FIND v(dout0_139) AT=585.025n

.meas tran vdout0_140ck1160 FIND v(dout0_140) AT=585.025n

.meas tran vdout0_141ck1160 FIND v(dout0_141) AT=585.025n

.meas tran vdout0_142ck1160 FIND v(dout0_142) AT=585.025n

.meas tran vdout0_143ck1160 FIND v(dout0_143) AT=585.025n

.meas tran vdout0_144ck1160 FIND v(dout0_144) AT=585.025n

.meas tran vdout0_145ck1160 FIND v(dout0_145) AT=585.025n

.meas tran vdout0_146ck1160 FIND v(dout0_146) AT=585.025n

.meas tran vdout0_147ck1160 FIND v(dout0_147) AT=585.025n

.meas tran vdout0_148ck1160 FIND v(dout0_148) AT=585.025n

.meas tran vdout0_149ck1160 FIND v(dout0_149) AT=585.025n

.meas tran vdout0_150ck1160 FIND v(dout0_150) AT=585.025n

.meas tran vdout0_151ck1160 FIND v(dout0_151) AT=585.025n

.meas tran vdout0_152ck1160 FIND v(dout0_152) AT=585.025n

.meas tran vdout0_153ck1160 FIND v(dout0_153) AT=585.025n

.meas tran vdout0_154ck1160 FIND v(dout0_154) AT=585.025n

.meas tran vdout0_155ck1160 FIND v(dout0_155) AT=585.025n

.meas tran vdout0_156ck1160 FIND v(dout0_156) AT=585.025n

.meas tran vdout0_157ck1160 FIND v(dout0_157) AT=585.025n

.meas tran vdout0_158ck1160 FIND v(dout0_158) AT=585.025n

.meas tran vdout0_159ck1160 FIND v(dout0_159) AT=585.025n

.meas tran vdout0_160ck1160 FIND v(dout0_160) AT=585.025n

.meas tran vdout0_161ck1160 FIND v(dout0_161) AT=585.025n

.meas tran vdout0_162ck1160 FIND v(dout0_162) AT=585.025n

.meas tran vdout0_163ck1160 FIND v(dout0_163) AT=585.025n

.meas tran vdout0_164ck1160 FIND v(dout0_164) AT=585.025n

.meas tran vdout0_165ck1160 FIND v(dout0_165) AT=585.025n

.meas tran vdout0_166ck1160 FIND v(dout0_166) AT=585.025n

.meas tran vdout0_167ck1160 FIND v(dout0_167) AT=585.025n

.meas tran vdout0_168ck1160 FIND v(dout0_168) AT=585.025n

.meas tran vdout0_169ck1160 FIND v(dout0_169) AT=585.025n

.meas tran vdout0_170ck1160 FIND v(dout0_170) AT=585.025n

.meas tran vdout0_171ck1160 FIND v(dout0_171) AT=585.025n

.meas tran vdout0_172ck1160 FIND v(dout0_172) AT=585.025n

.meas tran vdout0_173ck1160 FIND v(dout0_173) AT=585.025n

.meas tran vdout0_174ck1160 FIND v(dout0_174) AT=585.025n

.meas tran vdout0_175ck1160 FIND v(dout0_175) AT=585.025n

.meas tran vdout0_176ck1160 FIND v(dout0_176) AT=585.025n

.meas tran vdout0_177ck1160 FIND v(dout0_177) AT=585.025n

.meas tran vdout0_178ck1160 FIND v(dout0_178) AT=585.025n

.meas tran vdout0_179ck1160 FIND v(dout0_179) AT=585.025n

.meas tran vdout0_180ck1160 FIND v(dout0_180) AT=585.025n

.meas tran vdout0_181ck1160 FIND v(dout0_181) AT=585.025n

.meas tran vdout0_182ck1160 FIND v(dout0_182) AT=585.025n

.meas tran vdout0_183ck1160 FIND v(dout0_183) AT=585.025n

.meas tran vdout0_184ck1160 FIND v(dout0_184) AT=585.025n

.meas tran vdout0_185ck1160 FIND v(dout0_185) AT=585.025n

.meas tran vdout0_186ck1160 FIND v(dout0_186) AT=585.025n

.meas tran vdout0_187ck1160 FIND v(dout0_187) AT=585.025n

.meas tran vdout0_188ck1160 FIND v(dout0_188) AT=585.025n

.meas tran vdout0_189ck1160 FIND v(dout0_189) AT=585.025n

.meas tran vdout0_190ck1160 FIND v(dout0_190) AT=585.025n

.meas tran vdout0_191ck1160 FIND v(dout0_191) AT=585.025n

.meas tran vdout0_192ck1160 FIND v(dout0_192) AT=585.025n

.meas tran vdout0_193ck1160 FIND v(dout0_193) AT=585.025n

.meas tran vdout0_194ck1160 FIND v(dout0_194) AT=585.025n

.meas tran vdout0_195ck1160 FIND v(dout0_195) AT=585.025n

.meas tran vdout0_196ck1160 FIND v(dout0_196) AT=585.025n

.meas tran vdout0_197ck1160 FIND v(dout0_197) AT=585.025n

.meas tran vdout0_198ck1160 FIND v(dout0_198) AT=585.025n

.meas tran vdout0_199ck1160 FIND v(dout0_199) AT=585.025n

.meas tran vdout0_200ck1160 FIND v(dout0_200) AT=585.025n

.meas tran vdout0_201ck1160 FIND v(dout0_201) AT=585.025n

.meas tran vdout0_202ck1160 FIND v(dout0_202) AT=585.025n

.meas tran vdout0_203ck1160 FIND v(dout0_203) AT=585.025n

.meas tran vdout0_204ck1160 FIND v(dout0_204) AT=585.025n

.meas tran vdout0_205ck1160 FIND v(dout0_205) AT=585.025n

.meas tran vdout0_206ck1160 FIND v(dout0_206) AT=585.025n

.meas tran vdout0_207ck1160 FIND v(dout0_207) AT=585.025n

.meas tran vdout0_208ck1160 FIND v(dout0_208) AT=585.025n

.meas tran vdout0_209ck1160 FIND v(dout0_209) AT=585.025n

.meas tran vdout0_210ck1160 FIND v(dout0_210) AT=585.025n

.meas tran vdout0_211ck1160 FIND v(dout0_211) AT=585.025n

.meas tran vdout0_212ck1160 FIND v(dout0_212) AT=585.025n

.meas tran vdout0_213ck1160 FIND v(dout0_213) AT=585.025n

.meas tran vdout0_214ck1160 FIND v(dout0_214) AT=585.025n

.meas tran vdout0_215ck1160 FIND v(dout0_215) AT=585.025n

.meas tran vdout0_216ck1160 FIND v(dout0_216) AT=585.025n

.meas tran vdout0_217ck1160 FIND v(dout0_217) AT=585.025n

.meas tran vdout0_218ck1160 FIND v(dout0_218) AT=585.025n

.meas tran vdout0_219ck1160 FIND v(dout0_219) AT=585.025n

.meas tran vdout0_220ck1160 FIND v(dout0_220) AT=585.025n

.meas tran vdout0_221ck1160 FIND v(dout0_221) AT=585.025n

.meas tran vdout0_222ck1160 FIND v(dout0_222) AT=585.025n

.meas tran vdout0_223ck1160 FIND v(dout0_223) AT=585.025n

.meas tran vdout0_224ck1160 FIND v(dout0_224) AT=585.025n

.meas tran vdout0_225ck1160 FIND v(dout0_225) AT=585.025n

.meas tran vdout0_226ck1160 FIND v(dout0_226) AT=585.025n

.meas tran vdout0_227ck1160 FIND v(dout0_227) AT=585.025n

.meas tran vdout0_228ck1160 FIND v(dout0_228) AT=585.025n

.meas tran vdout0_229ck1160 FIND v(dout0_229) AT=585.025n

.meas tran vdout0_230ck1160 FIND v(dout0_230) AT=585.025n

.meas tran vdout0_231ck1160 FIND v(dout0_231) AT=585.025n

.meas tran vdout0_232ck1160 FIND v(dout0_232) AT=585.025n

.meas tran vdout0_233ck1160 FIND v(dout0_233) AT=585.025n

.meas tran vdout0_234ck1160 FIND v(dout0_234) AT=585.025n

.meas tran vdout0_235ck1160 FIND v(dout0_235) AT=585.025n

.meas tran vdout0_236ck1160 FIND v(dout0_236) AT=585.025n

.meas tran vdout0_237ck1160 FIND v(dout0_237) AT=585.025n

.meas tran vdout0_238ck1160 FIND v(dout0_238) AT=585.025n

.meas tran vdout0_239ck1160 FIND v(dout0_239) AT=585.025n

.meas tran vdout0_240ck1160 FIND v(dout0_240) AT=585.025n

.meas tran vdout0_241ck1160 FIND v(dout0_241) AT=585.025n

.meas tran vdout0_242ck1160 FIND v(dout0_242) AT=585.025n

.meas tran vdout0_243ck1160 FIND v(dout0_243) AT=585.025n

.meas tran vdout0_244ck1160 FIND v(dout0_244) AT=585.025n

.meas tran vdout0_245ck1160 FIND v(dout0_245) AT=585.025n

.meas tran vdout0_246ck1160 FIND v(dout0_246) AT=585.025n

.meas tran vdout0_247ck1160 FIND v(dout0_247) AT=585.025n

.meas tran vdout0_248ck1160 FIND v(dout0_248) AT=585.025n

.meas tran vdout0_249ck1160 FIND v(dout0_249) AT=585.025n

.meas tran vdout0_250ck1160 FIND v(dout0_250) AT=585.025n

.meas tran vdout0_251ck1160 FIND v(dout0_251) AT=585.025n

.meas tran vdout0_252ck1160 FIND v(dout0_252) AT=585.025n

.meas tran vdout0_253ck1160 FIND v(dout0_253) AT=585.025n

.meas tran vdout0_254ck1160 FIND v(dout0_254) AT=585.025n

.meas tran vdout0_255ck1160 FIND v(dout0_255) AT=585.025n

.meas tran vdout0_0ck1180 FIND v(dout0_0) AT=595.025n

.meas tran vdout0_1ck1180 FIND v(dout0_1) AT=595.025n

.meas tran vdout0_2ck1180 FIND v(dout0_2) AT=595.025n

.meas tran vdout0_3ck1180 FIND v(dout0_3) AT=595.025n

.meas tran vdout0_4ck1180 FIND v(dout0_4) AT=595.025n

.meas tran vdout0_5ck1180 FIND v(dout0_5) AT=595.025n

.meas tran vdout0_6ck1180 FIND v(dout0_6) AT=595.025n

.meas tran vdout0_7ck1180 FIND v(dout0_7) AT=595.025n

.meas tran vdout0_8ck1180 FIND v(dout0_8) AT=595.025n

.meas tran vdout0_9ck1180 FIND v(dout0_9) AT=595.025n

.meas tran vdout0_10ck1180 FIND v(dout0_10) AT=595.025n

.meas tran vdout0_11ck1180 FIND v(dout0_11) AT=595.025n

.meas tran vdout0_12ck1180 FIND v(dout0_12) AT=595.025n

.meas tran vdout0_13ck1180 FIND v(dout0_13) AT=595.025n

.meas tran vdout0_14ck1180 FIND v(dout0_14) AT=595.025n

.meas tran vdout0_15ck1180 FIND v(dout0_15) AT=595.025n

.meas tran vdout0_16ck1180 FIND v(dout0_16) AT=595.025n

.meas tran vdout0_17ck1180 FIND v(dout0_17) AT=595.025n

.meas tran vdout0_18ck1180 FIND v(dout0_18) AT=595.025n

.meas tran vdout0_19ck1180 FIND v(dout0_19) AT=595.025n

.meas tran vdout0_20ck1180 FIND v(dout0_20) AT=595.025n

.meas tran vdout0_21ck1180 FIND v(dout0_21) AT=595.025n

.meas tran vdout0_22ck1180 FIND v(dout0_22) AT=595.025n

.meas tran vdout0_23ck1180 FIND v(dout0_23) AT=595.025n

.meas tran vdout0_24ck1180 FIND v(dout0_24) AT=595.025n

.meas tran vdout0_25ck1180 FIND v(dout0_25) AT=595.025n

.meas tran vdout0_26ck1180 FIND v(dout0_26) AT=595.025n

.meas tran vdout0_27ck1180 FIND v(dout0_27) AT=595.025n

.meas tran vdout0_28ck1180 FIND v(dout0_28) AT=595.025n

.meas tran vdout0_29ck1180 FIND v(dout0_29) AT=595.025n

.meas tran vdout0_30ck1180 FIND v(dout0_30) AT=595.025n

.meas tran vdout0_31ck1180 FIND v(dout0_31) AT=595.025n

.meas tran vdout0_32ck1180 FIND v(dout0_32) AT=595.025n

.meas tran vdout0_33ck1180 FIND v(dout0_33) AT=595.025n

.meas tran vdout0_34ck1180 FIND v(dout0_34) AT=595.025n

.meas tran vdout0_35ck1180 FIND v(dout0_35) AT=595.025n

.meas tran vdout0_36ck1180 FIND v(dout0_36) AT=595.025n

.meas tran vdout0_37ck1180 FIND v(dout0_37) AT=595.025n

.meas tran vdout0_38ck1180 FIND v(dout0_38) AT=595.025n

.meas tran vdout0_39ck1180 FIND v(dout0_39) AT=595.025n

.meas tran vdout0_40ck1180 FIND v(dout0_40) AT=595.025n

.meas tran vdout0_41ck1180 FIND v(dout0_41) AT=595.025n

.meas tran vdout0_42ck1180 FIND v(dout0_42) AT=595.025n

.meas tran vdout0_43ck1180 FIND v(dout0_43) AT=595.025n

.meas tran vdout0_44ck1180 FIND v(dout0_44) AT=595.025n

.meas tran vdout0_45ck1180 FIND v(dout0_45) AT=595.025n

.meas tran vdout0_46ck1180 FIND v(dout0_46) AT=595.025n

.meas tran vdout0_47ck1180 FIND v(dout0_47) AT=595.025n

.meas tran vdout0_48ck1180 FIND v(dout0_48) AT=595.025n

.meas tran vdout0_49ck1180 FIND v(dout0_49) AT=595.025n

.meas tran vdout0_50ck1180 FIND v(dout0_50) AT=595.025n

.meas tran vdout0_51ck1180 FIND v(dout0_51) AT=595.025n

.meas tran vdout0_52ck1180 FIND v(dout0_52) AT=595.025n

.meas tran vdout0_53ck1180 FIND v(dout0_53) AT=595.025n

.meas tran vdout0_54ck1180 FIND v(dout0_54) AT=595.025n

.meas tran vdout0_55ck1180 FIND v(dout0_55) AT=595.025n

.meas tran vdout0_56ck1180 FIND v(dout0_56) AT=595.025n

.meas tran vdout0_57ck1180 FIND v(dout0_57) AT=595.025n

.meas tran vdout0_58ck1180 FIND v(dout0_58) AT=595.025n

.meas tran vdout0_59ck1180 FIND v(dout0_59) AT=595.025n

.meas tran vdout0_60ck1180 FIND v(dout0_60) AT=595.025n

.meas tran vdout0_61ck1180 FIND v(dout0_61) AT=595.025n

.meas tran vdout0_62ck1180 FIND v(dout0_62) AT=595.025n

.meas tran vdout0_63ck1180 FIND v(dout0_63) AT=595.025n

.meas tran vdout0_64ck1180 FIND v(dout0_64) AT=595.025n

.meas tran vdout0_65ck1180 FIND v(dout0_65) AT=595.025n

.meas tran vdout0_66ck1180 FIND v(dout0_66) AT=595.025n

.meas tran vdout0_67ck1180 FIND v(dout0_67) AT=595.025n

.meas tran vdout0_68ck1180 FIND v(dout0_68) AT=595.025n

.meas tran vdout0_69ck1180 FIND v(dout0_69) AT=595.025n

.meas tran vdout0_70ck1180 FIND v(dout0_70) AT=595.025n

.meas tran vdout0_71ck1180 FIND v(dout0_71) AT=595.025n

.meas tran vdout0_72ck1180 FIND v(dout0_72) AT=595.025n

.meas tran vdout0_73ck1180 FIND v(dout0_73) AT=595.025n

.meas tran vdout0_74ck1180 FIND v(dout0_74) AT=595.025n

.meas tran vdout0_75ck1180 FIND v(dout0_75) AT=595.025n

.meas tran vdout0_76ck1180 FIND v(dout0_76) AT=595.025n

.meas tran vdout0_77ck1180 FIND v(dout0_77) AT=595.025n

.meas tran vdout0_78ck1180 FIND v(dout0_78) AT=595.025n

.meas tran vdout0_79ck1180 FIND v(dout0_79) AT=595.025n

.meas tran vdout0_80ck1180 FIND v(dout0_80) AT=595.025n

.meas tran vdout0_81ck1180 FIND v(dout0_81) AT=595.025n

.meas tran vdout0_82ck1180 FIND v(dout0_82) AT=595.025n

.meas tran vdout0_83ck1180 FIND v(dout0_83) AT=595.025n

.meas tran vdout0_84ck1180 FIND v(dout0_84) AT=595.025n

.meas tran vdout0_85ck1180 FIND v(dout0_85) AT=595.025n

.meas tran vdout0_86ck1180 FIND v(dout0_86) AT=595.025n

.meas tran vdout0_87ck1180 FIND v(dout0_87) AT=595.025n

.meas tran vdout0_88ck1180 FIND v(dout0_88) AT=595.025n

.meas tran vdout0_89ck1180 FIND v(dout0_89) AT=595.025n

.meas tran vdout0_90ck1180 FIND v(dout0_90) AT=595.025n

.meas tran vdout0_91ck1180 FIND v(dout0_91) AT=595.025n

.meas tran vdout0_92ck1180 FIND v(dout0_92) AT=595.025n

.meas tran vdout0_93ck1180 FIND v(dout0_93) AT=595.025n

.meas tran vdout0_94ck1180 FIND v(dout0_94) AT=595.025n

.meas tran vdout0_95ck1180 FIND v(dout0_95) AT=595.025n

.meas tran vdout0_96ck1180 FIND v(dout0_96) AT=595.025n

.meas tran vdout0_97ck1180 FIND v(dout0_97) AT=595.025n

.meas tran vdout0_98ck1180 FIND v(dout0_98) AT=595.025n

.meas tran vdout0_99ck1180 FIND v(dout0_99) AT=595.025n

.meas tran vdout0_100ck1180 FIND v(dout0_100) AT=595.025n

.meas tran vdout0_101ck1180 FIND v(dout0_101) AT=595.025n

.meas tran vdout0_102ck1180 FIND v(dout0_102) AT=595.025n

.meas tran vdout0_103ck1180 FIND v(dout0_103) AT=595.025n

.meas tran vdout0_104ck1180 FIND v(dout0_104) AT=595.025n

.meas tran vdout0_105ck1180 FIND v(dout0_105) AT=595.025n

.meas tran vdout0_106ck1180 FIND v(dout0_106) AT=595.025n

.meas tran vdout0_107ck1180 FIND v(dout0_107) AT=595.025n

.meas tran vdout0_108ck1180 FIND v(dout0_108) AT=595.025n

.meas tran vdout0_109ck1180 FIND v(dout0_109) AT=595.025n

.meas tran vdout0_110ck1180 FIND v(dout0_110) AT=595.025n

.meas tran vdout0_111ck1180 FIND v(dout0_111) AT=595.025n

.meas tran vdout0_112ck1180 FIND v(dout0_112) AT=595.025n

.meas tran vdout0_113ck1180 FIND v(dout0_113) AT=595.025n

.meas tran vdout0_114ck1180 FIND v(dout0_114) AT=595.025n

.meas tran vdout0_115ck1180 FIND v(dout0_115) AT=595.025n

.meas tran vdout0_116ck1180 FIND v(dout0_116) AT=595.025n

.meas tran vdout0_117ck1180 FIND v(dout0_117) AT=595.025n

.meas tran vdout0_118ck1180 FIND v(dout0_118) AT=595.025n

.meas tran vdout0_119ck1180 FIND v(dout0_119) AT=595.025n

.meas tran vdout0_120ck1180 FIND v(dout0_120) AT=595.025n

.meas tran vdout0_121ck1180 FIND v(dout0_121) AT=595.025n

.meas tran vdout0_122ck1180 FIND v(dout0_122) AT=595.025n

.meas tran vdout0_123ck1180 FIND v(dout0_123) AT=595.025n

.meas tran vdout0_124ck1180 FIND v(dout0_124) AT=595.025n

.meas tran vdout0_125ck1180 FIND v(dout0_125) AT=595.025n

.meas tran vdout0_126ck1180 FIND v(dout0_126) AT=595.025n

.meas tran vdout0_127ck1180 FIND v(dout0_127) AT=595.025n

.meas tran vdout0_128ck1180 FIND v(dout0_128) AT=595.025n

.meas tran vdout0_129ck1180 FIND v(dout0_129) AT=595.025n

.meas tran vdout0_130ck1180 FIND v(dout0_130) AT=595.025n

.meas tran vdout0_131ck1180 FIND v(dout0_131) AT=595.025n

.meas tran vdout0_132ck1180 FIND v(dout0_132) AT=595.025n

.meas tran vdout0_133ck1180 FIND v(dout0_133) AT=595.025n

.meas tran vdout0_134ck1180 FIND v(dout0_134) AT=595.025n

.meas tran vdout0_135ck1180 FIND v(dout0_135) AT=595.025n

.meas tran vdout0_136ck1180 FIND v(dout0_136) AT=595.025n

.meas tran vdout0_137ck1180 FIND v(dout0_137) AT=595.025n

.meas tran vdout0_138ck1180 FIND v(dout0_138) AT=595.025n

.meas tran vdout0_139ck1180 FIND v(dout0_139) AT=595.025n

.meas tran vdout0_140ck1180 FIND v(dout0_140) AT=595.025n

.meas tran vdout0_141ck1180 FIND v(dout0_141) AT=595.025n

.meas tran vdout0_142ck1180 FIND v(dout0_142) AT=595.025n

.meas tran vdout0_143ck1180 FIND v(dout0_143) AT=595.025n

.meas tran vdout0_144ck1180 FIND v(dout0_144) AT=595.025n

.meas tran vdout0_145ck1180 FIND v(dout0_145) AT=595.025n

.meas tran vdout0_146ck1180 FIND v(dout0_146) AT=595.025n

.meas tran vdout0_147ck1180 FIND v(dout0_147) AT=595.025n

.meas tran vdout0_148ck1180 FIND v(dout0_148) AT=595.025n

.meas tran vdout0_149ck1180 FIND v(dout0_149) AT=595.025n

.meas tran vdout0_150ck1180 FIND v(dout0_150) AT=595.025n

.meas tran vdout0_151ck1180 FIND v(dout0_151) AT=595.025n

.meas tran vdout0_152ck1180 FIND v(dout0_152) AT=595.025n

.meas tran vdout0_153ck1180 FIND v(dout0_153) AT=595.025n

.meas tran vdout0_154ck1180 FIND v(dout0_154) AT=595.025n

.meas tran vdout0_155ck1180 FIND v(dout0_155) AT=595.025n

.meas tran vdout0_156ck1180 FIND v(dout0_156) AT=595.025n

.meas tran vdout0_157ck1180 FIND v(dout0_157) AT=595.025n

.meas tran vdout0_158ck1180 FIND v(dout0_158) AT=595.025n

.meas tran vdout0_159ck1180 FIND v(dout0_159) AT=595.025n

.meas tran vdout0_160ck1180 FIND v(dout0_160) AT=595.025n

.meas tran vdout0_161ck1180 FIND v(dout0_161) AT=595.025n

.meas tran vdout0_162ck1180 FIND v(dout0_162) AT=595.025n

.meas tran vdout0_163ck1180 FIND v(dout0_163) AT=595.025n

.meas tran vdout0_164ck1180 FIND v(dout0_164) AT=595.025n

.meas tran vdout0_165ck1180 FIND v(dout0_165) AT=595.025n

.meas tran vdout0_166ck1180 FIND v(dout0_166) AT=595.025n

.meas tran vdout0_167ck1180 FIND v(dout0_167) AT=595.025n

.meas tran vdout0_168ck1180 FIND v(dout0_168) AT=595.025n

.meas tran vdout0_169ck1180 FIND v(dout0_169) AT=595.025n

.meas tran vdout0_170ck1180 FIND v(dout0_170) AT=595.025n

.meas tran vdout0_171ck1180 FIND v(dout0_171) AT=595.025n

.meas tran vdout0_172ck1180 FIND v(dout0_172) AT=595.025n

.meas tran vdout0_173ck1180 FIND v(dout0_173) AT=595.025n

.meas tran vdout0_174ck1180 FIND v(dout0_174) AT=595.025n

.meas tran vdout0_175ck1180 FIND v(dout0_175) AT=595.025n

.meas tran vdout0_176ck1180 FIND v(dout0_176) AT=595.025n

.meas tran vdout0_177ck1180 FIND v(dout0_177) AT=595.025n

.meas tran vdout0_178ck1180 FIND v(dout0_178) AT=595.025n

.meas tran vdout0_179ck1180 FIND v(dout0_179) AT=595.025n

.meas tran vdout0_180ck1180 FIND v(dout0_180) AT=595.025n

.meas tran vdout0_181ck1180 FIND v(dout0_181) AT=595.025n

.meas tran vdout0_182ck1180 FIND v(dout0_182) AT=595.025n

.meas tran vdout0_183ck1180 FIND v(dout0_183) AT=595.025n

.meas tran vdout0_184ck1180 FIND v(dout0_184) AT=595.025n

.meas tran vdout0_185ck1180 FIND v(dout0_185) AT=595.025n

.meas tran vdout0_186ck1180 FIND v(dout0_186) AT=595.025n

.meas tran vdout0_187ck1180 FIND v(dout0_187) AT=595.025n

.meas tran vdout0_188ck1180 FIND v(dout0_188) AT=595.025n

.meas tran vdout0_189ck1180 FIND v(dout0_189) AT=595.025n

.meas tran vdout0_190ck1180 FIND v(dout0_190) AT=595.025n

.meas tran vdout0_191ck1180 FIND v(dout0_191) AT=595.025n

.meas tran vdout0_192ck1180 FIND v(dout0_192) AT=595.025n

.meas tran vdout0_193ck1180 FIND v(dout0_193) AT=595.025n

.meas tran vdout0_194ck1180 FIND v(dout0_194) AT=595.025n

.meas tran vdout0_195ck1180 FIND v(dout0_195) AT=595.025n

.meas tran vdout0_196ck1180 FIND v(dout0_196) AT=595.025n

.meas tran vdout0_197ck1180 FIND v(dout0_197) AT=595.025n

.meas tran vdout0_198ck1180 FIND v(dout0_198) AT=595.025n

.meas tran vdout0_199ck1180 FIND v(dout0_199) AT=595.025n

.meas tran vdout0_200ck1180 FIND v(dout0_200) AT=595.025n

.meas tran vdout0_201ck1180 FIND v(dout0_201) AT=595.025n

.meas tran vdout0_202ck1180 FIND v(dout0_202) AT=595.025n

.meas tran vdout0_203ck1180 FIND v(dout0_203) AT=595.025n

.meas tran vdout0_204ck1180 FIND v(dout0_204) AT=595.025n

.meas tran vdout0_205ck1180 FIND v(dout0_205) AT=595.025n

.meas tran vdout0_206ck1180 FIND v(dout0_206) AT=595.025n

.meas tran vdout0_207ck1180 FIND v(dout0_207) AT=595.025n

.meas tran vdout0_208ck1180 FIND v(dout0_208) AT=595.025n

.meas tran vdout0_209ck1180 FIND v(dout0_209) AT=595.025n

.meas tran vdout0_210ck1180 FIND v(dout0_210) AT=595.025n

.meas tran vdout0_211ck1180 FIND v(dout0_211) AT=595.025n

.meas tran vdout0_212ck1180 FIND v(dout0_212) AT=595.025n

.meas tran vdout0_213ck1180 FIND v(dout0_213) AT=595.025n

.meas tran vdout0_214ck1180 FIND v(dout0_214) AT=595.025n

.meas tran vdout0_215ck1180 FIND v(dout0_215) AT=595.025n

.meas tran vdout0_216ck1180 FIND v(dout0_216) AT=595.025n

.meas tran vdout0_217ck1180 FIND v(dout0_217) AT=595.025n

.meas tran vdout0_218ck1180 FIND v(dout0_218) AT=595.025n

.meas tran vdout0_219ck1180 FIND v(dout0_219) AT=595.025n

.meas tran vdout0_220ck1180 FIND v(dout0_220) AT=595.025n

.meas tran vdout0_221ck1180 FIND v(dout0_221) AT=595.025n

.meas tran vdout0_222ck1180 FIND v(dout0_222) AT=595.025n

.meas tran vdout0_223ck1180 FIND v(dout0_223) AT=595.025n

.meas tran vdout0_224ck1180 FIND v(dout0_224) AT=595.025n

.meas tran vdout0_225ck1180 FIND v(dout0_225) AT=595.025n

.meas tran vdout0_226ck1180 FIND v(dout0_226) AT=595.025n

.meas tran vdout0_227ck1180 FIND v(dout0_227) AT=595.025n

.meas tran vdout0_228ck1180 FIND v(dout0_228) AT=595.025n

.meas tran vdout0_229ck1180 FIND v(dout0_229) AT=595.025n

.meas tran vdout0_230ck1180 FIND v(dout0_230) AT=595.025n

.meas tran vdout0_231ck1180 FIND v(dout0_231) AT=595.025n

.meas tran vdout0_232ck1180 FIND v(dout0_232) AT=595.025n

.meas tran vdout0_233ck1180 FIND v(dout0_233) AT=595.025n

.meas tran vdout0_234ck1180 FIND v(dout0_234) AT=595.025n

.meas tran vdout0_235ck1180 FIND v(dout0_235) AT=595.025n

.meas tran vdout0_236ck1180 FIND v(dout0_236) AT=595.025n

.meas tran vdout0_237ck1180 FIND v(dout0_237) AT=595.025n

.meas tran vdout0_238ck1180 FIND v(dout0_238) AT=595.025n

.meas tran vdout0_239ck1180 FIND v(dout0_239) AT=595.025n

.meas tran vdout0_240ck1180 FIND v(dout0_240) AT=595.025n

.meas tran vdout0_241ck1180 FIND v(dout0_241) AT=595.025n

.meas tran vdout0_242ck1180 FIND v(dout0_242) AT=595.025n

.meas tran vdout0_243ck1180 FIND v(dout0_243) AT=595.025n

.meas tran vdout0_244ck1180 FIND v(dout0_244) AT=595.025n

.meas tran vdout0_245ck1180 FIND v(dout0_245) AT=595.025n

.meas tran vdout0_246ck1180 FIND v(dout0_246) AT=595.025n

.meas tran vdout0_247ck1180 FIND v(dout0_247) AT=595.025n

.meas tran vdout0_248ck1180 FIND v(dout0_248) AT=595.025n

.meas tran vdout0_249ck1180 FIND v(dout0_249) AT=595.025n

.meas tran vdout0_250ck1180 FIND v(dout0_250) AT=595.025n

.meas tran vdout0_251ck1180 FIND v(dout0_251) AT=595.025n

.meas tran vdout0_252ck1180 FIND v(dout0_252) AT=595.025n

.meas tran vdout0_253ck1180 FIND v(dout0_253) AT=595.025n

.meas tran vdout0_254ck1180 FIND v(dout0_254) AT=595.025n

.meas tran vdout0_255ck1180 FIND v(dout0_255) AT=595.025n

.meas tran vdout0_0ck1190 FIND v(dout0_0) AT=600.025n

.meas tran vdout0_1ck1190 FIND v(dout0_1) AT=600.025n

.meas tran vdout0_2ck1190 FIND v(dout0_2) AT=600.025n

.meas tran vdout0_3ck1190 FIND v(dout0_3) AT=600.025n

.meas tran vdout0_4ck1190 FIND v(dout0_4) AT=600.025n

.meas tran vdout0_5ck1190 FIND v(dout0_5) AT=600.025n

.meas tran vdout0_6ck1190 FIND v(dout0_6) AT=600.025n

.meas tran vdout0_7ck1190 FIND v(dout0_7) AT=600.025n

.meas tran vdout0_8ck1190 FIND v(dout0_8) AT=600.025n

.meas tran vdout0_9ck1190 FIND v(dout0_9) AT=600.025n

.meas tran vdout0_10ck1190 FIND v(dout0_10) AT=600.025n

.meas tran vdout0_11ck1190 FIND v(dout0_11) AT=600.025n

.meas tran vdout0_12ck1190 FIND v(dout0_12) AT=600.025n

.meas tran vdout0_13ck1190 FIND v(dout0_13) AT=600.025n

.meas tran vdout0_14ck1190 FIND v(dout0_14) AT=600.025n

.meas tran vdout0_15ck1190 FIND v(dout0_15) AT=600.025n

.meas tran vdout0_16ck1190 FIND v(dout0_16) AT=600.025n

.meas tran vdout0_17ck1190 FIND v(dout0_17) AT=600.025n

.meas tran vdout0_18ck1190 FIND v(dout0_18) AT=600.025n

.meas tran vdout0_19ck1190 FIND v(dout0_19) AT=600.025n

.meas tran vdout0_20ck1190 FIND v(dout0_20) AT=600.025n

.meas tran vdout0_21ck1190 FIND v(dout0_21) AT=600.025n

.meas tran vdout0_22ck1190 FIND v(dout0_22) AT=600.025n

.meas tran vdout0_23ck1190 FIND v(dout0_23) AT=600.025n

.meas tran vdout0_24ck1190 FIND v(dout0_24) AT=600.025n

.meas tran vdout0_25ck1190 FIND v(dout0_25) AT=600.025n

.meas tran vdout0_26ck1190 FIND v(dout0_26) AT=600.025n

.meas tran vdout0_27ck1190 FIND v(dout0_27) AT=600.025n

.meas tran vdout0_28ck1190 FIND v(dout0_28) AT=600.025n

.meas tran vdout0_29ck1190 FIND v(dout0_29) AT=600.025n

.meas tran vdout0_30ck1190 FIND v(dout0_30) AT=600.025n

.meas tran vdout0_31ck1190 FIND v(dout0_31) AT=600.025n

.meas tran vdout0_32ck1190 FIND v(dout0_32) AT=600.025n

.meas tran vdout0_33ck1190 FIND v(dout0_33) AT=600.025n

.meas tran vdout0_34ck1190 FIND v(dout0_34) AT=600.025n

.meas tran vdout0_35ck1190 FIND v(dout0_35) AT=600.025n

.meas tran vdout0_36ck1190 FIND v(dout0_36) AT=600.025n

.meas tran vdout0_37ck1190 FIND v(dout0_37) AT=600.025n

.meas tran vdout0_38ck1190 FIND v(dout0_38) AT=600.025n

.meas tran vdout0_39ck1190 FIND v(dout0_39) AT=600.025n

.meas tran vdout0_40ck1190 FIND v(dout0_40) AT=600.025n

.meas tran vdout0_41ck1190 FIND v(dout0_41) AT=600.025n

.meas tran vdout0_42ck1190 FIND v(dout0_42) AT=600.025n

.meas tran vdout0_43ck1190 FIND v(dout0_43) AT=600.025n

.meas tran vdout0_44ck1190 FIND v(dout0_44) AT=600.025n

.meas tran vdout0_45ck1190 FIND v(dout0_45) AT=600.025n

.meas tran vdout0_46ck1190 FIND v(dout0_46) AT=600.025n

.meas tran vdout0_47ck1190 FIND v(dout0_47) AT=600.025n

.meas tran vdout0_48ck1190 FIND v(dout0_48) AT=600.025n

.meas tran vdout0_49ck1190 FIND v(dout0_49) AT=600.025n

.meas tran vdout0_50ck1190 FIND v(dout0_50) AT=600.025n

.meas tran vdout0_51ck1190 FIND v(dout0_51) AT=600.025n

.meas tran vdout0_52ck1190 FIND v(dout0_52) AT=600.025n

.meas tran vdout0_53ck1190 FIND v(dout0_53) AT=600.025n

.meas tran vdout0_54ck1190 FIND v(dout0_54) AT=600.025n

.meas tran vdout0_55ck1190 FIND v(dout0_55) AT=600.025n

.meas tran vdout0_56ck1190 FIND v(dout0_56) AT=600.025n

.meas tran vdout0_57ck1190 FIND v(dout0_57) AT=600.025n

.meas tran vdout0_58ck1190 FIND v(dout0_58) AT=600.025n

.meas tran vdout0_59ck1190 FIND v(dout0_59) AT=600.025n

.meas tran vdout0_60ck1190 FIND v(dout0_60) AT=600.025n

.meas tran vdout0_61ck1190 FIND v(dout0_61) AT=600.025n

.meas tran vdout0_62ck1190 FIND v(dout0_62) AT=600.025n

.meas tran vdout0_63ck1190 FIND v(dout0_63) AT=600.025n

.meas tran vdout0_64ck1190 FIND v(dout0_64) AT=600.025n

.meas tran vdout0_65ck1190 FIND v(dout0_65) AT=600.025n

.meas tran vdout0_66ck1190 FIND v(dout0_66) AT=600.025n

.meas tran vdout0_67ck1190 FIND v(dout0_67) AT=600.025n

.meas tran vdout0_68ck1190 FIND v(dout0_68) AT=600.025n

.meas tran vdout0_69ck1190 FIND v(dout0_69) AT=600.025n

.meas tran vdout0_70ck1190 FIND v(dout0_70) AT=600.025n

.meas tran vdout0_71ck1190 FIND v(dout0_71) AT=600.025n

.meas tran vdout0_72ck1190 FIND v(dout0_72) AT=600.025n

.meas tran vdout0_73ck1190 FIND v(dout0_73) AT=600.025n

.meas tran vdout0_74ck1190 FIND v(dout0_74) AT=600.025n

.meas tran vdout0_75ck1190 FIND v(dout0_75) AT=600.025n

.meas tran vdout0_76ck1190 FIND v(dout0_76) AT=600.025n

.meas tran vdout0_77ck1190 FIND v(dout0_77) AT=600.025n

.meas tran vdout0_78ck1190 FIND v(dout0_78) AT=600.025n

.meas tran vdout0_79ck1190 FIND v(dout0_79) AT=600.025n

.meas tran vdout0_80ck1190 FIND v(dout0_80) AT=600.025n

.meas tran vdout0_81ck1190 FIND v(dout0_81) AT=600.025n

.meas tran vdout0_82ck1190 FIND v(dout0_82) AT=600.025n

.meas tran vdout0_83ck1190 FIND v(dout0_83) AT=600.025n

.meas tran vdout0_84ck1190 FIND v(dout0_84) AT=600.025n

.meas tran vdout0_85ck1190 FIND v(dout0_85) AT=600.025n

.meas tran vdout0_86ck1190 FIND v(dout0_86) AT=600.025n

.meas tran vdout0_87ck1190 FIND v(dout0_87) AT=600.025n

.meas tran vdout0_88ck1190 FIND v(dout0_88) AT=600.025n

.meas tran vdout0_89ck1190 FIND v(dout0_89) AT=600.025n

.meas tran vdout0_90ck1190 FIND v(dout0_90) AT=600.025n

.meas tran vdout0_91ck1190 FIND v(dout0_91) AT=600.025n

.meas tran vdout0_92ck1190 FIND v(dout0_92) AT=600.025n

.meas tran vdout0_93ck1190 FIND v(dout0_93) AT=600.025n

.meas tran vdout0_94ck1190 FIND v(dout0_94) AT=600.025n

.meas tran vdout0_95ck1190 FIND v(dout0_95) AT=600.025n

.meas tran vdout0_96ck1190 FIND v(dout0_96) AT=600.025n

.meas tran vdout0_97ck1190 FIND v(dout0_97) AT=600.025n

.meas tran vdout0_98ck1190 FIND v(dout0_98) AT=600.025n

.meas tran vdout0_99ck1190 FIND v(dout0_99) AT=600.025n

.meas tran vdout0_100ck1190 FIND v(dout0_100) AT=600.025n

.meas tran vdout0_101ck1190 FIND v(dout0_101) AT=600.025n

.meas tran vdout0_102ck1190 FIND v(dout0_102) AT=600.025n

.meas tran vdout0_103ck1190 FIND v(dout0_103) AT=600.025n

.meas tran vdout0_104ck1190 FIND v(dout0_104) AT=600.025n

.meas tran vdout0_105ck1190 FIND v(dout0_105) AT=600.025n

.meas tran vdout0_106ck1190 FIND v(dout0_106) AT=600.025n

.meas tran vdout0_107ck1190 FIND v(dout0_107) AT=600.025n

.meas tran vdout0_108ck1190 FIND v(dout0_108) AT=600.025n

.meas tran vdout0_109ck1190 FIND v(dout0_109) AT=600.025n

.meas tran vdout0_110ck1190 FIND v(dout0_110) AT=600.025n

.meas tran vdout0_111ck1190 FIND v(dout0_111) AT=600.025n

.meas tran vdout0_112ck1190 FIND v(dout0_112) AT=600.025n

.meas tran vdout0_113ck1190 FIND v(dout0_113) AT=600.025n

.meas tran vdout0_114ck1190 FIND v(dout0_114) AT=600.025n

.meas tran vdout0_115ck1190 FIND v(dout0_115) AT=600.025n

.meas tran vdout0_116ck1190 FIND v(dout0_116) AT=600.025n

.meas tran vdout0_117ck1190 FIND v(dout0_117) AT=600.025n

.meas tran vdout0_118ck1190 FIND v(dout0_118) AT=600.025n

.meas tran vdout0_119ck1190 FIND v(dout0_119) AT=600.025n

.meas tran vdout0_120ck1190 FIND v(dout0_120) AT=600.025n

.meas tran vdout0_121ck1190 FIND v(dout0_121) AT=600.025n

.meas tran vdout0_122ck1190 FIND v(dout0_122) AT=600.025n

.meas tran vdout0_123ck1190 FIND v(dout0_123) AT=600.025n

.meas tran vdout0_124ck1190 FIND v(dout0_124) AT=600.025n

.meas tran vdout0_125ck1190 FIND v(dout0_125) AT=600.025n

.meas tran vdout0_126ck1190 FIND v(dout0_126) AT=600.025n

.meas tran vdout0_127ck1190 FIND v(dout0_127) AT=600.025n

.meas tran vdout0_128ck1190 FIND v(dout0_128) AT=600.025n

.meas tran vdout0_129ck1190 FIND v(dout0_129) AT=600.025n

.meas tran vdout0_130ck1190 FIND v(dout0_130) AT=600.025n

.meas tran vdout0_131ck1190 FIND v(dout0_131) AT=600.025n

.meas tran vdout0_132ck1190 FIND v(dout0_132) AT=600.025n

.meas tran vdout0_133ck1190 FIND v(dout0_133) AT=600.025n

.meas tran vdout0_134ck1190 FIND v(dout0_134) AT=600.025n

.meas tran vdout0_135ck1190 FIND v(dout0_135) AT=600.025n

.meas tran vdout0_136ck1190 FIND v(dout0_136) AT=600.025n

.meas tran vdout0_137ck1190 FIND v(dout0_137) AT=600.025n

.meas tran vdout0_138ck1190 FIND v(dout0_138) AT=600.025n

.meas tran vdout0_139ck1190 FIND v(dout0_139) AT=600.025n

.meas tran vdout0_140ck1190 FIND v(dout0_140) AT=600.025n

.meas tran vdout0_141ck1190 FIND v(dout0_141) AT=600.025n

.meas tran vdout0_142ck1190 FIND v(dout0_142) AT=600.025n

.meas tran vdout0_143ck1190 FIND v(dout0_143) AT=600.025n

.meas tran vdout0_144ck1190 FIND v(dout0_144) AT=600.025n

.meas tran vdout0_145ck1190 FIND v(dout0_145) AT=600.025n

.meas tran vdout0_146ck1190 FIND v(dout0_146) AT=600.025n

.meas tran vdout0_147ck1190 FIND v(dout0_147) AT=600.025n

.meas tran vdout0_148ck1190 FIND v(dout0_148) AT=600.025n

.meas tran vdout0_149ck1190 FIND v(dout0_149) AT=600.025n

.meas tran vdout0_150ck1190 FIND v(dout0_150) AT=600.025n

.meas tran vdout0_151ck1190 FIND v(dout0_151) AT=600.025n

.meas tran vdout0_152ck1190 FIND v(dout0_152) AT=600.025n

.meas tran vdout0_153ck1190 FIND v(dout0_153) AT=600.025n

.meas tran vdout0_154ck1190 FIND v(dout0_154) AT=600.025n

.meas tran vdout0_155ck1190 FIND v(dout0_155) AT=600.025n

.meas tran vdout0_156ck1190 FIND v(dout0_156) AT=600.025n

.meas tran vdout0_157ck1190 FIND v(dout0_157) AT=600.025n

.meas tran vdout0_158ck1190 FIND v(dout0_158) AT=600.025n

.meas tran vdout0_159ck1190 FIND v(dout0_159) AT=600.025n

.meas tran vdout0_160ck1190 FIND v(dout0_160) AT=600.025n

.meas tran vdout0_161ck1190 FIND v(dout0_161) AT=600.025n

.meas tran vdout0_162ck1190 FIND v(dout0_162) AT=600.025n

.meas tran vdout0_163ck1190 FIND v(dout0_163) AT=600.025n

.meas tran vdout0_164ck1190 FIND v(dout0_164) AT=600.025n

.meas tran vdout0_165ck1190 FIND v(dout0_165) AT=600.025n

.meas tran vdout0_166ck1190 FIND v(dout0_166) AT=600.025n

.meas tran vdout0_167ck1190 FIND v(dout0_167) AT=600.025n

.meas tran vdout0_168ck1190 FIND v(dout0_168) AT=600.025n

.meas tran vdout0_169ck1190 FIND v(dout0_169) AT=600.025n

.meas tran vdout0_170ck1190 FIND v(dout0_170) AT=600.025n

.meas tran vdout0_171ck1190 FIND v(dout0_171) AT=600.025n

.meas tran vdout0_172ck1190 FIND v(dout0_172) AT=600.025n

.meas tran vdout0_173ck1190 FIND v(dout0_173) AT=600.025n

.meas tran vdout0_174ck1190 FIND v(dout0_174) AT=600.025n

.meas tran vdout0_175ck1190 FIND v(dout0_175) AT=600.025n

.meas tran vdout0_176ck1190 FIND v(dout0_176) AT=600.025n

.meas tran vdout0_177ck1190 FIND v(dout0_177) AT=600.025n

.meas tran vdout0_178ck1190 FIND v(dout0_178) AT=600.025n

.meas tran vdout0_179ck1190 FIND v(dout0_179) AT=600.025n

.meas tran vdout0_180ck1190 FIND v(dout0_180) AT=600.025n

.meas tran vdout0_181ck1190 FIND v(dout0_181) AT=600.025n

.meas tran vdout0_182ck1190 FIND v(dout0_182) AT=600.025n

.meas tran vdout0_183ck1190 FIND v(dout0_183) AT=600.025n

.meas tran vdout0_184ck1190 FIND v(dout0_184) AT=600.025n

.meas tran vdout0_185ck1190 FIND v(dout0_185) AT=600.025n

.meas tran vdout0_186ck1190 FIND v(dout0_186) AT=600.025n

.meas tran vdout0_187ck1190 FIND v(dout0_187) AT=600.025n

.meas tran vdout0_188ck1190 FIND v(dout0_188) AT=600.025n

.meas tran vdout0_189ck1190 FIND v(dout0_189) AT=600.025n

.meas tran vdout0_190ck1190 FIND v(dout0_190) AT=600.025n

.meas tran vdout0_191ck1190 FIND v(dout0_191) AT=600.025n

.meas tran vdout0_192ck1190 FIND v(dout0_192) AT=600.025n

.meas tran vdout0_193ck1190 FIND v(dout0_193) AT=600.025n

.meas tran vdout0_194ck1190 FIND v(dout0_194) AT=600.025n

.meas tran vdout0_195ck1190 FIND v(dout0_195) AT=600.025n

.meas tran vdout0_196ck1190 FIND v(dout0_196) AT=600.025n

.meas tran vdout0_197ck1190 FIND v(dout0_197) AT=600.025n

.meas tran vdout0_198ck1190 FIND v(dout0_198) AT=600.025n

.meas tran vdout0_199ck1190 FIND v(dout0_199) AT=600.025n

.meas tran vdout0_200ck1190 FIND v(dout0_200) AT=600.025n

.meas tran vdout0_201ck1190 FIND v(dout0_201) AT=600.025n

.meas tran vdout0_202ck1190 FIND v(dout0_202) AT=600.025n

.meas tran vdout0_203ck1190 FIND v(dout0_203) AT=600.025n

.meas tran vdout0_204ck1190 FIND v(dout0_204) AT=600.025n

.meas tran vdout0_205ck1190 FIND v(dout0_205) AT=600.025n

.meas tran vdout0_206ck1190 FIND v(dout0_206) AT=600.025n

.meas tran vdout0_207ck1190 FIND v(dout0_207) AT=600.025n

.meas tran vdout0_208ck1190 FIND v(dout0_208) AT=600.025n

.meas tran vdout0_209ck1190 FIND v(dout0_209) AT=600.025n

.meas tran vdout0_210ck1190 FIND v(dout0_210) AT=600.025n

.meas tran vdout0_211ck1190 FIND v(dout0_211) AT=600.025n

.meas tran vdout0_212ck1190 FIND v(dout0_212) AT=600.025n

.meas tran vdout0_213ck1190 FIND v(dout0_213) AT=600.025n

.meas tran vdout0_214ck1190 FIND v(dout0_214) AT=600.025n

.meas tran vdout0_215ck1190 FIND v(dout0_215) AT=600.025n

.meas tran vdout0_216ck1190 FIND v(dout0_216) AT=600.025n

.meas tran vdout0_217ck1190 FIND v(dout0_217) AT=600.025n

.meas tran vdout0_218ck1190 FIND v(dout0_218) AT=600.025n

.meas tran vdout0_219ck1190 FIND v(dout0_219) AT=600.025n

.meas tran vdout0_220ck1190 FIND v(dout0_220) AT=600.025n

.meas tran vdout0_221ck1190 FIND v(dout0_221) AT=600.025n

.meas tran vdout0_222ck1190 FIND v(dout0_222) AT=600.025n

.meas tran vdout0_223ck1190 FIND v(dout0_223) AT=600.025n

.meas tran vdout0_224ck1190 FIND v(dout0_224) AT=600.025n

.meas tran vdout0_225ck1190 FIND v(dout0_225) AT=600.025n

.meas tran vdout0_226ck1190 FIND v(dout0_226) AT=600.025n

.meas tran vdout0_227ck1190 FIND v(dout0_227) AT=600.025n

.meas tran vdout0_228ck1190 FIND v(dout0_228) AT=600.025n

.meas tran vdout0_229ck1190 FIND v(dout0_229) AT=600.025n

.meas tran vdout0_230ck1190 FIND v(dout0_230) AT=600.025n

.meas tran vdout0_231ck1190 FIND v(dout0_231) AT=600.025n

.meas tran vdout0_232ck1190 FIND v(dout0_232) AT=600.025n

.meas tran vdout0_233ck1190 FIND v(dout0_233) AT=600.025n

.meas tran vdout0_234ck1190 FIND v(dout0_234) AT=600.025n

.meas tran vdout0_235ck1190 FIND v(dout0_235) AT=600.025n

.meas tran vdout0_236ck1190 FIND v(dout0_236) AT=600.025n

.meas tran vdout0_237ck1190 FIND v(dout0_237) AT=600.025n

.meas tran vdout0_238ck1190 FIND v(dout0_238) AT=600.025n

.meas tran vdout0_239ck1190 FIND v(dout0_239) AT=600.025n

.meas tran vdout0_240ck1190 FIND v(dout0_240) AT=600.025n

.meas tran vdout0_241ck1190 FIND v(dout0_241) AT=600.025n

.meas tran vdout0_242ck1190 FIND v(dout0_242) AT=600.025n

.meas tran vdout0_243ck1190 FIND v(dout0_243) AT=600.025n

.meas tran vdout0_244ck1190 FIND v(dout0_244) AT=600.025n

.meas tran vdout0_245ck1190 FIND v(dout0_245) AT=600.025n

.meas tran vdout0_246ck1190 FIND v(dout0_246) AT=600.025n

.meas tran vdout0_247ck1190 FIND v(dout0_247) AT=600.025n

.meas tran vdout0_248ck1190 FIND v(dout0_248) AT=600.025n

.meas tran vdout0_249ck1190 FIND v(dout0_249) AT=600.025n

.meas tran vdout0_250ck1190 FIND v(dout0_250) AT=600.025n

.meas tran vdout0_251ck1190 FIND v(dout0_251) AT=600.025n

.meas tran vdout0_252ck1190 FIND v(dout0_252) AT=600.025n

.meas tran vdout0_253ck1190 FIND v(dout0_253) AT=600.025n

.meas tran vdout0_254ck1190 FIND v(dout0_254) AT=600.025n

.meas tran vdout0_255ck1190 FIND v(dout0_255) AT=600.025n

.meas tran vdout0_0ck1200 FIND v(dout0_0) AT=605.025n

.meas tran vdout0_1ck1200 FIND v(dout0_1) AT=605.025n

.meas tran vdout0_2ck1200 FIND v(dout0_2) AT=605.025n

.meas tran vdout0_3ck1200 FIND v(dout0_3) AT=605.025n

.meas tran vdout0_4ck1200 FIND v(dout0_4) AT=605.025n

.meas tran vdout0_5ck1200 FIND v(dout0_5) AT=605.025n

.meas tran vdout0_6ck1200 FIND v(dout0_6) AT=605.025n

.meas tran vdout0_7ck1200 FIND v(dout0_7) AT=605.025n

.meas tran vdout0_8ck1200 FIND v(dout0_8) AT=605.025n

.meas tran vdout0_9ck1200 FIND v(dout0_9) AT=605.025n

.meas tran vdout0_10ck1200 FIND v(dout0_10) AT=605.025n

.meas tran vdout0_11ck1200 FIND v(dout0_11) AT=605.025n

.meas tran vdout0_12ck1200 FIND v(dout0_12) AT=605.025n

.meas tran vdout0_13ck1200 FIND v(dout0_13) AT=605.025n

.meas tran vdout0_14ck1200 FIND v(dout0_14) AT=605.025n

.meas tran vdout0_15ck1200 FIND v(dout0_15) AT=605.025n

.meas tran vdout0_16ck1200 FIND v(dout0_16) AT=605.025n

.meas tran vdout0_17ck1200 FIND v(dout0_17) AT=605.025n

.meas tran vdout0_18ck1200 FIND v(dout0_18) AT=605.025n

.meas tran vdout0_19ck1200 FIND v(dout0_19) AT=605.025n

.meas tran vdout0_20ck1200 FIND v(dout0_20) AT=605.025n

.meas tran vdout0_21ck1200 FIND v(dout0_21) AT=605.025n

.meas tran vdout0_22ck1200 FIND v(dout0_22) AT=605.025n

.meas tran vdout0_23ck1200 FIND v(dout0_23) AT=605.025n

.meas tran vdout0_24ck1200 FIND v(dout0_24) AT=605.025n

.meas tran vdout0_25ck1200 FIND v(dout0_25) AT=605.025n

.meas tran vdout0_26ck1200 FIND v(dout0_26) AT=605.025n

.meas tran vdout0_27ck1200 FIND v(dout0_27) AT=605.025n

.meas tran vdout0_28ck1200 FIND v(dout0_28) AT=605.025n

.meas tran vdout0_29ck1200 FIND v(dout0_29) AT=605.025n

.meas tran vdout0_30ck1200 FIND v(dout0_30) AT=605.025n

.meas tran vdout0_31ck1200 FIND v(dout0_31) AT=605.025n

.meas tran vdout0_32ck1200 FIND v(dout0_32) AT=605.025n

.meas tran vdout0_33ck1200 FIND v(dout0_33) AT=605.025n

.meas tran vdout0_34ck1200 FIND v(dout0_34) AT=605.025n

.meas tran vdout0_35ck1200 FIND v(dout0_35) AT=605.025n

.meas tran vdout0_36ck1200 FIND v(dout0_36) AT=605.025n

.meas tran vdout0_37ck1200 FIND v(dout0_37) AT=605.025n

.meas tran vdout0_38ck1200 FIND v(dout0_38) AT=605.025n

.meas tran vdout0_39ck1200 FIND v(dout0_39) AT=605.025n

.meas tran vdout0_40ck1200 FIND v(dout0_40) AT=605.025n

.meas tran vdout0_41ck1200 FIND v(dout0_41) AT=605.025n

.meas tran vdout0_42ck1200 FIND v(dout0_42) AT=605.025n

.meas tran vdout0_43ck1200 FIND v(dout0_43) AT=605.025n

.meas tran vdout0_44ck1200 FIND v(dout0_44) AT=605.025n

.meas tran vdout0_45ck1200 FIND v(dout0_45) AT=605.025n

.meas tran vdout0_46ck1200 FIND v(dout0_46) AT=605.025n

.meas tran vdout0_47ck1200 FIND v(dout0_47) AT=605.025n

.meas tran vdout0_48ck1200 FIND v(dout0_48) AT=605.025n

.meas tran vdout0_49ck1200 FIND v(dout0_49) AT=605.025n

.meas tran vdout0_50ck1200 FIND v(dout0_50) AT=605.025n

.meas tran vdout0_51ck1200 FIND v(dout0_51) AT=605.025n

.meas tran vdout0_52ck1200 FIND v(dout0_52) AT=605.025n

.meas tran vdout0_53ck1200 FIND v(dout0_53) AT=605.025n

.meas tran vdout0_54ck1200 FIND v(dout0_54) AT=605.025n

.meas tran vdout0_55ck1200 FIND v(dout0_55) AT=605.025n

.meas tran vdout0_56ck1200 FIND v(dout0_56) AT=605.025n

.meas tran vdout0_57ck1200 FIND v(dout0_57) AT=605.025n

.meas tran vdout0_58ck1200 FIND v(dout0_58) AT=605.025n

.meas tran vdout0_59ck1200 FIND v(dout0_59) AT=605.025n

.meas tran vdout0_60ck1200 FIND v(dout0_60) AT=605.025n

.meas tran vdout0_61ck1200 FIND v(dout0_61) AT=605.025n

.meas tran vdout0_62ck1200 FIND v(dout0_62) AT=605.025n

.meas tran vdout0_63ck1200 FIND v(dout0_63) AT=605.025n

.meas tran vdout0_64ck1200 FIND v(dout0_64) AT=605.025n

.meas tran vdout0_65ck1200 FIND v(dout0_65) AT=605.025n

.meas tran vdout0_66ck1200 FIND v(dout0_66) AT=605.025n

.meas tran vdout0_67ck1200 FIND v(dout0_67) AT=605.025n

.meas tran vdout0_68ck1200 FIND v(dout0_68) AT=605.025n

.meas tran vdout0_69ck1200 FIND v(dout0_69) AT=605.025n

.meas tran vdout0_70ck1200 FIND v(dout0_70) AT=605.025n

.meas tran vdout0_71ck1200 FIND v(dout0_71) AT=605.025n

.meas tran vdout0_72ck1200 FIND v(dout0_72) AT=605.025n

.meas tran vdout0_73ck1200 FIND v(dout0_73) AT=605.025n

.meas tran vdout0_74ck1200 FIND v(dout0_74) AT=605.025n

.meas tran vdout0_75ck1200 FIND v(dout0_75) AT=605.025n

.meas tran vdout0_76ck1200 FIND v(dout0_76) AT=605.025n

.meas tran vdout0_77ck1200 FIND v(dout0_77) AT=605.025n

.meas tran vdout0_78ck1200 FIND v(dout0_78) AT=605.025n

.meas tran vdout0_79ck1200 FIND v(dout0_79) AT=605.025n

.meas tran vdout0_80ck1200 FIND v(dout0_80) AT=605.025n

.meas tran vdout0_81ck1200 FIND v(dout0_81) AT=605.025n

.meas tran vdout0_82ck1200 FIND v(dout0_82) AT=605.025n

.meas tran vdout0_83ck1200 FIND v(dout0_83) AT=605.025n

.meas tran vdout0_84ck1200 FIND v(dout0_84) AT=605.025n

.meas tran vdout0_85ck1200 FIND v(dout0_85) AT=605.025n

.meas tran vdout0_86ck1200 FIND v(dout0_86) AT=605.025n

.meas tran vdout0_87ck1200 FIND v(dout0_87) AT=605.025n

.meas tran vdout0_88ck1200 FIND v(dout0_88) AT=605.025n

.meas tran vdout0_89ck1200 FIND v(dout0_89) AT=605.025n

.meas tran vdout0_90ck1200 FIND v(dout0_90) AT=605.025n

.meas tran vdout0_91ck1200 FIND v(dout0_91) AT=605.025n

.meas tran vdout0_92ck1200 FIND v(dout0_92) AT=605.025n

.meas tran vdout0_93ck1200 FIND v(dout0_93) AT=605.025n

.meas tran vdout0_94ck1200 FIND v(dout0_94) AT=605.025n

.meas tran vdout0_95ck1200 FIND v(dout0_95) AT=605.025n

.meas tran vdout0_96ck1200 FIND v(dout0_96) AT=605.025n

.meas tran vdout0_97ck1200 FIND v(dout0_97) AT=605.025n

.meas tran vdout0_98ck1200 FIND v(dout0_98) AT=605.025n

.meas tran vdout0_99ck1200 FIND v(dout0_99) AT=605.025n

.meas tran vdout0_100ck1200 FIND v(dout0_100) AT=605.025n

.meas tran vdout0_101ck1200 FIND v(dout0_101) AT=605.025n

.meas tran vdout0_102ck1200 FIND v(dout0_102) AT=605.025n

.meas tran vdout0_103ck1200 FIND v(dout0_103) AT=605.025n

.meas tran vdout0_104ck1200 FIND v(dout0_104) AT=605.025n

.meas tran vdout0_105ck1200 FIND v(dout0_105) AT=605.025n

.meas tran vdout0_106ck1200 FIND v(dout0_106) AT=605.025n

.meas tran vdout0_107ck1200 FIND v(dout0_107) AT=605.025n

.meas tran vdout0_108ck1200 FIND v(dout0_108) AT=605.025n

.meas tran vdout0_109ck1200 FIND v(dout0_109) AT=605.025n

.meas tran vdout0_110ck1200 FIND v(dout0_110) AT=605.025n

.meas tran vdout0_111ck1200 FIND v(dout0_111) AT=605.025n

.meas tran vdout0_112ck1200 FIND v(dout0_112) AT=605.025n

.meas tran vdout0_113ck1200 FIND v(dout0_113) AT=605.025n

.meas tran vdout0_114ck1200 FIND v(dout0_114) AT=605.025n

.meas tran vdout0_115ck1200 FIND v(dout0_115) AT=605.025n

.meas tran vdout0_116ck1200 FIND v(dout0_116) AT=605.025n

.meas tran vdout0_117ck1200 FIND v(dout0_117) AT=605.025n

.meas tran vdout0_118ck1200 FIND v(dout0_118) AT=605.025n

.meas tran vdout0_119ck1200 FIND v(dout0_119) AT=605.025n

.meas tran vdout0_120ck1200 FIND v(dout0_120) AT=605.025n

.meas tran vdout0_121ck1200 FIND v(dout0_121) AT=605.025n

.meas tran vdout0_122ck1200 FIND v(dout0_122) AT=605.025n

.meas tran vdout0_123ck1200 FIND v(dout0_123) AT=605.025n

.meas tran vdout0_124ck1200 FIND v(dout0_124) AT=605.025n

.meas tran vdout0_125ck1200 FIND v(dout0_125) AT=605.025n

.meas tran vdout0_126ck1200 FIND v(dout0_126) AT=605.025n

.meas tran vdout0_127ck1200 FIND v(dout0_127) AT=605.025n

.meas tran vdout0_128ck1200 FIND v(dout0_128) AT=605.025n

.meas tran vdout0_129ck1200 FIND v(dout0_129) AT=605.025n

.meas tran vdout0_130ck1200 FIND v(dout0_130) AT=605.025n

.meas tran vdout0_131ck1200 FIND v(dout0_131) AT=605.025n

.meas tran vdout0_132ck1200 FIND v(dout0_132) AT=605.025n

.meas tran vdout0_133ck1200 FIND v(dout0_133) AT=605.025n

.meas tran vdout0_134ck1200 FIND v(dout0_134) AT=605.025n

.meas tran vdout0_135ck1200 FIND v(dout0_135) AT=605.025n

.meas tran vdout0_136ck1200 FIND v(dout0_136) AT=605.025n

.meas tran vdout0_137ck1200 FIND v(dout0_137) AT=605.025n

.meas tran vdout0_138ck1200 FIND v(dout0_138) AT=605.025n

.meas tran vdout0_139ck1200 FIND v(dout0_139) AT=605.025n

.meas tran vdout0_140ck1200 FIND v(dout0_140) AT=605.025n

.meas tran vdout0_141ck1200 FIND v(dout0_141) AT=605.025n

.meas tran vdout0_142ck1200 FIND v(dout0_142) AT=605.025n

.meas tran vdout0_143ck1200 FIND v(dout0_143) AT=605.025n

.meas tran vdout0_144ck1200 FIND v(dout0_144) AT=605.025n

.meas tran vdout0_145ck1200 FIND v(dout0_145) AT=605.025n

.meas tran vdout0_146ck1200 FIND v(dout0_146) AT=605.025n

.meas tran vdout0_147ck1200 FIND v(dout0_147) AT=605.025n

.meas tran vdout0_148ck1200 FIND v(dout0_148) AT=605.025n

.meas tran vdout0_149ck1200 FIND v(dout0_149) AT=605.025n

.meas tran vdout0_150ck1200 FIND v(dout0_150) AT=605.025n

.meas tran vdout0_151ck1200 FIND v(dout0_151) AT=605.025n

.meas tran vdout0_152ck1200 FIND v(dout0_152) AT=605.025n

.meas tran vdout0_153ck1200 FIND v(dout0_153) AT=605.025n

.meas tran vdout0_154ck1200 FIND v(dout0_154) AT=605.025n

.meas tran vdout0_155ck1200 FIND v(dout0_155) AT=605.025n

.meas tran vdout0_156ck1200 FIND v(dout0_156) AT=605.025n

.meas tran vdout0_157ck1200 FIND v(dout0_157) AT=605.025n

.meas tran vdout0_158ck1200 FIND v(dout0_158) AT=605.025n

.meas tran vdout0_159ck1200 FIND v(dout0_159) AT=605.025n

.meas tran vdout0_160ck1200 FIND v(dout0_160) AT=605.025n

.meas tran vdout0_161ck1200 FIND v(dout0_161) AT=605.025n

.meas tran vdout0_162ck1200 FIND v(dout0_162) AT=605.025n

.meas tran vdout0_163ck1200 FIND v(dout0_163) AT=605.025n

.meas tran vdout0_164ck1200 FIND v(dout0_164) AT=605.025n

.meas tran vdout0_165ck1200 FIND v(dout0_165) AT=605.025n

.meas tran vdout0_166ck1200 FIND v(dout0_166) AT=605.025n

.meas tran vdout0_167ck1200 FIND v(dout0_167) AT=605.025n

.meas tran vdout0_168ck1200 FIND v(dout0_168) AT=605.025n

.meas tran vdout0_169ck1200 FIND v(dout0_169) AT=605.025n

.meas tran vdout0_170ck1200 FIND v(dout0_170) AT=605.025n

.meas tran vdout0_171ck1200 FIND v(dout0_171) AT=605.025n

.meas tran vdout0_172ck1200 FIND v(dout0_172) AT=605.025n

.meas tran vdout0_173ck1200 FIND v(dout0_173) AT=605.025n

.meas tran vdout0_174ck1200 FIND v(dout0_174) AT=605.025n

.meas tran vdout0_175ck1200 FIND v(dout0_175) AT=605.025n

.meas tran vdout0_176ck1200 FIND v(dout0_176) AT=605.025n

.meas tran vdout0_177ck1200 FIND v(dout0_177) AT=605.025n

.meas tran vdout0_178ck1200 FIND v(dout0_178) AT=605.025n

.meas tran vdout0_179ck1200 FIND v(dout0_179) AT=605.025n

.meas tran vdout0_180ck1200 FIND v(dout0_180) AT=605.025n

.meas tran vdout0_181ck1200 FIND v(dout0_181) AT=605.025n

.meas tran vdout0_182ck1200 FIND v(dout0_182) AT=605.025n

.meas tran vdout0_183ck1200 FIND v(dout0_183) AT=605.025n

.meas tran vdout0_184ck1200 FIND v(dout0_184) AT=605.025n

.meas tran vdout0_185ck1200 FIND v(dout0_185) AT=605.025n

.meas tran vdout0_186ck1200 FIND v(dout0_186) AT=605.025n

.meas tran vdout0_187ck1200 FIND v(dout0_187) AT=605.025n

.meas tran vdout0_188ck1200 FIND v(dout0_188) AT=605.025n

.meas tran vdout0_189ck1200 FIND v(dout0_189) AT=605.025n

.meas tran vdout0_190ck1200 FIND v(dout0_190) AT=605.025n

.meas tran vdout0_191ck1200 FIND v(dout0_191) AT=605.025n

.meas tran vdout0_192ck1200 FIND v(dout0_192) AT=605.025n

.meas tran vdout0_193ck1200 FIND v(dout0_193) AT=605.025n

.meas tran vdout0_194ck1200 FIND v(dout0_194) AT=605.025n

.meas tran vdout0_195ck1200 FIND v(dout0_195) AT=605.025n

.meas tran vdout0_196ck1200 FIND v(dout0_196) AT=605.025n

.meas tran vdout0_197ck1200 FIND v(dout0_197) AT=605.025n

.meas tran vdout0_198ck1200 FIND v(dout0_198) AT=605.025n

.meas tran vdout0_199ck1200 FIND v(dout0_199) AT=605.025n

.meas tran vdout0_200ck1200 FIND v(dout0_200) AT=605.025n

.meas tran vdout0_201ck1200 FIND v(dout0_201) AT=605.025n

.meas tran vdout0_202ck1200 FIND v(dout0_202) AT=605.025n

.meas tran vdout0_203ck1200 FIND v(dout0_203) AT=605.025n

.meas tran vdout0_204ck1200 FIND v(dout0_204) AT=605.025n

.meas tran vdout0_205ck1200 FIND v(dout0_205) AT=605.025n

.meas tran vdout0_206ck1200 FIND v(dout0_206) AT=605.025n

.meas tran vdout0_207ck1200 FIND v(dout0_207) AT=605.025n

.meas tran vdout0_208ck1200 FIND v(dout0_208) AT=605.025n

.meas tran vdout0_209ck1200 FIND v(dout0_209) AT=605.025n

.meas tran vdout0_210ck1200 FIND v(dout0_210) AT=605.025n

.meas tran vdout0_211ck1200 FIND v(dout0_211) AT=605.025n

.meas tran vdout0_212ck1200 FIND v(dout0_212) AT=605.025n

.meas tran vdout0_213ck1200 FIND v(dout0_213) AT=605.025n

.meas tran vdout0_214ck1200 FIND v(dout0_214) AT=605.025n

.meas tran vdout0_215ck1200 FIND v(dout0_215) AT=605.025n

.meas tran vdout0_216ck1200 FIND v(dout0_216) AT=605.025n

.meas tran vdout0_217ck1200 FIND v(dout0_217) AT=605.025n

.meas tran vdout0_218ck1200 FIND v(dout0_218) AT=605.025n

.meas tran vdout0_219ck1200 FIND v(dout0_219) AT=605.025n

.meas tran vdout0_220ck1200 FIND v(dout0_220) AT=605.025n

.meas tran vdout0_221ck1200 FIND v(dout0_221) AT=605.025n

.meas tran vdout0_222ck1200 FIND v(dout0_222) AT=605.025n

.meas tran vdout0_223ck1200 FIND v(dout0_223) AT=605.025n

.meas tran vdout0_224ck1200 FIND v(dout0_224) AT=605.025n

.meas tran vdout0_225ck1200 FIND v(dout0_225) AT=605.025n

.meas tran vdout0_226ck1200 FIND v(dout0_226) AT=605.025n

.meas tran vdout0_227ck1200 FIND v(dout0_227) AT=605.025n

.meas tran vdout0_228ck1200 FIND v(dout0_228) AT=605.025n

.meas tran vdout0_229ck1200 FIND v(dout0_229) AT=605.025n

.meas tran vdout0_230ck1200 FIND v(dout0_230) AT=605.025n

.meas tran vdout0_231ck1200 FIND v(dout0_231) AT=605.025n

.meas tran vdout0_232ck1200 FIND v(dout0_232) AT=605.025n

.meas tran vdout0_233ck1200 FIND v(dout0_233) AT=605.025n

.meas tran vdout0_234ck1200 FIND v(dout0_234) AT=605.025n

.meas tran vdout0_235ck1200 FIND v(dout0_235) AT=605.025n

.meas tran vdout0_236ck1200 FIND v(dout0_236) AT=605.025n

.meas tran vdout0_237ck1200 FIND v(dout0_237) AT=605.025n

.meas tran vdout0_238ck1200 FIND v(dout0_238) AT=605.025n

.meas tran vdout0_239ck1200 FIND v(dout0_239) AT=605.025n

.meas tran vdout0_240ck1200 FIND v(dout0_240) AT=605.025n

.meas tran vdout0_241ck1200 FIND v(dout0_241) AT=605.025n

.meas tran vdout0_242ck1200 FIND v(dout0_242) AT=605.025n

.meas tran vdout0_243ck1200 FIND v(dout0_243) AT=605.025n

.meas tran vdout0_244ck1200 FIND v(dout0_244) AT=605.025n

.meas tran vdout0_245ck1200 FIND v(dout0_245) AT=605.025n

.meas tran vdout0_246ck1200 FIND v(dout0_246) AT=605.025n

.meas tran vdout0_247ck1200 FIND v(dout0_247) AT=605.025n

.meas tran vdout0_248ck1200 FIND v(dout0_248) AT=605.025n

.meas tran vdout0_249ck1200 FIND v(dout0_249) AT=605.025n

.meas tran vdout0_250ck1200 FIND v(dout0_250) AT=605.025n

.meas tran vdout0_251ck1200 FIND v(dout0_251) AT=605.025n

.meas tran vdout0_252ck1200 FIND v(dout0_252) AT=605.025n

.meas tran vdout0_253ck1200 FIND v(dout0_253) AT=605.025n

.meas tran vdout0_254ck1200 FIND v(dout0_254) AT=605.025n

.meas tran vdout0_255ck1200 FIND v(dout0_255) AT=605.025n

.meas tran vdout0_0ck1210 FIND v(dout0_0) AT=610.025n

.meas tran vdout0_1ck1210 FIND v(dout0_1) AT=610.025n

.meas tran vdout0_2ck1210 FIND v(dout0_2) AT=610.025n

.meas tran vdout0_3ck1210 FIND v(dout0_3) AT=610.025n

.meas tran vdout0_4ck1210 FIND v(dout0_4) AT=610.025n

.meas tran vdout0_5ck1210 FIND v(dout0_5) AT=610.025n

.meas tran vdout0_6ck1210 FIND v(dout0_6) AT=610.025n

.meas tran vdout0_7ck1210 FIND v(dout0_7) AT=610.025n

.meas tran vdout0_8ck1210 FIND v(dout0_8) AT=610.025n

.meas tran vdout0_9ck1210 FIND v(dout0_9) AT=610.025n

.meas tran vdout0_10ck1210 FIND v(dout0_10) AT=610.025n

.meas tran vdout0_11ck1210 FIND v(dout0_11) AT=610.025n

.meas tran vdout0_12ck1210 FIND v(dout0_12) AT=610.025n

.meas tran vdout0_13ck1210 FIND v(dout0_13) AT=610.025n

.meas tran vdout0_14ck1210 FIND v(dout0_14) AT=610.025n

.meas tran vdout0_15ck1210 FIND v(dout0_15) AT=610.025n

.meas tran vdout0_16ck1210 FIND v(dout0_16) AT=610.025n

.meas tran vdout0_17ck1210 FIND v(dout0_17) AT=610.025n

.meas tran vdout0_18ck1210 FIND v(dout0_18) AT=610.025n

.meas tran vdout0_19ck1210 FIND v(dout0_19) AT=610.025n

.meas tran vdout0_20ck1210 FIND v(dout0_20) AT=610.025n

.meas tran vdout0_21ck1210 FIND v(dout0_21) AT=610.025n

.meas tran vdout0_22ck1210 FIND v(dout0_22) AT=610.025n

.meas tran vdout0_23ck1210 FIND v(dout0_23) AT=610.025n

.meas tran vdout0_24ck1210 FIND v(dout0_24) AT=610.025n

.meas tran vdout0_25ck1210 FIND v(dout0_25) AT=610.025n

.meas tran vdout0_26ck1210 FIND v(dout0_26) AT=610.025n

.meas tran vdout0_27ck1210 FIND v(dout0_27) AT=610.025n

.meas tran vdout0_28ck1210 FIND v(dout0_28) AT=610.025n

.meas tran vdout0_29ck1210 FIND v(dout0_29) AT=610.025n

.meas tran vdout0_30ck1210 FIND v(dout0_30) AT=610.025n

.meas tran vdout0_31ck1210 FIND v(dout0_31) AT=610.025n

.meas tran vdout0_32ck1210 FIND v(dout0_32) AT=610.025n

.meas tran vdout0_33ck1210 FIND v(dout0_33) AT=610.025n

.meas tran vdout0_34ck1210 FIND v(dout0_34) AT=610.025n

.meas tran vdout0_35ck1210 FIND v(dout0_35) AT=610.025n

.meas tran vdout0_36ck1210 FIND v(dout0_36) AT=610.025n

.meas tran vdout0_37ck1210 FIND v(dout0_37) AT=610.025n

.meas tran vdout0_38ck1210 FIND v(dout0_38) AT=610.025n

.meas tran vdout0_39ck1210 FIND v(dout0_39) AT=610.025n

.meas tran vdout0_40ck1210 FIND v(dout0_40) AT=610.025n

.meas tran vdout0_41ck1210 FIND v(dout0_41) AT=610.025n

.meas tran vdout0_42ck1210 FIND v(dout0_42) AT=610.025n

.meas tran vdout0_43ck1210 FIND v(dout0_43) AT=610.025n

.meas tran vdout0_44ck1210 FIND v(dout0_44) AT=610.025n

.meas tran vdout0_45ck1210 FIND v(dout0_45) AT=610.025n

.meas tran vdout0_46ck1210 FIND v(dout0_46) AT=610.025n

.meas tran vdout0_47ck1210 FIND v(dout0_47) AT=610.025n

.meas tran vdout0_48ck1210 FIND v(dout0_48) AT=610.025n

.meas tran vdout0_49ck1210 FIND v(dout0_49) AT=610.025n

.meas tran vdout0_50ck1210 FIND v(dout0_50) AT=610.025n

.meas tran vdout0_51ck1210 FIND v(dout0_51) AT=610.025n

.meas tran vdout0_52ck1210 FIND v(dout0_52) AT=610.025n

.meas tran vdout0_53ck1210 FIND v(dout0_53) AT=610.025n

.meas tran vdout0_54ck1210 FIND v(dout0_54) AT=610.025n

.meas tran vdout0_55ck1210 FIND v(dout0_55) AT=610.025n

.meas tran vdout0_56ck1210 FIND v(dout0_56) AT=610.025n

.meas tran vdout0_57ck1210 FIND v(dout0_57) AT=610.025n

.meas tran vdout0_58ck1210 FIND v(dout0_58) AT=610.025n

.meas tran vdout0_59ck1210 FIND v(dout0_59) AT=610.025n

.meas tran vdout0_60ck1210 FIND v(dout0_60) AT=610.025n

.meas tran vdout0_61ck1210 FIND v(dout0_61) AT=610.025n

.meas tran vdout0_62ck1210 FIND v(dout0_62) AT=610.025n

.meas tran vdout0_63ck1210 FIND v(dout0_63) AT=610.025n

.meas tran vdout0_64ck1210 FIND v(dout0_64) AT=610.025n

.meas tran vdout0_65ck1210 FIND v(dout0_65) AT=610.025n

.meas tran vdout0_66ck1210 FIND v(dout0_66) AT=610.025n

.meas tran vdout0_67ck1210 FIND v(dout0_67) AT=610.025n

.meas tran vdout0_68ck1210 FIND v(dout0_68) AT=610.025n

.meas tran vdout0_69ck1210 FIND v(dout0_69) AT=610.025n

.meas tran vdout0_70ck1210 FIND v(dout0_70) AT=610.025n

.meas tran vdout0_71ck1210 FIND v(dout0_71) AT=610.025n

.meas tran vdout0_72ck1210 FIND v(dout0_72) AT=610.025n

.meas tran vdout0_73ck1210 FIND v(dout0_73) AT=610.025n

.meas tran vdout0_74ck1210 FIND v(dout0_74) AT=610.025n

.meas tran vdout0_75ck1210 FIND v(dout0_75) AT=610.025n

.meas tran vdout0_76ck1210 FIND v(dout0_76) AT=610.025n

.meas tran vdout0_77ck1210 FIND v(dout0_77) AT=610.025n

.meas tran vdout0_78ck1210 FIND v(dout0_78) AT=610.025n

.meas tran vdout0_79ck1210 FIND v(dout0_79) AT=610.025n

.meas tran vdout0_80ck1210 FIND v(dout0_80) AT=610.025n

.meas tran vdout0_81ck1210 FIND v(dout0_81) AT=610.025n

.meas tran vdout0_82ck1210 FIND v(dout0_82) AT=610.025n

.meas tran vdout0_83ck1210 FIND v(dout0_83) AT=610.025n

.meas tran vdout0_84ck1210 FIND v(dout0_84) AT=610.025n

.meas tran vdout0_85ck1210 FIND v(dout0_85) AT=610.025n

.meas tran vdout0_86ck1210 FIND v(dout0_86) AT=610.025n

.meas tran vdout0_87ck1210 FIND v(dout0_87) AT=610.025n

.meas tran vdout0_88ck1210 FIND v(dout0_88) AT=610.025n

.meas tran vdout0_89ck1210 FIND v(dout0_89) AT=610.025n

.meas tran vdout0_90ck1210 FIND v(dout0_90) AT=610.025n

.meas tran vdout0_91ck1210 FIND v(dout0_91) AT=610.025n

.meas tran vdout0_92ck1210 FIND v(dout0_92) AT=610.025n

.meas tran vdout0_93ck1210 FIND v(dout0_93) AT=610.025n

.meas tran vdout0_94ck1210 FIND v(dout0_94) AT=610.025n

.meas tran vdout0_95ck1210 FIND v(dout0_95) AT=610.025n

.meas tran vdout0_96ck1210 FIND v(dout0_96) AT=610.025n

.meas tran vdout0_97ck1210 FIND v(dout0_97) AT=610.025n

.meas tran vdout0_98ck1210 FIND v(dout0_98) AT=610.025n

.meas tran vdout0_99ck1210 FIND v(dout0_99) AT=610.025n

.meas tran vdout0_100ck1210 FIND v(dout0_100) AT=610.025n

.meas tran vdout0_101ck1210 FIND v(dout0_101) AT=610.025n

.meas tran vdout0_102ck1210 FIND v(dout0_102) AT=610.025n

.meas tran vdout0_103ck1210 FIND v(dout0_103) AT=610.025n

.meas tran vdout0_104ck1210 FIND v(dout0_104) AT=610.025n

.meas tran vdout0_105ck1210 FIND v(dout0_105) AT=610.025n

.meas tran vdout0_106ck1210 FIND v(dout0_106) AT=610.025n

.meas tran vdout0_107ck1210 FIND v(dout0_107) AT=610.025n

.meas tran vdout0_108ck1210 FIND v(dout0_108) AT=610.025n

.meas tran vdout0_109ck1210 FIND v(dout0_109) AT=610.025n

.meas tran vdout0_110ck1210 FIND v(dout0_110) AT=610.025n

.meas tran vdout0_111ck1210 FIND v(dout0_111) AT=610.025n

.meas tran vdout0_112ck1210 FIND v(dout0_112) AT=610.025n

.meas tran vdout0_113ck1210 FIND v(dout0_113) AT=610.025n

.meas tran vdout0_114ck1210 FIND v(dout0_114) AT=610.025n

.meas tran vdout0_115ck1210 FIND v(dout0_115) AT=610.025n

.meas tran vdout0_116ck1210 FIND v(dout0_116) AT=610.025n

.meas tran vdout0_117ck1210 FIND v(dout0_117) AT=610.025n

.meas tran vdout0_118ck1210 FIND v(dout0_118) AT=610.025n

.meas tran vdout0_119ck1210 FIND v(dout0_119) AT=610.025n

.meas tran vdout0_120ck1210 FIND v(dout0_120) AT=610.025n

.meas tran vdout0_121ck1210 FIND v(dout0_121) AT=610.025n

.meas tran vdout0_122ck1210 FIND v(dout0_122) AT=610.025n

.meas tran vdout0_123ck1210 FIND v(dout0_123) AT=610.025n

.meas tran vdout0_124ck1210 FIND v(dout0_124) AT=610.025n

.meas tran vdout0_125ck1210 FIND v(dout0_125) AT=610.025n

.meas tran vdout0_126ck1210 FIND v(dout0_126) AT=610.025n

.meas tran vdout0_127ck1210 FIND v(dout0_127) AT=610.025n

.meas tran vdout0_128ck1210 FIND v(dout0_128) AT=610.025n

.meas tran vdout0_129ck1210 FIND v(dout0_129) AT=610.025n

.meas tran vdout0_130ck1210 FIND v(dout0_130) AT=610.025n

.meas tran vdout0_131ck1210 FIND v(dout0_131) AT=610.025n

.meas tran vdout0_132ck1210 FIND v(dout0_132) AT=610.025n

.meas tran vdout0_133ck1210 FIND v(dout0_133) AT=610.025n

.meas tran vdout0_134ck1210 FIND v(dout0_134) AT=610.025n

.meas tran vdout0_135ck1210 FIND v(dout0_135) AT=610.025n

.meas tran vdout0_136ck1210 FIND v(dout0_136) AT=610.025n

.meas tran vdout0_137ck1210 FIND v(dout0_137) AT=610.025n

.meas tran vdout0_138ck1210 FIND v(dout0_138) AT=610.025n

.meas tran vdout0_139ck1210 FIND v(dout0_139) AT=610.025n

.meas tran vdout0_140ck1210 FIND v(dout0_140) AT=610.025n

.meas tran vdout0_141ck1210 FIND v(dout0_141) AT=610.025n

.meas tran vdout0_142ck1210 FIND v(dout0_142) AT=610.025n

.meas tran vdout0_143ck1210 FIND v(dout0_143) AT=610.025n

.meas tran vdout0_144ck1210 FIND v(dout0_144) AT=610.025n

.meas tran vdout0_145ck1210 FIND v(dout0_145) AT=610.025n

.meas tran vdout0_146ck1210 FIND v(dout0_146) AT=610.025n

.meas tran vdout0_147ck1210 FIND v(dout0_147) AT=610.025n

.meas tran vdout0_148ck1210 FIND v(dout0_148) AT=610.025n

.meas tran vdout0_149ck1210 FIND v(dout0_149) AT=610.025n

.meas tran vdout0_150ck1210 FIND v(dout0_150) AT=610.025n

.meas tran vdout0_151ck1210 FIND v(dout0_151) AT=610.025n

.meas tran vdout0_152ck1210 FIND v(dout0_152) AT=610.025n

.meas tran vdout0_153ck1210 FIND v(dout0_153) AT=610.025n

.meas tran vdout0_154ck1210 FIND v(dout0_154) AT=610.025n

.meas tran vdout0_155ck1210 FIND v(dout0_155) AT=610.025n

.meas tran vdout0_156ck1210 FIND v(dout0_156) AT=610.025n

.meas tran vdout0_157ck1210 FIND v(dout0_157) AT=610.025n

.meas tran vdout0_158ck1210 FIND v(dout0_158) AT=610.025n

.meas tran vdout0_159ck1210 FIND v(dout0_159) AT=610.025n

.meas tran vdout0_160ck1210 FIND v(dout0_160) AT=610.025n

.meas tran vdout0_161ck1210 FIND v(dout0_161) AT=610.025n

.meas tran vdout0_162ck1210 FIND v(dout0_162) AT=610.025n

.meas tran vdout0_163ck1210 FIND v(dout0_163) AT=610.025n

.meas tran vdout0_164ck1210 FIND v(dout0_164) AT=610.025n

.meas tran vdout0_165ck1210 FIND v(dout0_165) AT=610.025n

.meas tran vdout0_166ck1210 FIND v(dout0_166) AT=610.025n

.meas tran vdout0_167ck1210 FIND v(dout0_167) AT=610.025n

.meas tran vdout0_168ck1210 FIND v(dout0_168) AT=610.025n

.meas tran vdout0_169ck1210 FIND v(dout0_169) AT=610.025n

.meas tran vdout0_170ck1210 FIND v(dout0_170) AT=610.025n

.meas tran vdout0_171ck1210 FIND v(dout0_171) AT=610.025n

.meas tran vdout0_172ck1210 FIND v(dout0_172) AT=610.025n

.meas tran vdout0_173ck1210 FIND v(dout0_173) AT=610.025n

.meas tran vdout0_174ck1210 FIND v(dout0_174) AT=610.025n

.meas tran vdout0_175ck1210 FIND v(dout0_175) AT=610.025n

.meas tran vdout0_176ck1210 FIND v(dout0_176) AT=610.025n

.meas tran vdout0_177ck1210 FIND v(dout0_177) AT=610.025n

.meas tran vdout0_178ck1210 FIND v(dout0_178) AT=610.025n

.meas tran vdout0_179ck1210 FIND v(dout0_179) AT=610.025n

.meas tran vdout0_180ck1210 FIND v(dout0_180) AT=610.025n

.meas tran vdout0_181ck1210 FIND v(dout0_181) AT=610.025n

.meas tran vdout0_182ck1210 FIND v(dout0_182) AT=610.025n

.meas tran vdout0_183ck1210 FIND v(dout0_183) AT=610.025n

.meas tran vdout0_184ck1210 FIND v(dout0_184) AT=610.025n

.meas tran vdout0_185ck1210 FIND v(dout0_185) AT=610.025n

.meas tran vdout0_186ck1210 FIND v(dout0_186) AT=610.025n

.meas tran vdout0_187ck1210 FIND v(dout0_187) AT=610.025n

.meas tran vdout0_188ck1210 FIND v(dout0_188) AT=610.025n

.meas tran vdout0_189ck1210 FIND v(dout0_189) AT=610.025n

.meas tran vdout0_190ck1210 FIND v(dout0_190) AT=610.025n

.meas tran vdout0_191ck1210 FIND v(dout0_191) AT=610.025n

.meas tran vdout0_192ck1210 FIND v(dout0_192) AT=610.025n

.meas tran vdout0_193ck1210 FIND v(dout0_193) AT=610.025n

.meas tran vdout0_194ck1210 FIND v(dout0_194) AT=610.025n

.meas tran vdout0_195ck1210 FIND v(dout0_195) AT=610.025n

.meas tran vdout0_196ck1210 FIND v(dout0_196) AT=610.025n

.meas tran vdout0_197ck1210 FIND v(dout0_197) AT=610.025n

.meas tran vdout0_198ck1210 FIND v(dout0_198) AT=610.025n

.meas tran vdout0_199ck1210 FIND v(dout0_199) AT=610.025n

.meas tran vdout0_200ck1210 FIND v(dout0_200) AT=610.025n

.meas tran vdout0_201ck1210 FIND v(dout0_201) AT=610.025n

.meas tran vdout0_202ck1210 FIND v(dout0_202) AT=610.025n

.meas tran vdout0_203ck1210 FIND v(dout0_203) AT=610.025n

.meas tran vdout0_204ck1210 FIND v(dout0_204) AT=610.025n

.meas tran vdout0_205ck1210 FIND v(dout0_205) AT=610.025n

.meas tran vdout0_206ck1210 FIND v(dout0_206) AT=610.025n

.meas tran vdout0_207ck1210 FIND v(dout0_207) AT=610.025n

.meas tran vdout0_208ck1210 FIND v(dout0_208) AT=610.025n

.meas tran vdout0_209ck1210 FIND v(dout0_209) AT=610.025n

.meas tran vdout0_210ck1210 FIND v(dout0_210) AT=610.025n

.meas tran vdout0_211ck1210 FIND v(dout0_211) AT=610.025n

.meas tran vdout0_212ck1210 FIND v(dout0_212) AT=610.025n

.meas tran vdout0_213ck1210 FIND v(dout0_213) AT=610.025n

.meas tran vdout0_214ck1210 FIND v(dout0_214) AT=610.025n

.meas tran vdout0_215ck1210 FIND v(dout0_215) AT=610.025n

.meas tran vdout0_216ck1210 FIND v(dout0_216) AT=610.025n

.meas tran vdout0_217ck1210 FIND v(dout0_217) AT=610.025n

.meas tran vdout0_218ck1210 FIND v(dout0_218) AT=610.025n

.meas tran vdout0_219ck1210 FIND v(dout0_219) AT=610.025n

.meas tran vdout0_220ck1210 FIND v(dout0_220) AT=610.025n

.meas tran vdout0_221ck1210 FIND v(dout0_221) AT=610.025n

.meas tran vdout0_222ck1210 FIND v(dout0_222) AT=610.025n

.meas tran vdout0_223ck1210 FIND v(dout0_223) AT=610.025n

.meas tran vdout0_224ck1210 FIND v(dout0_224) AT=610.025n

.meas tran vdout0_225ck1210 FIND v(dout0_225) AT=610.025n

.meas tran vdout0_226ck1210 FIND v(dout0_226) AT=610.025n

.meas tran vdout0_227ck1210 FIND v(dout0_227) AT=610.025n

.meas tran vdout0_228ck1210 FIND v(dout0_228) AT=610.025n

.meas tran vdout0_229ck1210 FIND v(dout0_229) AT=610.025n

.meas tran vdout0_230ck1210 FIND v(dout0_230) AT=610.025n

.meas tran vdout0_231ck1210 FIND v(dout0_231) AT=610.025n

.meas tran vdout0_232ck1210 FIND v(dout0_232) AT=610.025n

.meas tran vdout0_233ck1210 FIND v(dout0_233) AT=610.025n

.meas tran vdout0_234ck1210 FIND v(dout0_234) AT=610.025n

.meas tran vdout0_235ck1210 FIND v(dout0_235) AT=610.025n

.meas tran vdout0_236ck1210 FIND v(dout0_236) AT=610.025n

.meas tran vdout0_237ck1210 FIND v(dout0_237) AT=610.025n

.meas tran vdout0_238ck1210 FIND v(dout0_238) AT=610.025n

.meas tran vdout0_239ck1210 FIND v(dout0_239) AT=610.025n

.meas tran vdout0_240ck1210 FIND v(dout0_240) AT=610.025n

.meas tran vdout0_241ck1210 FIND v(dout0_241) AT=610.025n

.meas tran vdout0_242ck1210 FIND v(dout0_242) AT=610.025n

.meas tran vdout0_243ck1210 FIND v(dout0_243) AT=610.025n

.meas tran vdout0_244ck1210 FIND v(dout0_244) AT=610.025n

.meas tran vdout0_245ck1210 FIND v(dout0_245) AT=610.025n

.meas tran vdout0_246ck1210 FIND v(dout0_246) AT=610.025n

.meas tran vdout0_247ck1210 FIND v(dout0_247) AT=610.025n

.meas tran vdout0_248ck1210 FIND v(dout0_248) AT=610.025n

.meas tran vdout0_249ck1210 FIND v(dout0_249) AT=610.025n

.meas tran vdout0_250ck1210 FIND v(dout0_250) AT=610.025n

.meas tran vdout0_251ck1210 FIND v(dout0_251) AT=610.025n

.meas tran vdout0_252ck1210 FIND v(dout0_252) AT=610.025n

.meas tran vdout0_253ck1210 FIND v(dout0_253) AT=610.025n

.meas tran vdout0_254ck1210 FIND v(dout0_254) AT=610.025n

.meas tran vdout0_255ck1210 FIND v(dout0_255) AT=610.025n

.meas tran vdout0_0ck1220 FIND v(dout0_0) AT=615.025n

.meas tran vdout0_1ck1220 FIND v(dout0_1) AT=615.025n

.meas tran vdout0_2ck1220 FIND v(dout0_2) AT=615.025n

.meas tran vdout0_3ck1220 FIND v(dout0_3) AT=615.025n

.meas tran vdout0_4ck1220 FIND v(dout0_4) AT=615.025n

.meas tran vdout0_5ck1220 FIND v(dout0_5) AT=615.025n

.meas tran vdout0_6ck1220 FIND v(dout0_6) AT=615.025n

.meas tran vdout0_7ck1220 FIND v(dout0_7) AT=615.025n

.meas tran vdout0_8ck1220 FIND v(dout0_8) AT=615.025n

.meas tran vdout0_9ck1220 FIND v(dout0_9) AT=615.025n

.meas tran vdout0_10ck1220 FIND v(dout0_10) AT=615.025n

.meas tran vdout0_11ck1220 FIND v(dout0_11) AT=615.025n

.meas tran vdout0_12ck1220 FIND v(dout0_12) AT=615.025n

.meas tran vdout0_13ck1220 FIND v(dout0_13) AT=615.025n

.meas tran vdout0_14ck1220 FIND v(dout0_14) AT=615.025n

.meas tran vdout0_15ck1220 FIND v(dout0_15) AT=615.025n

.meas tran vdout0_16ck1220 FIND v(dout0_16) AT=615.025n

.meas tran vdout0_17ck1220 FIND v(dout0_17) AT=615.025n

.meas tran vdout0_18ck1220 FIND v(dout0_18) AT=615.025n

.meas tran vdout0_19ck1220 FIND v(dout0_19) AT=615.025n

.meas tran vdout0_20ck1220 FIND v(dout0_20) AT=615.025n

.meas tran vdout0_21ck1220 FIND v(dout0_21) AT=615.025n

.meas tran vdout0_22ck1220 FIND v(dout0_22) AT=615.025n

.meas tran vdout0_23ck1220 FIND v(dout0_23) AT=615.025n

.meas tran vdout0_24ck1220 FIND v(dout0_24) AT=615.025n

.meas tran vdout0_25ck1220 FIND v(dout0_25) AT=615.025n

.meas tran vdout0_26ck1220 FIND v(dout0_26) AT=615.025n

.meas tran vdout0_27ck1220 FIND v(dout0_27) AT=615.025n

.meas tran vdout0_28ck1220 FIND v(dout0_28) AT=615.025n

.meas tran vdout0_29ck1220 FIND v(dout0_29) AT=615.025n

.meas tran vdout0_30ck1220 FIND v(dout0_30) AT=615.025n

.meas tran vdout0_31ck1220 FIND v(dout0_31) AT=615.025n

.meas tran vdout0_32ck1220 FIND v(dout0_32) AT=615.025n

.meas tran vdout0_33ck1220 FIND v(dout0_33) AT=615.025n

.meas tran vdout0_34ck1220 FIND v(dout0_34) AT=615.025n

.meas tran vdout0_35ck1220 FIND v(dout0_35) AT=615.025n

.meas tran vdout0_36ck1220 FIND v(dout0_36) AT=615.025n

.meas tran vdout0_37ck1220 FIND v(dout0_37) AT=615.025n

.meas tran vdout0_38ck1220 FIND v(dout0_38) AT=615.025n

.meas tran vdout0_39ck1220 FIND v(dout0_39) AT=615.025n

.meas tran vdout0_40ck1220 FIND v(dout0_40) AT=615.025n

.meas tran vdout0_41ck1220 FIND v(dout0_41) AT=615.025n

.meas tran vdout0_42ck1220 FIND v(dout0_42) AT=615.025n

.meas tran vdout0_43ck1220 FIND v(dout0_43) AT=615.025n

.meas tran vdout0_44ck1220 FIND v(dout0_44) AT=615.025n

.meas tran vdout0_45ck1220 FIND v(dout0_45) AT=615.025n

.meas tran vdout0_46ck1220 FIND v(dout0_46) AT=615.025n

.meas tran vdout0_47ck1220 FIND v(dout0_47) AT=615.025n

.meas tran vdout0_48ck1220 FIND v(dout0_48) AT=615.025n

.meas tran vdout0_49ck1220 FIND v(dout0_49) AT=615.025n

.meas tran vdout0_50ck1220 FIND v(dout0_50) AT=615.025n

.meas tran vdout0_51ck1220 FIND v(dout0_51) AT=615.025n

.meas tran vdout0_52ck1220 FIND v(dout0_52) AT=615.025n

.meas tran vdout0_53ck1220 FIND v(dout0_53) AT=615.025n

.meas tran vdout0_54ck1220 FIND v(dout0_54) AT=615.025n

.meas tran vdout0_55ck1220 FIND v(dout0_55) AT=615.025n

.meas tran vdout0_56ck1220 FIND v(dout0_56) AT=615.025n

.meas tran vdout0_57ck1220 FIND v(dout0_57) AT=615.025n

.meas tran vdout0_58ck1220 FIND v(dout0_58) AT=615.025n

.meas tran vdout0_59ck1220 FIND v(dout0_59) AT=615.025n

.meas tran vdout0_60ck1220 FIND v(dout0_60) AT=615.025n

.meas tran vdout0_61ck1220 FIND v(dout0_61) AT=615.025n

.meas tran vdout0_62ck1220 FIND v(dout0_62) AT=615.025n

.meas tran vdout0_63ck1220 FIND v(dout0_63) AT=615.025n

.meas tran vdout0_64ck1220 FIND v(dout0_64) AT=615.025n

.meas tran vdout0_65ck1220 FIND v(dout0_65) AT=615.025n

.meas tran vdout0_66ck1220 FIND v(dout0_66) AT=615.025n

.meas tran vdout0_67ck1220 FIND v(dout0_67) AT=615.025n

.meas tran vdout0_68ck1220 FIND v(dout0_68) AT=615.025n

.meas tran vdout0_69ck1220 FIND v(dout0_69) AT=615.025n

.meas tran vdout0_70ck1220 FIND v(dout0_70) AT=615.025n

.meas tran vdout0_71ck1220 FIND v(dout0_71) AT=615.025n

.meas tran vdout0_72ck1220 FIND v(dout0_72) AT=615.025n

.meas tran vdout0_73ck1220 FIND v(dout0_73) AT=615.025n

.meas tran vdout0_74ck1220 FIND v(dout0_74) AT=615.025n

.meas tran vdout0_75ck1220 FIND v(dout0_75) AT=615.025n

.meas tran vdout0_76ck1220 FIND v(dout0_76) AT=615.025n

.meas tran vdout0_77ck1220 FIND v(dout0_77) AT=615.025n

.meas tran vdout0_78ck1220 FIND v(dout0_78) AT=615.025n

.meas tran vdout0_79ck1220 FIND v(dout0_79) AT=615.025n

.meas tran vdout0_80ck1220 FIND v(dout0_80) AT=615.025n

.meas tran vdout0_81ck1220 FIND v(dout0_81) AT=615.025n

.meas tran vdout0_82ck1220 FIND v(dout0_82) AT=615.025n

.meas tran vdout0_83ck1220 FIND v(dout0_83) AT=615.025n

.meas tran vdout0_84ck1220 FIND v(dout0_84) AT=615.025n

.meas tran vdout0_85ck1220 FIND v(dout0_85) AT=615.025n

.meas tran vdout0_86ck1220 FIND v(dout0_86) AT=615.025n

.meas tran vdout0_87ck1220 FIND v(dout0_87) AT=615.025n

.meas tran vdout0_88ck1220 FIND v(dout0_88) AT=615.025n

.meas tran vdout0_89ck1220 FIND v(dout0_89) AT=615.025n

.meas tran vdout0_90ck1220 FIND v(dout0_90) AT=615.025n

.meas tran vdout0_91ck1220 FIND v(dout0_91) AT=615.025n

.meas tran vdout0_92ck1220 FIND v(dout0_92) AT=615.025n

.meas tran vdout0_93ck1220 FIND v(dout0_93) AT=615.025n

.meas tran vdout0_94ck1220 FIND v(dout0_94) AT=615.025n

.meas tran vdout0_95ck1220 FIND v(dout0_95) AT=615.025n

.meas tran vdout0_96ck1220 FIND v(dout0_96) AT=615.025n

.meas tran vdout0_97ck1220 FIND v(dout0_97) AT=615.025n

.meas tran vdout0_98ck1220 FIND v(dout0_98) AT=615.025n

.meas tran vdout0_99ck1220 FIND v(dout0_99) AT=615.025n

.meas tran vdout0_100ck1220 FIND v(dout0_100) AT=615.025n

.meas tran vdout0_101ck1220 FIND v(dout0_101) AT=615.025n

.meas tran vdout0_102ck1220 FIND v(dout0_102) AT=615.025n

.meas tran vdout0_103ck1220 FIND v(dout0_103) AT=615.025n

.meas tran vdout0_104ck1220 FIND v(dout0_104) AT=615.025n

.meas tran vdout0_105ck1220 FIND v(dout0_105) AT=615.025n

.meas tran vdout0_106ck1220 FIND v(dout0_106) AT=615.025n

.meas tran vdout0_107ck1220 FIND v(dout0_107) AT=615.025n

.meas tran vdout0_108ck1220 FIND v(dout0_108) AT=615.025n

.meas tran vdout0_109ck1220 FIND v(dout0_109) AT=615.025n

.meas tran vdout0_110ck1220 FIND v(dout0_110) AT=615.025n

.meas tran vdout0_111ck1220 FIND v(dout0_111) AT=615.025n

.meas tran vdout0_112ck1220 FIND v(dout0_112) AT=615.025n

.meas tran vdout0_113ck1220 FIND v(dout0_113) AT=615.025n

.meas tran vdout0_114ck1220 FIND v(dout0_114) AT=615.025n

.meas tran vdout0_115ck1220 FIND v(dout0_115) AT=615.025n

.meas tran vdout0_116ck1220 FIND v(dout0_116) AT=615.025n

.meas tran vdout0_117ck1220 FIND v(dout0_117) AT=615.025n

.meas tran vdout0_118ck1220 FIND v(dout0_118) AT=615.025n

.meas tran vdout0_119ck1220 FIND v(dout0_119) AT=615.025n

.meas tran vdout0_120ck1220 FIND v(dout0_120) AT=615.025n

.meas tran vdout0_121ck1220 FIND v(dout0_121) AT=615.025n

.meas tran vdout0_122ck1220 FIND v(dout0_122) AT=615.025n

.meas tran vdout0_123ck1220 FIND v(dout0_123) AT=615.025n

.meas tran vdout0_124ck1220 FIND v(dout0_124) AT=615.025n

.meas tran vdout0_125ck1220 FIND v(dout0_125) AT=615.025n

.meas tran vdout0_126ck1220 FIND v(dout0_126) AT=615.025n

.meas tran vdout0_127ck1220 FIND v(dout0_127) AT=615.025n

.meas tran vdout0_128ck1220 FIND v(dout0_128) AT=615.025n

.meas tran vdout0_129ck1220 FIND v(dout0_129) AT=615.025n

.meas tran vdout0_130ck1220 FIND v(dout0_130) AT=615.025n

.meas tran vdout0_131ck1220 FIND v(dout0_131) AT=615.025n

.meas tran vdout0_132ck1220 FIND v(dout0_132) AT=615.025n

.meas tran vdout0_133ck1220 FIND v(dout0_133) AT=615.025n

.meas tran vdout0_134ck1220 FIND v(dout0_134) AT=615.025n

.meas tran vdout0_135ck1220 FIND v(dout0_135) AT=615.025n

.meas tran vdout0_136ck1220 FIND v(dout0_136) AT=615.025n

.meas tran vdout0_137ck1220 FIND v(dout0_137) AT=615.025n

.meas tran vdout0_138ck1220 FIND v(dout0_138) AT=615.025n

.meas tran vdout0_139ck1220 FIND v(dout0_139) AT=615.025n

.meas tran vdout0_140ck1220 FIND v(dout0_140) AT=615.025n

.meas tran vdout0_141ck1220 FIND v(dout0_141) AT=615.025n

.meas tran vdout0_142ck1220 FIND v(dout0_142) AT=615.025n

.meas tran vdout0_143ck1220 FIND v(dout0_143) AT=615.025n

.meas tran vdout0_144ck1220 FIND v(dout0_144) AT=615.025n

.meas tran vdout0_145ck1220 FIND v(dout0_145) AT=615.025n

.meas tran vdout0_146ck1220 FIND v(dout0_146) AT=615.025n

.meas tran vdout0_147ck1220 FIND v(dout0_147) AT=615.025n

.meas tran vdout0_148ck1220 FIND v(dout0_148) AT=615.025n

.meas tran vdout0_149ck1220 FIND v(dout0_149) AT=615.025n

.meas tran vdout0_150ck1220 FIND v(dout0_150) AT=615.025n

.meas tran vdout0_151ck1220 FIND v(dout0_151) AT=615.025n

.meas tran vdout0_152ck1220 FIND v(dout0_152) AT=615.025n

.meas tran vdout0_153ck1220 FIND v(dout0_153) AT=615.025n

.meas tran vdout0_154ck1220 FIND v(dout0_154) AT=615.025n

.meas tran vdout0_155ck1220 FIND v(dout0_155) AT=615.025n

.meas tran vdout0_156ck1220 FIND v(dout0_156) AT=615.025n

.meas tran vdout0_157ck1220 FIND v(dout0_157) AT=615.025n

.meas tran vdout0_158ck1220 FIND v(dout0_158) AT=615.025n

.meas tran vdout0_159ck1220 FIND v(dout0_159) AT=615.025n

.meas tran vdout0_160ck1220 FIND v(dout0_160) AT=615.025n

.meas tran vdout0_161ck1220 FIND v(dout0_161) AT=615.025n

.meas tran vdout0_162ck1220 FIND v(dout0_162) AT=615.025n

.meas tran vdout0_163ck1220 FIND v(dout0_163) AT=615.025n

.meas tran vdout0_164ck1220 FIND v(dout0_164) AT=615.025n

.meas tran vdout0_165ck1220 FIND v(dout0_165) AT=615.025n

.meas tran vdout0_166ck1220 FIND v(dout0_166) AT=615.025n

.meas tran vdout0_167ck1220 FIND v(dout0_167) AT=615.025n

.meas tran vdout0_168ck1220 FIND v(dout0_168) AT=615.025n

.meas tran vdout0_169ck1220 FIND v(dout0_169) AT=615.025n

.meas tran vdout0_170ck1220 FIND v(dout0_170) AT=615.025n

.meas tran vdout0_171ck1220 FIND v(dout0_171) AT=615.025n

.meas tran vdout0_172ck1220 FIND v(dout0_172) AT=615.025n

.meas tran vdout0_173ck1220 FIND v(dout0_173) AT=615.025n

.meas tran vdout0_174ck1220 FIND v(dout0_174) AT=615.025n

.meas tran vdout0_175ck1220 FIND v(dout0_175) AT=615.025n

.meas tran vdout0_176ck1220 FIND v(dout0_176) AT=615.025n

.meas tran vdout0_177ck1220 FIND v(dout0_177) AT=615.025n

.meas tran vdout0_178ck1220 FIND v(dout0_178) AT=615.025n

.meas tran vdout0_179ck1220 FIND v(dout0_179) AT=615.025n

.meas tran vdout0_180ck1220 FIND v(dout0_180) AT=615.025n

.meas tran vdout0_181ck1220 FIND v(dout0_181) AT=615.025n

.meas tran vdout0_182ck1220 FIND v(dout0_182) AT=615.025n

.meas tran vdout0_183ck1220 FIND v(dout0_183) AT=615.025n

.meas tran vdout0_184ck1220 FIND v(dout0_184) AT=615.025n

.meas tran vdout0_185ck1220 FIND v(dout0_185) AT=615.025n

.meas tran vdout0_186ck1220 FIND v(dout0_186) AT=615.025n

.meas tran vdout0_187ck1220 FIND v(dout0_187) AT=615.025n

.meas tran vdout0_188ck1220 FIND v(dout0_188) AT=615.025n

.meas tran vdout0_189ck1220 FIND v(dout0_189) AT=615.025n

.meas tran vdout0_190ck1220 FIND v(dout0_190) AT=615.025n

.meas tran vdout0_191ck1220 FIND v(dout0_191) AT=615.025n

.meas tran vdout0_192ck1220 FIND v(dout0_192) AT=615.025n

.meas tran vdout0_193ck1220 FIND v(dout0_193) AT=615.025n

.meas tran vdout0_194ck1220 FIND v(dout0_194) AT=615.025n

.meas tran vdout0_195ck1220 FIND v(dout0_195) AT=615.025n

.meas tran vdout0_196ck1220 FIND v(dout0_196) AT=615.025n

.meas tran vdout0_197ck1220 FIND v(dout0_197) AT=615.025n

.meas tran vdout0_198ck1220 FIND v(dout0_198) AT=615.025n

.meas tran vdout0_199ck1220 FIND v(dout0_199) AT=615.025n

.meas tran vdout0_200ck1220 FIND v(dout0_200) AT=615.025n

.meas tran vdout0_201ck1220 FIND v(dout0_201) AT=615.025n

.meas tran vdout0_202ck1220 FIND v(dout0_202) AT=615.025n

.meas tran vdout0_203ck1220 FIND v(dout0_203) AT=615.025n

.meas tran vdout0_204ck1220 FIND v(dout0_204) AT=615.025n

.meas tran vdout0_205ck1220 FIND v(dout0_205) AT=615.025n

.meas tran vdout0_206ck1220 FIND v(dout0_206) AT=615.025n

.meas tran vdout0_207ck1220 FIND v(dout0_207) AT=615.025n

.meas tran vdout0_208ck1220 FIND v(dout0_208) AT=615.025n

.meas tran vdout0_209ck1220 FIND v(dout0_209) AT=615.025n

.meas tran vdout0_210ck1220 FIND v(dout0_210) AT=615.025n

.meas tran vdout0_211ck1220 FIND v(dout0_211) AT=615.025n

.meas tran vdout0_212ck1220 FIND v(dout0_212) AT=615.025n

.meas tran vdout0_213ck1220 FIND v(dout0_213) AT=615.025n

.meas tran vdout0_214ck1220 FIND v(dout0_214) AT=615.025n

.meas tran vdout0_215ck1220 FIND v(dout0_215) AT=615.025n

.meas tran vdout0_216ck1220 FIND v(dout0_216) AT=615.025n

.meas tran vdout0_217ck1220 FIND v(dout0_217) AT=615.025n

.meas tran vdout0_218ck1220 FIND v(dout0_218) AT=615.025n

.meas tran vdout0_219ck1220 FIND v(dout0_219) AT=615.025n

.meas tran vdout0_220ck1220 FIND v(dout0_220) AT=615.025n

.meas tran vdout0_221ck1220 FIND v(dout0_221) AT=615.025n

.meas tran vdout0_222ck1220 FIND v(dout0_222) AT=615.025n

.meas tran vdout0_223ck1220 FIND v(dout0_223) AT=615.025n

.meas tran vdout0_224ck1220 FIND v(dout0_224) AT=615.025n

.meas tran vdout0_225ck1220 FIND v(dout0_225) AT=615.025n

.meas tran vdout0_226ck1220 FIND v(dout0_226) AT=615.025n

.meas tran vdout0_227ck1220 FIND v(dout0_227) AT=615.025n

.meas tran vdout0_228ck1220 FIND v(dout0_228) AT=615.025n

.meas tran vdout0_229ck1220 FIND v(dout0_229) AT=615.025n

.meas tran vdout0_230ck1220 FIND v(dout0_230) AT=615.025n

.meas tran vdout0_231ck1220 FIND v(dout0_231) AT=615.025n

.meas tran vdout0_232ck1220 FIND v(dout0_232) AT=615.025n

.meas tran vdout0_233ck1220 FIND v(dout0_233) AT=615.025n

.meas tran vdout0_234ck1220 FIND v(dout0_234) AT=615.025n

.meas tran vdout0_235ck1220 FIND v(dout0_235) AT=615.025n

.meas tran vdout0_236ck1220 FIND v(dout0_236) AT=615.025n

.meas tran vdout0_237ck1220 FIND v(dout0_237) AT=615.025n

.meas tran vdout0_238ck1220 FIND v(dout0_238) AT=615.025n

.meas tran vdout0_239ck1220 FIND v(dout0_239) AT=615.025n

.meas tran vdout0_240ck1220 FIND v(dout0_240) AT=615.025n

.meas tran vdout0_241ck1220 FIND v(dout0_241) AT=615.025n

.meas tran vdout0_242ck1220 FIND v(dout0_242) AT=615.025n

.meas tran vdout0_243ck1220 FIND v(dout0_243) AT=615.025n

.meas tran vdout0_244ck1220 FIND v(dout0_244) AT=615.025n

.meas tran vdout0_245ck1220 FIND v(dout0_245) AT=615.025n

.meas tran vdout0_246ck1220 FIND v(dout0_246) AT=615.025n

.meas tran vdout0_247ck1220 FIND v(dout0_247) AT=615.025n

.meas tran vdout0_248ck1220 FIND v(dout0_248) AT=615.025n

.meas tran vdout0_249ck1220 FIND v(dout0_249) AT=615.025n

.meas tran vdout0_250ck1220 FIND v(dout0_250) AT=615.025n

.meas tran vdout0_251ck1220 FIND v(dout0_251) AT=615.025n

.meas tran vdout0_252ck1220 FIND v(dout0_252) AT=615.025n

.meas tran vdout0_253ck1220 FIND v(dout0_253) AT=615.025n

.meas tran vdout0_254ck1220 FIND v(dout0_254) AT=615.025n

.meas tran vdout0_255ck1220 FIND v(dout0_255) AT=615.025n

.meas tran vdout0_0ck1240 FIND v(dout0_0) AT=625.025n

.meas tran vdout0_1ck1240 FIND v(dout0_1) AT=625.025n

.meas tran vdout0_2ck1240 FIND v(dout0_2) AT=625.025n

.meas tran vdout0_3ck1240 FIND v(dout0_3) AT=625.025n

.meas tran vdout0_4ck1240 FIND v(dout0_4) AT=625.025n

.meas tran vdout0_5ck1240 FIND v(dout0_5) AT=625.025n

.meas tran vdout0_6ck1240 FIND v(dout0_6) AT=625.025n

.meas tran vdout0_7ck1240 FIND v(dout0_7) AT=625.025n

.meas tran vdout0_8ck1240 FIND v(dout0_8) AT=625.025n

.meas tran vdout0_9ck1240 FIND v(dout0_9) AT=625.025n

.meas tran vdout0_10ck1240 FIND v(dout0_10) AT=625.025n

.meas tran vdout0_11ck1240 FIND v(dout0_11) AT=625.025n

.meas tran vdout0_12ck1240 FIND v(dout0_12) AT=625.025n

.meas tran vdout0_13ck1240 FIND v(dout0_13) AT=625.025n

.meas tran vdout0_14ck1240 FIND v(dout0_14) AT=625.025n

.meas tran vdout0_15ck1240 FIND v(dout0_15) AT=625.025n

.meas tran vdout0_16ck1240 FIND v(dout0_16) AT=625.025n

.meas tran vdout0_17ck1240 FIND v(dout0_17) AT=625.025n

.meas tran vdout0_18ck1240 FIND v(dout0_18) AT=625.025n

.meas tran vdout0_19ck1240 FIND v(dout0_19) AT=625.025n

.meas tran vdout0_20ck1240 FIND v(dout0_20) AT=625.025n

.meas tran vdout0_21ck1240 FIND v(dout0_21) AT=625.025n

.meas tran vdout0_22ck1240 FIND v(dout0_22) AT=625.025n

.meas tran vdout0_23ck1240 FIND v(dout0_23) AT=625.025n

.meas tran vdout0_24ck1240 FIND v(dout0_24) AT=625.025n

.meas tran vdout0_25ck1240 FIND v(dout0_25) AT=625.025n

.meas tran vdout0_26ck1240 FIND v(dout0_26) AT=625.025n

.meas tran vdout0_27ck1240 FIND v(dout0_27) AT=625.025n

.meas tran vdout0_28ck1240 FIND v(dout0_28) AT=625.025n

.meas tran vdout0_29ck1240 FIND v(dout0_29) AT=625.025n

.meas tran vdout0_30ck1240 FIND v(dout0_30) AT=625.025n

.meas tran vdout0_31ck1240 FIND v(dout0_31) AT=625.025n

.meas tran vdout0_32ck1240 FIND v(dout0_32) AT=625.025n

.meas tran vdout0_33ck1240 FIND v(dout0_33) AT=625.025n

.meas tran vdout0_34ck1240 FIND v(dout0_34) AT=625.025n

.meas tran vdout0_35ck1240 FIND v(dout0_35) AT=625.025n

.meas tran vdout0_36ck1240 FIND v(dout0_36) AT=625.025n

.meas tran vdout0_37ck1240 FIND v(dout0_37) AT=625.025n

.meas tran vdout0_38ck1240 FIND v(dout0_38) AT=625.025n

.meas tran vdout0_39ck1240 FIND v(dout0_39) AT=625.025n

.meas tran vdout0_40ck1240 FIND v(dout0_40) AT=625.025n

.meas tran vdout0_41ck1240 FIND v(dout0_41) AT=625.025n

.meas tran vdout0_42ck1240 FIND v(dout0_42) AT=625.025n

.meas tran vdout0_43ck1240 FIND v(dout0_43) AT=625.025n

.meas tran vdout0_44ck1240 FIND v(dout0_44) AT=625.025n

.meas tran vdout0_45ck1240 FIND v(dout0_45) AT=625.025n

.meas tran vdout0_46ck1240 FIND v(dout0_46) AT=625.025n

.meas tran vdout0_47ck1240 FIND v(dout0_47) AT=625.025n

.meas tran vdout0_48ck1240 FIND v(dout0_48) AT=625.025n

.meas tran vdout0_49ck1240 FIND v(dout0_49) AT=625.025n

.meas tran vdout0_50ck1240 FIND v(dout0_50) AT=625.025n

.meas tran vdout0_51ck1240 FIND v(dout0_51) AT=625.025n

.meas tran vdout0_52ck1240 FIND v(dout0_52) AT=625.025n

.meas tran vdout0_53ck1240 FIND v(dout0_53) AT=625.025n

.meas tran vdout0_54ck1240 FIND v(dout0_54) AT=625.025n

.meas tran vdout0_55ck1240 FIND v(dout0_55) AT=625.025n

.meas tran vdout0_56ck1240 FIND v(dout0_56) AT=625.025n

.meas tran vdout0_57ck1240 FIND v(dout0_57) AT=625.025n

.meas tran vdout0_58ck1240 FIND v(dout0_58) AT=625.025n

.meas tran vdout0_59ck1240 FIND v(dout0_59) AT=625.025n

.meas tran vdout0_60ck1240 FIND v(dout0_60) AT=625.025n

.meas tran vdout0_61ck1240 FIND v(dout0_61) AT=625.025n

.meas tran vdout0_62ck1240 FIND v(dout0_62) AT=625.025n

.meas tran vdout0_63ck1240 FIND v(dout0_63) AT=625.025n

.meas tran vdout0_64ck1240 FIND v(dout0_64) AT=625.025n

.meas tran vdout0_65ck1240 FIND v(dout0_65) AT=625.025n

.meas tran vdout0_66ck1240 FIND v(dout0_66) AT=625.025n

.meas tran vdout0_67ck1240 FIND v(dout0_67) AT=625.025n

.meas tran vdout0_68ck1240 FIND v(dout0_68) AT=625.025n

.meas tran vdout0_69ck1240 FIND v(dout0_69) AT=625.025n

.meas tran vdout0_70ck1240 FIND v(dout0_70) AT=625.025n

.meas tran vdout0_71ck1240 FIND v(dout0_71) AT=625.025n

.meas tran vdout0_72ck1240 FIND v(dout0_72) AT=625.025n

.meas tran vdout0_73ck1240 FIND v(dout0_73) AT=625.025n

.meas tran vdout0_74ck1240 FIND v(dout0_74) AT=625.025n

.meas tran vdout0_75ck1240 FIND v(dout0_75) AT=625.025n

.meas tran vdout0_76ck1240 FIND v(dout0_76) AT=625.025n

.meas tran vdout0_77ck1240 FIND v(dout0_77) AT=625.025n

.meas tran vdout0_78ck1240 FIND v(dout0_78) AT=625.025n

.meas tran vdout0_79ck1240 FIND v(dout0_79) AT=625.025n

.meas tran vdout0_80ck1240 FIND v(dout0_80) AT=625.025n

.meas tran vdout0_81ck1240 FIND v(dout0_81) AT=625.025n

.meas tran vdout0_82ck1240 FIND v(dout0_82) AT=625.025n

.meas tran vdout0_83ck1240 FIND v(dout0_83) AT=625.025n

.meas tran vdout0_84ck1240 FIND v(dout0_84) AT=625.025n

.meas tran vdout0_85ck1240 FIND v(dout0_85) AT=625.025n

.meas tran vdout0_86ck1240 FIND v(dout0_86) AT=625.025n

.meas tran vdout0_87ck1240 FIND v(dout0_87) AT=625.025n

.meas tran vdout0_88ck1240 FIND v(dout0_88) AT=625.025n

.meas tran vdout0_89ck1240 FIND v(dout0_89) AT=625.025n

.meas tran vdout0_90ck1240 FIND v(dout0_90) AT=625.025n

.meas tran vdout0_91ck1240 FIND v(dout0_91) AT=625.025n

.meas tran vdout0_92ck1240 FIND v(dout0_92) AT=625.025n

.meas tran vdout0_93ck1240 FIND v(dout0_93) AT=625.025n

.meas tran vdout0_94ck1240 FIND v(dout0_94) AT=625.025n

.meas tran vdout0_95ck1240 FIND v(dout0_95) AT=625.025n

.meas tran vdout0_96ck1240 FIND v(dout0_96) AT=625.025n

.meas tran vdout0_97ck1240 FIND v(dout0_97) AT=625.025n

.meas tran vdout0_98ck1240 FIND v(dout0_98) AT=625.025n

.meas tran vdout0_99ck1240 FIND v(dout0_99) AT=625.025n

.meas tran vdout0_100ck1240 FIND v(dout0_100) AT=625.025n

.meas tran vdout0_101ck1240 FIND v(dout0_101) AT=625.025n

.meas tran vdout0_102ck1240 FIND v(dout0_102) AT=625.025n

.meas tran vdout0_103ck1240 FIND v(dout0_103) AT=625.025n

.meas tran vdout0_104ck1240 FIND v(dout0_104) AT=625.025n

.meas tran vdout0_105ck1240 FIND v(dout0_105) AT=625.025n

.meas tran vdout0_106ck1240 FIND v(dout0_106) AT=625.025n

.meas tran vdout0_107ck1240 FIND v(dout0_107) AT=625.025n

.meas tran vdout0_108ck1240 FIND v(dout0_108) AT=625.025n

.meas tran vdout0_109ck1240 FIND v(dout0_109) AT=625.025n

.meas tran vdout0_110ck1240 FIND v(dout0_110) AT=625.025n

.meas tran vdout0_111ck1240 FIND v(dout0_111) AT=625.025n

.meas tran vdout0_112ck1240 FIND v(dout0_112) AT=625.025n

.meas tran vdout0_113ck1240 FIND v(dout0_113) AT=625.025n

.meas tran vdout0_114ck1240 FIND v(dout0_114) AT=625.025n

.meas tran vdout0_115ck1240 FIND v(dout0_115) AT=625.025n

.meas tran vdout0_116ck1240 FIND v(dout0_116) AT=625.025n

.meas tran vdout0_117ck1240 FIND v(dout0_117) AT=625.025n

.meas tran vdout0_118ck1240 FIND v(dout0_118) AT=625.025n

.meas tran vdout0_119ck1240 FIND v(dout0_119) AT=625.025n

.meas tran vdout0_120ck1240 FIND v(dout0_120) AT=625.025n

.meas tran vdout0_121ck1240 FIND v(dout0_121) AT=625.025n

.meas tran vdout0_122ck1240 FIND v(dout0_122) AT=625.025n

.meas tran vdout0_123ck1240 FIND v(dout0_123) AT=625.025n

.meas tran vdout0_124ck1240 FIND v(dout0_124) AT=625.025n

.meas tran vdout0_125ck1240 FIND v(dout0_125) AT=625.025n

.meas tran vdout0_126ck1240 FIND v(dout0_126) AT=625.025n

.meas tran vdout0_127ck1240 FIND v(dout0_127) AT=625.025n

.meas tran vdout0_128ck1240 FIND v(dout0_128) AT=625.025n

.meas tran vdout0_129ck1240 FIND v(dout0_129) AT=625.025n

.meas tran vdout0_130ck1240 FIND v(dout0_130) AT=625.025n

.meas tran vdout0_131ck1240 FIND v(dout0_131) AT=625.025n

.meas tran vdout0_132ck1240 FIND v(dout0_132) AT=625.025n

.meas tran vdout0_133ck1240 FIND v(dout0_133) AT=625.025n

.meas tran vdout0_134ck1240 FIND v(dout0_134) AT=625.025n

.meas tran vdout0_135ck1240 FIND v(dout0_135) AT=625.025n

.meas tran vdout0_136ck1240 FIND v(dout0_136) AT=625.025n

.meas tran vdout0_137ck1240 FIND v(dout0_137) AT=625.025n

.meas tran vdout0_138ck1240 FIND v(dout0_138) AT=625.025n

.meas tran vdout0_139ck1240 FIND v(dout0_139) AT=625.025n

.meas tran vdout0_140ck1240 FIND v(dout0_140) AT=625.025n

.meas tran vdout0_141ck1240 FIND v(dout0_141) AT=625.025n

.meas tran vdout0_142ck1240 FIND v(dout0_142) AT=625.025n

.meas tran vdout0_143ck1240 FIND v(dout0_143) AT=625.025n

.meas tran vdout0_144ck1240 FIND v(dout0_144) AT=625.025n

.meas tran vdout0_145ck1240 FIND v(dout0_145) AT=625.025n

.meas tran vdout0_146ck1240 FIND v(dout0_146) AT=625.025n

.meas tran vdout0_147ck1240 FIND v(dout0_147) AT=625.025n

.meas tran vdout0_148ck1240 FIND v(dout0_148) AT=625.025n

.meas tran vdout0_149ck1240 FIND v(dout0_149) AT=625.025n

.meas tran vdout0_150ck1240 FIND v(dout0_150) AT=625.025n

.meas tran vdout0_151ck1240 FIND v(dout0_151) AT=625.025n

.meas tran vdout0_152ck1240 FIND v(dout0_152) AT=625.025n

.meas tran vdout0_153ck1240 FIND v(dout0_153) AT=625.025n

.meas tran vdout0_154ck1240 FIND v(dout0_154) AT=625.025n

.meas tran vdout0_155ck1240 FIND v(dout0_155) AT=625.025n

.meas tran vdout0_156ck1240 FIND v(dout0_156) AT=625.025n

.meas tran vdout0_157ck1240 FIND v(dout0_157) AT=625.025n

.meas tran vdout0_158ck1240 FIND v(dout0_158) AT=625.025n

.meas tran vdout0_159ck1240 FIND v(dout0_159) AT=625.025n

.meas tran vdout0_160ck1240 FIND v(dout0_160) AT=625.025n

.meas tran vdout0_161ck1240 FIND v(dout0_161) AT=625.025n

.meas tran vdout0_162ck1240 FIND v(dout0_162) AT=625.025n

.meas tran vdout0_163ck1240 FIND v(dout0_163) AT=625.025n

.meas tran vdout0_164ck1240 FIND v(dout0_164) AT=625.025n

.meas tran vdout0_165ck1240 FIND v(dout0_165) AT=625.025n

.meas tran vdout0_166ck1240 FIND v(dout0_166) AT=625.025n

.meas tran vdout0_167ck1240 FIND v(dout0_167) AT=625.025n

.meas tran vdout0_168ck1240 FIND v(dout0_168) AT=625.025n

.meas tran vdout0_169ck1240 FIND v(dout0_169) AT=625.025n

.meas tran vdout0_170ck1240 FIND v(dout0_170) AT=625.025n

.meas tran vdout0_171ck1240 FIND v(dout0_171) AT=625.025n

.meas tran vdout0_172ck1240 FIND v(dout0_172) AT=625.025n

.meas tran vdout0_173ck1240 FIND v(dout0_173) AT=625.025n

.meas tran vdout0_174ck1240 FIND v(dout0_174) AT=625.025n

.meas tran vdout0_175ck1240 FIND v(dout0_175) AT=625.025n

.meas tran vdout0_176ck1240 FIND v(dout0_176) AT=625.025n

.meas tran vdout0_177ck1240 FIND v(dout0_177) AT=625.025n

.meas tran vdout0_178ck1240 FIND v(dout0_178) AT=625.025n

.meas tran vdout0_179ck1240 FIND v(dout0_179) AT=625.025n

.meas tran vdout0_180ck1240 FIND v(dout0_180) AT=625.025n

.meas tran vdout0_181ck1240 FIND v(dout0_181) AT=625.025n

.meas tran vdout0_182ck1240 FIND v(dout0_182) AT=625.025n

.meas tran vdout0_183ck1240 FIND v(dout0_183) AT=625.025n

.meas tran vdout0_184ck1240 FIND v(dout0_184) AT=625.025n

.meas tran vdout0_185ck1240 FIND v(dout0_185) AT=625.025n

.meas tran vdout0_186ck1240 FIND v(dout0_186) AT=625.025n

.meas tran vdout0_187ck1240 FIND v(dout0_187) AT=625.025n

.meas tran vdout0_188ck1240 FIND v(dout0_188) AT=625.025n

.meas tran vdout0_189ck1240 FIND v(dout0_189) AT=625.025n

.meas tran vdout0_190ck1240 FIND v(dout0_190) AT=625.025n

.meas tran vdout0_191ck1240 FIND v(dout0_191) AT=625.025n

.meas tran vdout0_192ck1240 FIND v(dout0_192) AT=625.025n

.meas tran vdout0_193ck1240 FIND v(dout0_193) AT=625.025n

.meas tran vdout0_194ck1240 FIND v(dout0_194) AT=625.025n

.meas tran vdout0_195ck1240 FIND v(dout0_195) AT=625.025n

.meas tran vdout0_196ck1240 FIND v(dout0_196) AT=625.025n

.meas tran vdout0_197ck1240 FIND v(dout0_197) AT=625.025n

.meas tran vdout0_198ck1240 FIND v(dout0_198) AT=625.025n

.meas tran vdout0_199ck1240 FIND v(dout0_199) AT=625.025n

.meas tran vdout0_200ck1240 FIND v(dout0_200) AT=625.025n

.meas tran vdout0_201ck1240 FIND v(dout0_201) AT=625.025n

.meas tran vdout0_202ck1240 FIND v(dout0_202) AT=625.025n

.meas tran vdout0_203ck1240 FIND v(dout0_203) AT=625.025n

.meas tran vdout0_204ck1240 FIND v(dout0_204) AT=625.025n

.meas tran vdout0_205ck1240 FIND v(dout0_205) AT=625.025n

.meas tran vdout0_206ck1240 FIND v(dout0_206) AT=625.025n

.meas tran vdout0_207ck1240 FIND v(dout0_207) AT=625.025n

.meas tran vdout0_208ck1240 FIND v(dout0_208) AT=625.025n

.meas tran vdout0_209ck1240 FIND v(dout0_209) AT=625.025n

.meas tran vdout0_210ck1240 FIND v(dout0_210) AT=625.025n

.meas tran vdout0_211ck1240 FIND v(dout0_211) AT=625.025n

.meas tran vdout0_212ck1240 FIND v(dout0_212) AT=625.025n

.meas tran vdout0_213ck1240 FIND v(dout0_213) AT=625.025n

.meas tran vdout0_214ck1240 FIND v(dout0_214) AT=625.025n

.meas tran vdout0_215ck1240 FIND v(dout0_215) AT=625.025n

.meas tran vdout0_216ck1240 FIND v(dout0_216) AT=625.025n

.meas tran vdout0_217ck1240 FIND v(dout0_217) AT=625.025n

.meas tran vdout0_218ck1240 FIND v(dout0_218) AT=625.025n

.meas tran vdout0_219ck1240 FIND v(dout0_219) AT=625.025n

.meas tran vdout0_220ck1240 FIND v(dout0_220) AT=625.025n

.meas tran vdout0_221ck1240 FIND v(dout0_221) AT=625.025n

.meas tran vdout0_222ck1240 FIND v(dout0_222) AT=625.025n

.meas tran vdout0_223ck1240 FIND v(dout0_223) AT=625.025n

.meas tran vdout0_224ck1240 FIND v(dout0_224) AT=625.025n

.meas tran vdout0_225ck1240 FIND v(dout0_225) AT=625.025n

.meas tran vdout0_226ck1240 FIND v(dout0_226) AT=625.025n

.meas tran vdout0_227ck1240 FIND v(dout0_227) AT=625.025n

.meas tran vdout0_228ck1240 FIND v(dout0_228) AT=625.025n

.meas tran vdout0_229ck1240 FIND v(dout0_229) AT=625.025n

.meas tran vdout0_230ck1240 FIND v(dout0_230) AT=625.025n

.meas tran vdout0_231ck1240 FIND v(dout0_231) AT=625.025n

.meas tran vdout0_232ck1240 FIND v(dout0_232) AT=625.025n

.meas tran vdout0_233ck1240 FIND v(dout0_233) AT=625.025n

.meas tran vdout0_234ck1240 FIND v(dout0_234) AT=625.025n

.meas tran vdout0_235ck1240 FIND v(dout0_235) AT=625.025n

.meas tran vdout0_236ck1240 FIND v(dout0_236) AT=625.025n

.meas tran vdout0_237ck1240 FIND v(dout0_237) AT=625.025n

.meas tran vdout0_238ck1240 FIND v(dout0_238) AT=625.025n

.meas tran vdout0_239ck1240 FIND v(dout0_239) AT=625.025n

.meas tran vdout0_240ck1240 FIND v(dout0_240) AT=625.025n

.meas tran vdout0_241ck1240 FIND v(dout0_241) AT=625.025n

.meas tran vdout0_242ck1240 FIND v(dout0_242) AT=625.025n

.meas tran vdout0_243ck1240 FIND v(dout0_243) AT=625.025n

.meas tran vdout0_244ck1240 FIND v(dout0_244) AT=625.025n

.meas tran vdout0_245ck1240 FIND v(dout0_245) AT=625.025n

.meas tran vdout0_246ck1240 FIND v(dout0_246) AT=625.025n

.meas tran vdout0_247ck1240 FIND v(dout0_247) AT=625.025n

.meas tran vdout0_248ck1240 FIND v(dout0_248) AT=625.025n

.meas tran vdout0_249ck1240 FIND v(dout0_249) AT=625.025n

.meas tran vdout0_250ck1240 FIND v(dout0_250) AT=625.025n

.meas tran vdout0_251ck1240 FIND v(dout0_251) AT=625.025n

.meas tran vdout0_252ck1240 FIND v(dout0_252) AT=625.025n

.meas tran vdout0_253ck1240 FIND v(dout0_253) AT=625.025n

.meas tran vdout0_254ck1240 FIND v(dout0_254) AT=625.025n

.meas tran vdout0_255ck1240 FIND v(dout0_255) AT=625.025n

.meas tran vdout0_0ck1250 FIND v(dout0_0) AT=630.025n

.meas tran vdout0_1ck1250 FIND v(dout0_1) AT=630.025n

.meas tran vdout0_2ck1250 FIND v(dout0_2) AT=630.025n

.meas tran vdout0_3ck1250 FIND v(dout0_3) AT=630.025n

.meas tran vdout0_4ck1250 FIND v(dout0_4) AT=630.025n

.meas tran vdout0_5ck1250 FIND v(dout0_5) AT=630.025n

.meas tran vdout0_6ck1250 FIND v(dout0_6) AT=630.025n

.meas tran vdout0_7ck1250 FIND v(dout0_7) AT=630.025n

.meas tran vdout0_8ck1250 FIND v(dout0_8) AT=630.025n

.meas tran vdout0_9ck1250 FIND v(dout0_9) AT=630.025n

.meas tran vdout0_10ck1250 FIND v(dout0_10) AT=630.025n

.meas tran vdout0_11ck1250 FIND v(dout0_11) AT=630.025n

.meas tran vdout0_12ck1250 FIND v(dout0_12) AT=630.025n

.meas tran vdout0_13ck1250 FIND v(dout0_13) AT=630.025n

.meas tran vdout0_14ck1250 FIND v(dout0_14) AT=630.025n

.meas tran vdout0_15ck1250 FIND v(dout0_15) AT=630.025n

.meas tran vdout0_16ck1250 FIND v(dout0_16) AT=630.025n

.meas tran vdout0_17ck1250 FIND v(dout0_17) AT=630.025n

.meas tran vdout0_18ck1250 FIND v(dout0_18) AT=630.025n

.meas tran vdout0_19ck1250 FIND v(dout0_19) AT=630.025n

.meas tran vdout0_20ck1250 FIND v(dout0_20) AT=630.025n

.meas tran vdout0_21ck1250 FIND v(dout0_21) AT=630.025n

.meas tran vdout0_22ck1250 FIND v(dout0_22) AT=630.025n

.meas tran vdout0_23ck1250 FIND v(dout0_23) AT=630.025n

.meas tran vdout0_24ck1250 FIND v(dout0_24) AT=630.025n

.meas tran vdout0_25ck1250 FIND v(dout0_25) AT=630.025n

.meas tran vdout0_26ck1250 FIND v(dout0_26) AT=630.025n

.meas tran vdout0_27ck1250 FIND v(dout0_27) AT=630.025n

.meas tran vdout0_28ck1250 FIND v(dout0_28) AT=630.025n

.meas tran vdout0_29ck1250 FIND v(dout0_29) AT=630.025n

.meas tran vdout0_30ck1250 FIND v(dout0_30) AT=630.025n

.meas tran vdout0_31ck1250 FIND v(dout0_31) AT=630.025n

.meas tran vdout0_32ck1250 FIND v(dout0_32) AT=630.025n

.meas tran vdout0_33ck1250 FIND v(dout0_33) AT=630.025n

.meas tran vdout0_34ck1250 FIND v(dout0_34) AT=630.025n

.meas tran vdout0_35ck1250 FIND v(dout0_35) AT=630.025n

.meas tran vdout0_36ck1250 FIND v(dout0_36) AT=630.025n

.meas tran vdout0_37ck1250 FIND v(dout0_37) AT=630.025n

.meas tran vdout0_38ck1250 FIND v(dout0_38) AT=630.025n

.meas tran vdout0_39ck1250 FIND v(dout0_39) AT=630.025n

.meas tran vdout0_40ck1250 FIND v(dout0_40) AT=630.025n

.meas tran vdout0_41ck1250 FIND v(dout0_41) AT=630.025n

.meas tran vdout0_42ck1250 FIND v(dout0_42) AT=630.025n

.meas tran vdout0_43ck1250 FIND v(dout0_43) AT=630.025n

.meas tran vdout0_44ck1250 FIND v(dout0_44) AT=630.025n

.meas tran vdout0_45ck1250 FIND v(dout0_45) AT=630.025n

.meas tran vdout0_46ck1250 FIND v(dout0_46) AT=630.025n

.meas tran vdout0_47ck1250 FIND v(dout0_47) AT=630.025n

.meas tran vdout0_48ck1250 FIND v(dout0_48) AT=630.025n

.meas tran vdout0_49ck1250 FIND v(dout0_49) AT=630.025n

.meas tran vdout0_50ck1250 FIND v(dout0_50) AT=630.025n

.meas tran vdout0_51ck1250 FIND v(dout0_51) AT=630.025n

.meas tran vdout0_52ck1250 FIND v(dout0_52) AT=630.025n

.meas tran vdout0_53ck1250 FIND v(dout0_53) AT=630.025n

.meas tran vdout0_54ck1250 FIND v(dout0_54) AT=630.025n

.meas tran vdout0_55ck1250 FIND v(dout0_55) AT=630.025n

.meas tran vdout0_56ck1250 FIND v(dout0_56) AT=630.025n

.meas tran vdout0_57ck1250 FIND v(dout0_57) AT=630.025n

.meas tran vdout0_58ck1250 FIND v(dout0_58) AT=630.025n

.meas tran vdout0_59ck1250 FIND v(dout0_59) AT=630.025n

.meas tran vdout0_60ck1250 FIND v(dout0_60) AT=630.025n

.meas tran vdout0_61ck1250 FIND v(dout0_61) AT=630.025n

.meas tran vdout0_62ck1250 FIND v(dout0_62) AT=630.025n

.meas tran vdout0_63ck1250 FIND v(dout0_63) AT=630.025n

.meas tran vdout0_64ck1250 FIND v(dout0_64) AT=630.025n

.meas tran vdout0_65ck1250 FIND v(dout0_65) AT=630.025n

.meas tran vdout0_66ck1250 FIND v(dout0_66) AT=630.025n

.meas tran vdout0_67ck1250 FIND v(dout0_67) AT=630.025n

.meas tran vdout0_68ck1250 FIND v(dout0_68) AT=630.025n

.meas tran vdout0_69ck1250 FIND v(dout0_69) AT=630.025n

.meas tran vdout0_70ck1250 FIND v(dout0_70) AT=630.025n

.meas tran vdout0_71ck1250 FIND v(dout0_71) AT=630.025n

.meas tran vdout0_72ck1250 FIND v(dout0_72) AT=630.025n

.meas tran vdout0_73ck1250 FIND v(dout0_73) AT=630.025n

.meas tran vdout0_74ck1250 FIND v(dout0_74) AT=630.025n

.meas tran vdout0_75ck1250 FIND v(dout0_75) AT=630.025n

.meas tran vdout0_76ck1250 FIND v(dout0_76) AT=630.025n

.meas tran vdout0_77ck1250 FIND v(dout0_77) AT=630.025n

.meas tran vdout0_78ck1250 FIND v(dout0_78) AT=630.025n

.meas tran vdout0_79ck1250 FIND v(dout0_79) AT=630.025n

.meas tran vdout0_80ck1250 FIND v(dout0_80) AT=630.025n

.meas tran vdout0_81ck1250 FIND v(dout0_81) AT=630.025n

.meas tran vdout0_82ck1250 FIND v(dout0_82) AT=630.025n

.meas tran vdout0_83ck1250 FIND v(dout0_83) AT=630.025n

.meas tran vdout0_84ck1250 FIND v(dout0_84) AT=630.025n

.meas tran vdout0_85ck1250 FIND v(dout0_85) AT=630.025n

.meas tran vdout0_86ck1250 FIND v(dout0_86) AT=630.025n

.meas tran vdout0_87ck1250 FIND v(dout0_87) AT=630.025n

.meas tran vdout0_88ck1250 FIND v(dout0_88) AT=630.025n

.meas tran vdout0_89ck1250 FIND v(dout0_89) AT=630.025n

.meas tran vdout0_90ck1250 FIND v(dout0_90) AT=630.025n

.meas tran vdout0_91ck1250 FIND v(dout0_91) AT=630.025n

.meas tran vdout0_92ck1250 FIND v(dout0_92) AT=630.025n

.meas tran vdout0_93ck1250 FIND v(dout0_93) AT=630.025n

.meas tran vdout0_94ck1250 FIND v(dout0_94) AT=630.025n

.meas tran vdout0_95ck1250 FIND v(dout0_95) AT=630.025n

.meas tran vdout0_96ck1250 FIND v(dout0_96) AT=630.025n

.meas tran vdout0_97ck1250 FIND v(dout0_97) AT=630.025n

.meas tran vdout0_98ck1250 FIND v(dout0_98) AT=630.025n

.meas tran vdout0_99ck1250 FIND v(dout0_99) AT=630.025n

.meas tran vdout0_100ck1250 FIND v(dout0_100) AT=630.025n

.meas tran vdout0_101ck1250 FIND v(dout0_101) AT=630.025n

.meas tran vdout0_102ck1250 FIND v(dout0_102) AT=630.025n

.meas tran vdout0_103ck1250 FIND v(dout0_103) AT=630.025n

.meas tran vdout0_104ck1250 FIND v(dout0_104) AT=630.025n

.meas tran vdout0_105ck1250 FIND v(dout0_105) AT=630.025n

.meas tran vdout0_106ck1250 FIND v(dout0_106) AT=630.025n

.meas tran vdout0_107ck1250 FIND v(dout0_107) AT=630.025n

.meas tran vdout0_108ck1250 FIND v(dout0_108) AT=630.025n

.meas tran vdout0_109ck1250 FIND v(dout0_109) AT=630.025n

.meas tran vdout0_110ck1250 FIND v(dout0_110) AT=630.025n

.meas tran vdout0_111ck1250 FIND v(dout0_111) AT=630.025n

.meas tran vdout0_112ck1250 FIND v(dout0_112) AT=630.025n

.meas tran vdout0_113ck1250 FIND v(dout0_113) AT=630.025n

.meas tran vdout0_114ck1250 FIND v(dout0_114) AT=630.025n

.meas tran vdout0_115ck1250 FIND v(dout0_115) AT=630.025n

.meas tran vdout0_116ck1250 FIND v(dout0_116) AT=630.025n

.meas tran vdout0_117ck1250 FIND v(dout0_117) AT=630.025n

.meas tran vdout0_118ck1250 FIND v(dout0_118) AT=630.025n

.meas tran vdout0_119ck1250 FIND v(dout0_119) AT=630.025n

.meas tran vdout0_120ck1250 FIND v(dout0_120) AT=630.025n

.meas tran vdout0_121ck1250 FIND v(dout0_121) AT=630.025n

.meas tran vdout0_122ck1250 FIND v(dout0_122) AT=630.025n

.meas tran vdout0_123ck1250 FIND v(dout0_123) AT=630.025n

.meas tran vdout0_124ck1250 FIND v(dout0_124) AT=630.025n

.meas tran vdout0_125ck1250 FIND v(dout0_125) AT=630.025n

.meas tran vdout0_126ck1250 FIND v(dout0_126) AT=630.025n

.meas tran vdout0_127ck1250 FIND v(dout0_127) AT=630.025n

.meas tran vdout0_128ck1250 FIND v(dout0_128) AT=630.025n

.meas tran vdout0_129ck1250 FIND v(dout0_129) AT=630.025n

.meas tran vdout0_130ck1250 FIND v(dout0_130) AT=630.025n

.meas tran vdout0_131ck1250 FIND v(dout0_131) AT=630.025n

.meas tran vdout0_132ck1250 FIND v(dout0_132) AT=630.025n

.meas tran vdout0_133ck1250 FIND v(dout0_133) AT=630.025n

.meas tran vdout0_134ck1250 FIND v(dout0_134) AT=630.025n

.meas tran vdout0_135ck1250 FIND v(dout0_135) AT=630.025n

.meas tran vdout0_136ck1250 FIND v(dout0_136) AT=630.025n

.meas tran vdout0_137ck1250 FIND v(dout0_137) AT=630.025n

.meas tran vdout0_138ck1250 FIND v(dout0_138) AT=630.025n

.meas tran vdout0_139ck1250 FIND v(dout0_139) AT=630.025n

.meas tran vdout0_140ck1250 FIND v(dout0_140) AT=630.025n

.meas tran vdout0_141ck1250 FIND v(dout0_141) AT=630.025n

.meas tran vdout0_142ck1250 FIND v(dout0_142) AT=630.025n

.meas tran vdout0_143ck1250 FIND v(dout0_143) AT=630.025n

.meas tran vdout0_144ck1250 FIND v(dout0_144) AT=630.025n

.meas tran vdout0_145ck1250 FIND v(dout0_145) AT=630.025n

.meas tran vdout0_146ck1250 FIND v(dout0_146) AT=630.025n

.meas tran vdout0_147ck1250 FIND v(dout0_147) AT=630.025n

.meas tran vdout0_148ck1250 FIND v(dout0_148) AT=630.025n

.meas tran vdout0_149ck1250 FIND v(dout0_149) AT=630.025n

.meas tran vdout0_150ck1250 FIND v(dout0_150) AT=630.025n

.meas tran vdout0_151ck1250 FIND v(dout0_151) AT=630.025n

.meas tran vdout0_152ck1250 FIND v(dout0_152) AT=630.025n

.meas tran vdout0_153ck1250 FIND v(dout0_153) AT=630.025n

.meas tran vdout0_154ck1250 FIND v(dout0_154) AT=630.025n

.meas tran vdout0_155ck1250 FIND v(dout0_155) AT=630.025n

.meas tran vdout0_156ck1250 FIND v(dout0_156) AT=630.025n

.meas tran vdout0_157ck1250 FIND v(dout0_157) AT=630.025n

.meas tran vdout0_158ck1250 FIND v(dout0_158) AT=630.025n

.meas tran vdout0_159ck1250 FIND v(dout0_159) AT=630.025n

.meas tran vdout0_160ck1250 FIND v(dout0_160) AT=630.025n

.meas tran vdout0_161ck1250 FIND v(dout0_161) AT=630.025n

.meas tran vdout0_162ck1250 FIND v(dout0_162) AT=630.025n

.meas tran vdout0_163ck1250 FIND v(dout0_163) AT=630.025n

.meas tran vdout0_164ck1250 FIND v(dout0_164) AT=630.025n

.meas tran vdout0_165ck1250 FIND v(dout0_165) AT=630.025n

.meas tran vdout0_166ck1250 FIND v(dout0_166) AT=630.025n

.meas tran vdout0_167ck1250 FIND v(dout0_167) AT=630.025n

.meas tran vdout0_168ck1250 FIND v(dout0_168) AT=630.025n

.meas tran vdout0_169ck1250 FIND v(dout0_169) AT=630.025n

.meas tran vdout0_170ck1250 FIND v(dout0_170) AT=630.025n

.meas tran vdout0_171ck1250 FIND v(dout0_171) AT=630.025n

.meas tran vdout0_172ck1250 FIND v(dout0_172) AT=630.025n

.meas tran vdout0_173ck1250 FIND v(dout0_173) AT=630.025n

.meas tran vdout0_174ck1250 FIND v(dout0_174) AT=630.025n

.meas tran vdout0_175ck1250 FIND v(dout0_175) AT=630.025n

.meas tran vdout0_176ck1250 FIND v(dout0_176) AT=630.025n

.meas tran vdout0_177ck1250 FIND v(dout0_177) AT=630.025n

.meas tran vdout0_178ck1250 FIND v(dout0_178) AT=630.025n

.meas tran vdout0_179ck1250 FIND v(dout0_179) AT=630.025n

.meas tran vdout0_180ck1250 FIND v(dout0_180) AT=630.025n

.meas tran vdout0_181ck1250 FIND v(dout0_181) AT=630.025n

.meas tran vdout0_182ck1250 FIND v(dout0_182) AT=630.025n

.meas tran vdout0_183ck1250 FIND v(dout0_183) AT=630.025n

.meas tran vdout0_184ck1250 FIND v(dout0_184) AT=630.025n

.meas tran vdout0_185ck1250 FIND v(dout0_185) AT=630.025n

.meas tran vdout0_186ck1250 FIND v(dout0_186) AT=630.025n

.meas tran vdout0_187ck1250 FIND v(dout0_187) AT=630.025n

.meas tran vdout0_188ck1250 FIND v(dout0_188) AT=630.025n

.meas tran vdout0_189ck1250 FIND v(dout0_189) AT=630.025n

.meas tran vdout0_190ck1250 FIND v(dout0_190) AT=630.025n

.meas tran vdout0_191ck1250 FIND v(dout0_191) AT=630.025n

.meas tran vdout0_192ck1250 FIND v(dout0_192) AT=630.025n

.meas tran vdout0_193ck1250 FIND v(dout0_193) AT=630.025n

.meas tran vdout0_194ck1250 FIND v(dout0_194) AT=630.025n

.meas tran vdout0_195ck1250 FIND v(dout0_195) AT=630.025n

.meas tran vdout0_196ck1250 FIND v(dout0_196) AT=630.025n

.meas tran vdout0_197ck1250 FIND v(dout0_197) AT=630.025n

.meas tran vdout0_198ck1250 FIND v(dout0_198) AT=630.025n

.meas tran vdout0_199ck1250 FIND v(dout0_199) AT=630.025n

.meas tran vdout0_200ck1250 FIND v(dout0_200) AT=630.025n

.meas tran vdout0_201ck1250 FIND v(dout0_201) AT=630.025n

.meas tran vdout0_202ck1250 FIND v(dout0_202) AT=630.025n

.meas tran vdout0_203ck1250 FIND v(dout0_203) AT=630.025n

.meas tran vdout0_204ck1250 FIND v(dout0_204) AT=630.025n

.meas tran vdout0_205ck1250 FIND v(dout0_205) AT=630.025n

.meas tran vdout0_206ck1250 FIND v(dout0_206) AT=630.025n

.meas tran vdout0_207ck1250 FIND v(dout0_207) AT=630.025n

.meas tran vdout0_208ck1250 FIND v(dout0_208) AT=630.025n

.meas tran vdout0_209ck1250 FIND v(dout0_209) AT=630.025n

.meas tran vdout0_210ck1250 FIND v(dout0_210) AT=630.025n

.meas tran vdout0_211ck1250 FIND v(dout0_211) AT=630.025n

.meas tran vdout0_212ck1250 FIND v(dout0_212) AT=630.025n

.meas tran vdout0_213ck1250 FIND v(dout0_213) AT=630.025n

.meas tran vdout0_214ck1250 FIND v(dout0_214) AT=630.025n

.meas tran vdout0_215ck1250 FIND v(dout0_215) AT=630.025n

.meas tran vdout0_216ck1250 FIND v(dout0_216) AT=630.025n

.meas tran vdout0_217ck1250 FIND v(dout0_217) AT=630.025n

.meas tran vdout0_218ck1250 FIND v(dout0_218) AT=630.025n

.meas tran vdout0_219ck1250 FIND v(dout0_219) AT=630.025n

.meas tran vdout0_220ck1250 FIND v(dout0_220) AT=630.025n

.meas tran vdout0_221ck1250 FIND v(dout0_221) AT=630.025n

.meas tran vdout0_222ck1250 FIND v(dout0_222) AT=630.025n

.meas tran vdout0_223ck1250 FIND v(dout0_223) AT=630.025n

.meas tran vdout0_224ck1250 FIND v(dout0_224) AT=630.025n

.meas tran vdout0_225ck1250 FIND v(dout0_225) AT=630.025n

.meas tran vdout0_226ck1250 FIND v(dout0_226) AT=630.025n

.meas tran vdout0_227ck1250 FIND v(dout0_227) AT=630.025n

.meas tran vdout0_228ck1250 FIND v(dout0_228) AT=630.025n

.meas tran vdout0_229ck1250 FIND v(dout0_229) AT=630.025n

.meas tran vdout0_230ck1250 FIND v(dout0_230) AT=630.025n

.meas tran vdout0_231ck1250 FIND v(dout0_231) AT=630.025n

.meas tran vdout0_232ck1250 FIND v(dout0_232) AT=630.025n

.meas tran vdout0_233ck1250 FIND v(dout0_233) AT=630.025n

.meas tran vdout0_234ck1250 FIND v(dout0_234) AT=630.025n

.meas tran vdout0_235ck1250 FIND v(dout0_235) AT=630.025n

.meas tran vdout0_236ck1250 FIND v(dout0_236) AT=630.025n

.meas tran vdout0_237ck1250 FIND v(dout0_237) AT=630.025n

.meas tran vdout0_238ck1250 FIND v(dout0_238) AT=630.025n

.meas tran vdout0_239ck1250 FIND v(dout0_239) AT=630.025n

.meas tran vdout0_240ck1250 FIND v(dout0_240) AT=630.025n

.meas tran vdout0_241ck1250 FIND v(dout0_241) AT=630.025n

.meas tran vdout0_242ck1250 FIND v(dout0_242) AT=630.025n

.meas tran vdout0_243ck1250 FIND v(dout0_243) AT=630.025n

.meas tran vdout0_244ck1250 FIND v(dout0_244) AT=630.025n

.meas tran vdout0_245ck1250 FIND v(dout0_245) AT=630.025n

.meas tran vdout0_246ck1250 FIND v(dout0_246) AT=630.025n

.meas tran vdout0_247ck1250 FIND v(dout0_247) AT=630.025n

.meas tran vdout0_248ck1250 FIND v(dout0_248) AT=630.025n

.meas tran vdout0_249ck1250 FIND v(dout0_249) AT=630.025n

.meas tran vdout0_250ck1250 FIND v(dout0_250) AT=630.025n

.meas tran vdout0_251ck1250 FIND v(dout0_251) AT=630.025n

.meas tran vdout0_252ck1250 FIND v(dout0_252) AT=630.025n

.meas tran vdout0_253ck1250 FIND v(dout0_253) AT=630.025n

.meas tran vdout0_254ck1250 FIND v(dout0_254) AT=630.025n

.meas tran vdout0_255ck1250 FIND v(dout0_255) AT=630.025n

.meas tran vdout0_0ck1260 FIND v(dout0_0) AT=635.025n

.meas tran vdout0_1ck1260 FIND v(dout0_1) AT=635.025n

.meas tran vdout0_2ck1260 FIND v(dout0_2) AT=635.025n

.meas tran vdout0_3ck1260 FIND v(dout0_3) AT=635.025n

.meas tran vdout0_4ck1260 FIND v(dout0_4) AT=635.025n

.meas tran vdout0_5ck1260 FIND v(dout0_5) AT=635.025n

.meas tran vdout0_6ck1260 FIND v(dout0_6) AT=635.025n

.meas tran vdout0_7ck1260 FIND v(dout0_7) AT=635.025n

.meas tran vdout0_8ck1260 FIND v(dout0_8) AT=635.025n

.meas tran vdout0_9ck1260 FIND v(dout0_9) AT=635.025n

.meas tran vdout0_10ck1260 FIND v(dout0_10) AT=635.025n

.meas tran vdout0_11ck1260 FIND v(dout0_11) AT=635.025n

.meas tran vdout0_12ck1260 FIND v(dout0_12) AT=635.025n

.meas tran vdout0_13ck1260 FIND v(dout0_13) AT=635.025n

.meas tran vdout0_14ck1260 FIND v(dout0_14) AT=635.025n

.meas tran vdout0_15ck1260 FIND v(dout0_15) AT=635.025n

.meas tran vdout0_16ck1260 FIND v(dout0_16) AT=635.025n

.meas tran vdout0_17ck1260 FIND v(dout0_17) AT=635.025n

.meas tran vdout0_18ck1260 FIND v(dout0_18) AT=635.025n

.meas tran vdout0_19ck1260 FIND v(dout0_19) AT=635.025n

.meas tran vdout0_20ck1260 FIND v(dout0_20) AT=635.025n

.meas tran vdout0_21ck1260 FIND v(dout0_21) AT=635.025n

.meas tran vdout0_22ck1260 FIND v(dout0_22) AT=635.025n

.meas tran vdout0_23ck1260 FIND v(dout0_23) AT=635.025n

.meas tran vdout0_24ck1260 FIND v(dout0_24) AT=635.025n

.meas tran vdout0_25ck1260 FIND v(dout0_25) AT=635.025n

.meas tran vdout0_26ck1260 FIND v(dout0_26) AT=635.025n

.meas tran vdout0_27ck1260 FIND v(dout0_27) AT=635.025n

.meas tran vdout0_28ck1260 FIND v(dout0_28) AT=635.025n

.meas tran vdout0_29ck1260 FIND v(dout0_29) AT=635.025n

.meas tran vdout0_30ck1260 FIND v(dout0_30) AT=635.025n

.meas tran vdout0_31ck1260 FIND v(dout0_31) AT=635.025n

.meas tran vdout0_32ck1260 FIND v(dout0_32) AT=635.025n

.meas tran vdout0_33ck1260 FIND v(dout0_33) AT=635.025n

.meas tran vdout0_34ck1260 FIND v(dout0_34) AT=635.025n

.meas tran vdout0_35ck1260 FIND v(dout0_35) AT=635.025n

.meas tran vdout0_36ck1260 FIND v(dout0_36) AT=635.025n

.meas tran vdout0_37ck1260 FIND v(dout0_37) AT=635.025n

.meas tran vdout0_38ck1260 FIND v(dout0_38) AT=635.025n

.meas tran vdout0_39ck1260 FIND v(dout0_39) AT=635.025n

.meas tran vdout0_40ck1260 FIND v(dout0_40) AT=635.025n

.meas tran vdout0_41ck1260 FIND v(dout0_41) AT=635.025n

.meas tran vdout0_42ck1260 FIND v(dout0_42) AT=635.025n

.meas tran vdout0_43ck1260 FIND v(dout0_43) AT=635.025n

.meas tran vdout0_44ck1260 FIND v(dout0_44) AT=635.025n

.meas tran vdout0_45ck1260 FIND v(dout0_45) AT=635.025n

.meas tran vdout0_46ck1260 FIND v(dout0_46) AT=635.025n

.meas tran vdout0_47ck1260 FIND v(dout0_47) AT=635.025n

.meas tran vdout0_48ck1260 FIND v(dout0_48) AT=635.025n

.meas tran vdout0_49ck1260 FIND v(dout0_49) AT=635.025n

.meas tran vdout0_50ck1260 FIND v(dout0_50) AT=635.025n

.meas tran vdout0_51ck1260 FIND v(dout0_51) AT=635.025n

.meas tran vdout0_52ck1260 FIND v(dout0_52) AT=635.025n

.meas tran vdout0_53ck1260 FIND v(dout0_53) AT=635.025n

.meas tran vdout0_54ck1260 FIND v(dout0_54) AT=635.025n

.meas tran vdout0_55ck1260 FIND v(dout0_55) AT=635.025n

.meas tran vdout0_56ck1260 FIND v(dout0_56) AT=635.025n

.meas tran vdout0_57ck1260 FIND v(dout0_57) AT=635.025n

.meas tran vdout0_58ck1260 FIND v(dout0_58) AT=635.025n

.meas tran vdout0_59ck1260 FIND v(dout0_59) AT=635.025n

.meas tran vdout0_60ck1260 FIND v(dout0_60) AT=635.025n

.meas tran vdout0_61ck1260 FIND v(dout0_61) AT=635.025n

.meas tran vdout0_62ck1260 FIND v(dout0_62) AT=635.025n

.meas tran vdout0_63ck1260 FIND v(dout0_63) AT=635.025n

.meas tran vdout0_64ck1260 FIND v(dout0_64) AT=635.025n

.meas tran vdout0_65ck1260 FIND v(dout0_65) AT=635.025n

.meas tran vdout0_66ck1260 FIND v(dout0_66) AT=635.025n

.meas tran vdout0_67ck1260 FIND v(dout0_67) AT=635.025n

.meas tran vdout0_68ck1260 FIND v(dout0_68) AT=635.025n

.meas tran vdout0_69ck1260 FIND v(dout0_69) AT=635.025n

.meas tran vdout0_70ck1260 FIND v(dout0_70) AT=635.025n

.meas tran vdout0_71ck1260 FIND v(dout0_71) AT=635.025n

.meas tran vdout0_72ck1260 FIND v(dout0_72) AT=635.025n

.meas tran vdout0_73ck1260 FIND v(dout0_73) AT=635.025n

.meas tran vdout0_74ck1260 FIND v(dout0_74) AT=635.025n

.meas tran vdout0_75ck1260 FIND v(dout0_75) AT=635.025n

.meas tran vdout0_76ck1260 FIND v(dout0_76) AT=635.025n

.meas tran vdout0_77ck1260 FIND v(dout0_77) AT=635.025n

.meas tran vdout0_78ck1260 FIND v(dout0_78) AT=635.025n

.meas tran vdout0_79ck1260 FIND v(dout0_79) AT=635.025n

.meas tran vdout0_80ck1260 FIND v(dout0_80) AT=635.025n

.meas tran vdout0_81ck1260 FIND v(dout0_81) AT=635.025n

.meas tran vdout0_82ck1260 FIND v(dout0_82) AT=635.025n

.meas tran vdout0_83ck1260 FIND v(dout0_83) AT=635.025n

.meas tran vdout0_84ck1260 FIND v(dout0_84) AT=635.025n

.meas tran vdout0_85ck1260 FIND v(dout0_85) AT=635.025n

.meas tran vdout0_86ck1260 FIND v(dout0_86) AT=635.025n

.meas tran vdout0_87ck1260 FIND v(dout0_87) AT=635.025n

.meas tran vdout0_88ck1260 FIND v(dout0_88) AT=635.025n

.meas tran vdout0_89ck1260 FIND v(dout0_89) AT=635.025n

.meas tran vdout0_90ck1260 FIND v(dout0_90) AT=635.025n

.meas tran vdout0_91ck1260 FIND v(dout0_91) AT=635.025n

.meas tran vdout0_92ck1260 FIND v(dout0_92) AT=635.025n

.meas tran vdout0_93ck1260 FIND v(dout0_93) AT=635.025n

.meas tran vdout0_94ck1260 FIND v(dout0_94) AT=635.025n

.meas tran vdout0_95ck1260 FIND v(dout0_95) AT=635.025n

.meas tran vdout0_96ck1260 FIND v(dout0_96) AT=635.025n

.meas tran vdout0_97ck1260 FIND v(dout0_97) AT=635.025n

.meas tran vdout0_98ck1260 FIND v(dout0_98) AT=635.025n

.meas tran vdout0_99ck1260 FIND v(dout0_99) AT=635.025n

.meas tran vdout0_100ck1260 FIND v(dout0_100) AT=635.025n

.meas tran vdout0_101ck1260 FIND v(dout0_101) AT=635.025n

.meas tran vdout0_102ck1260 FIND v(dout0_102) AT=635.025n

.meas tran vdout0_103ck1260 FIND v(dout0_103) AT=635.025n

.meas tran vdout0_104ck1260 FIND v(dout0_104) AT=635.025n

.meas tran vdout0_105ck1260 FIND v(dout0_105) AT=635.025n

.meas tran vdout0_106ck1260 FIND v(dout0_106) AT=635.025n

.meas tran vdout0_107ck1260 FIND v(dout0_107) AT=635.025n

.meas tran vdout0_108ck1260 FIND v(dout0_108) AT=635.025n

.meas tran vdout0_109ck1260 FIND v(dout0_109) AT=635.025n

.meas tran vdout0_110ck1260 FIND v(dout0_110) AT=635.025n

.meas tran vdout0_111ck1260 FIND v(dout0_111) AT=635.025n

.meas tran vdout0_112ck1260 FIND v(dout0_112) AT=635.025n

.meas tran vdout0_113ck1260 FIND v(dout0_113) AT=635.025n

.meas tran vdout0_114ck1260 FIND v(dout0_114) AT=635.025n

.meas tran vdout0_115ck1260 FIND v(dout0_115) AT=635.025n

.meas tran vdout0_116ck1260 FIND v(dout0_116) AT=635.025n

.meas tran vdout0_117ck1260 FIND v(dout0_117) AT=635.025n

.meas tran vdout0_118ck1260 FIND v(dout0_118) AT=635.025n

.meas tran vdout0_119ck1260 FIND v(dout0_119) AT=635.025n

.meas tran vdout0_120ck1260 FIND v(dout0_120) AT=635.025n

.meas tran vdout0_121ck1260 FIND v(dout0_121) AT=635.025n

.meas tran vdout0_122ck1260 FIND v(dout0_122) AT=635.025n

.meas tran vdout0_123ck1260 FIND v(dout0_123) AT=635.025n

.meas tran vdout0_124ck1260 FIND v(dout0_124) AT=635.025n

.meas tran vdout0_125ck1260 FIND v(dout0_125) AT=635.025n

.meas tran vdout0_126ck1260 FIND v(dout0_126) AT=635.025n

.meas tran vdout0_127ck1260 FIND v(dout0_127) AT=635.025n

.meas tran vdout0_128ck1260 FIND v(dout0_128) AT=635.025n

.meas tran vdout0_129ck1260 FIND v(dout0_129) AT=635.025n

.meas tran vdout0_130ck1260 FIND v(dout0_130) AT=635.025n

.meas tran vdout0_131ck1260 FIND v(dout0_131) AT=635.025n

.meas tran vdout0_132ck1260 FIND v(dout0_132) AT=635.025n

.meas tran vdout0_133ck1260 FIND v(dout0_133) AT=635.025n

.meas tran vdout0_134ck1260 FIND v(dout0_134) AT=635.025n

.meas tran vdout0_135ck1260 FIND v(dout0_135) AT=635.025n

.meas tran vdout0_136ck1260 FIND v(dout0_136) AT=635.025n

.meas tran vdout0_137ck1260 FIND v(dout0_137) AT=635.025n

.meas tran vdout0_138ck1260 FIND v(dout0_138) AT=635.025n

.meas tran vdout0_139ck1260 FIND v(dout0_139) AT=635.025n

.meas tran vdout0_140ck1260 FIND v(dout0_140) AT=635.025n

.meas tran vdout0_141ck1260 FIND v(dout0_141) AT=635.025n

.meas tran vdout0_142ck1260 FIND v(dout0_142) AT=635.025n

.meas tran vdout0_143ck1260 FIND v(dout0_143) AT=635.025n

.meas tran vdout0_144ck1260 FIND v(dout0_144) AT=635.025n

.meas tran vdout0_145ck1260 FIND v(dout0_145) AT=635.025n

.meas tran vdout0_146ck1260 FIND v(dout0_146) AT=635.025n

.meas tran vdout0_147ck1260 FIND v(dout0_147) AT=635.025n

.meas tran vdout0_148ck1260 FIND v(dout0_148) AT=635.025n

.meas tran vdout0_149ck1260 FIND v(dout0_149) AT=635.025n

.meas tran vdout0_150ck1260 FIND v(dout0_150) AT=635.025n

.meas tran vdout0_151ck1260 FIND v(dout0_151) AT=635.025n

.meas tran vdout0_152ck1260 FIND v(dout0_152) AT=635.025n

.meas tran vdout0_153ck1260 FIND v(dout0_153) AT=635.025n

.meas tran vdout0_154ck1260 FIND v(dout0_154) AT=635.025n

.meas tran vdout0_155ck1260 FIND v(dout0_155) AT=635.025n

.meas tran vdout0_156ck1260 FIND v(dout0_156) AT=635.025n

.meas tran vdout0_157ck1260 FIND v(dout0_157) AT=635.025n

.meas tran vdout0_158ck1260 FIND v(dout0_158) AT=635.025n

.meas tran vdout0_159ck1260 FIND v(dout0_159) AT=635.025n

.meas tran vdout0_160ck1260 FIND v(dout0_160) AT=635.025n

.meas tran vdout0_161ck1260 FIND v(dout0_161) AT=635.025n

.meas tran vdout0_162ck1260 FIND v(dout0_162) AT=635.025n

.meas tran vdout0_163ck1260 FIND v(dout0_163) AT=635.025n

.meas tran vdout0_164ck1260 FIND v(dout0_164) AT=635.025n

.meas tran vdout0_165ck1260 FIND v(dout0_165) AT=635.025n

.meas tran vdout0_166ck1260 FIND v(dout0_166) AT=635.025n

.meas tran vdout0_167ck1260 FIND v(dout0_167) AT=635.025n

.meas tran vdout0_168ck1260 FIND v(dout0_168) AT=635.025n

.meas tran vdout0_169ck1260 FIND v(dout0_169) AT=635.025n

.meas tran vdout0_170ck1260 FIND v(dout0_170) AT=635.025n

.meas tran vdout0_171ck1260 FIND v(dout0_171) AT=635.025n

.meas tran vdout0_172ck1260 FIND v(dout0_172) AT=635.025n

.meas tran vdout0_173ck1260 FIND v(dout0_173) AT=635.025n

.meas tran vdout0_174ck1260 FIND v(dout0_174) AT=635.025n

.meas tran vdout0_175ck1260 FIND v(dout0_175) AT=635.025n

.meas tran vdout0_176ck1260 FIND v(dout0_176) AT=635.025n

.meas tran vdout0_177ck1260 FIND v(dout0_177) AT=635.025n

.meas tran vdout0_178ck1260 FIND v(dout0_178) AT=635.025n

.meas tran vdout0_179ck1260 FIND v(dout0_179) AT=635.025n

.meas tran vdout0_180ck1260 FIND v(dout0_180) AT=635.025n

.meas tran vdout0_181ck1260 FIND v(dout0_181) AT=635.025n

.meas tran vdout0_182ck1260 FIND v(dout0_182) AT=635.025n

.meas tran vdout0_183ck1260 FIND v(dout0_183) AT=635.025n

.meas tran vdout0_184ck1260 FIND v(dout0_184) AT=635.025n

.meas tran vdout0_185ck1260 FIND v(dout0_185) AT=635.025n

.meas tran vdout0_186ck1260 FIND v(dout0_186) AT=635.025n

.meas tran vdout0_187ck1260 FIND v(dout0_187) AT=635.025n

.meas tran vdout0_188ck1260 FIND v(dout0_188) AT=635.025n

.meas tran vdout0_189ck1260 FIND v(dout0_189) AT=635.025n

.meas tran vdout0_190ck1260 FIND v(dout0_190) AT=635.025n

.meas tran vdout0_191ck1260 FIND v(dout0_191) AT=635.025n

.meas tran vdout0_192ck1260 FIND v(dout0_192) AT=635.025n

.meas tran vdout0_193ck1260 FIND v(dout0_193) AT=635.025n

.meas tran vdout0_194ck1260 FIND v(dout0_194) AT=635.025n

.meas tran vdout0_195ck1260 FIND v(dout0_195) AT=635.025n

.meas tran vdout0_196ck1260 FIND v(dout0_196) AT=635.025n

.meas tran vdout0_197ck1260 FIND v(dout0_197) AT=635.025n

.meas tran vdout0_198ck1260 FIND v(dout0_198) AT=635.025n

.meas tran vdout0_199ck1260 FIND v(dout0_199) AT=635.025n

.meas tran vdout0_200ck1260 FIND v(dout0_200) AT=635.025n

.meas tran vdout0_201ck1260 FIND v(dout0_201) AT=635.025n

.meas tran vdout0_202ck1260 FIND v(dout0_202) AT=635.025n

.meas tran vdout0_203ck1260 FIND v(dout0_203) AT=635.025n

.meas tran vdout0_204ck1260 FIND v(dout0_204) AT=635.025n

.meas tran vdout0_205ck1260 FIND v(dout0_205) AT=635.025n

.meas tran vdout0_206ck1260 FIND v(dout0_206) AT=635.025n

.meas tran vdout0_207ck1260 FIND v(dout0_207) AT=635.025n

.meas tran vdout0_208ck1260 FIND v(dout0_208) AT=635.025n

.meas tran vdout0_209ck1260 FIND v(dout0_209) AT=635.025n

.meas tran vdout0_210ck1260 FIND v(dout0_210) AT=635.025n

.meas tran vdout0_211ck1260 FIND v(dout0_211) AT=635.025n

.meas tran vdout0_212ck1260 FIND v(dout0_212) AT=635.025n

.meas tran vdout0_213ck1260 FIND v(dout0_213) AT=635.025n

.meas tran vdout0_214ck1260 FIND v(dout0_214) AT=635.025n

.meas tran vdout0_215ck1260 FIND v(dout0_215) AT=635.025n

.meas tran vdout0_216ck1260 FIND v(dout0_216) AT=635.025n

.meas tran vdout0_217ck1260 FIND v(dout0_217) AT=635.025n

.meas tran vdout0_218ck1260 FIND v(dout0_218) AT=635.025n

.meas tran vdout0_219ck1260 FIND v(dout0_219) AT=635.025n

.meas tran vdout0_220ck1260 FIND v(dout0_220) AT=635.025n

.meas tran vdout0_221ck1260 FIND v(dout0_221) AT=635.025n

.meas tran vdout0_222ck1260 FIND v(dout0_222) AT=635.025n

.meas tran vdout0_223ck1260 FIND v(dout0_223) AT=635.025n

.meas tran vdout0_224ck1260 FIND v(dout0_224) AT=635.025n

.meas tran vdout0_225ck1260 FIND v(dout0_225) AT=635.025n

.meas tran vdout0_226ck1260 FIND v(dout0_226) AT=635.025n

.meas tran vdout0_227ck1260 FIND v(dout0_227) AT=635.025n

.meas tran vdout0_228ck1260 FIND v(dout0_228) AT=635.025n

.meas tran vdout0_229ck1260 FIND v(dout0_229) AT=635.025n

.meas tran vdout0_230ck1260 FIND v(dout0_230) AT=635.025n

.meas tran vdout0_231ck1260 FIND v(dout0_231) AT=635.025n

.meas tran vdout0_232ck1260 FIND v(dout0_232) AT=635.025n

.meas tran vdout0_233ck1260 FIND v(dout0_233) AT=635.025n

.meas tran vdout0_234ck1260 FIND v(dout0_234) AT=635.025n

.meas tran vdout0_235ck1260 FIND v(dout0_235) AT=635.025n

.meas tran vdout0_236ck1260 FIND v(dout0_236) AT=635.025n

.meas tran vdout0_237ck1260 FIND v(dout0_237) AT=635.025n

.meas tran vdout0_238ck1260 FIND v(dout0_238) AT=635.025n

.meas tran vdout0_239ck1260 FIND v(dout0_239) AT=635.025n

.meas tran vdout0_240ck1260 FIND v(dout0_240) AT=635.025n

.meas tran vdout0_241ck1260 FIND v(dout0_241) AT=635.025n

.meas tran vdout0_242ck1260 FIND v(dout0_242) AT=635.025n

.meas tran vdout0_243ck1260 FIND v(dout0_243) AT=635.025n

.meas tran vdout0_244ck1260 FIND v(dout0_244) AT=635.025n

.meas tran vdout0_245ck1260 FIND v(dout0_245) AT=635.025n

.meas tran vdout0_246ck1260 FIND v(dout0_246) AT=635.025n

.meas tran vdout0_247ck1260 FIND v(dout0_247) AT=635.025n

.meas tran vdout0_248ck1260 FIND v(dout0_248) AT=635.025n

.meas tran vdout0_249ck1260 FIND v(dout0_249) AT=635.025n

.meas tran vdout0_250ck1260 FIND v(dout0_250) AT=635.025n

.meas tran vdout0_251ck1260 FIND v(dout0_251) AT=635.025n

.meas tran vdout0_252ck1260 FIND v(dout0_252) AT=635.025n

.meas tran vdout0_253ck1260 FIND v(dout0_253) AT=635.025n

.meas tran vdout0_254ck1260 FIND v(dout0_254) AT=635.025n

.meas tran vdout0_255ck1260 FIND v(dout0_255) AT=635.025n

.meas tran vdout0_0ck1280 FIND v(dout0_0) AT=645.025n

.meas tran vdout0_1ck1280 FIND v(dout0_1) AT=645.025n

.meas tran vdout0_2ck1280 FIND v(dout0_2) AT=645.025n

.meas tran vdout0_3ck1280 FIND v(dout0_3) AT=645.025n

.meas tran vdout0_4ck1280 FIND v(dout0_4) AT=645.025n

.meas tran vdout0_5ck1280 FIND v(dout0_5) AT=645.025n

.meas tran vdout0_6ck1280 FIND v(dout0_6) AT=645.025n

.meas tran vdout0_7ck1280 FIND v(dout0_7) AT=645.025n

.meas tran vdout0_8ck1280 FIND v(dout0_8) AT=645.025n

.meas tran vdout0_9ck1280 FIND v(dout0_9) AT=645.025n

.meas tran vdout0_10ck1280 FIND v(dout0_10) AT=645.025n

.meas tran vdout0_11ck1280 FIND v(dout0_11) AT=645.025n

.meas tran vdout0_12ck1280 FIND v(dout0_12) AT=645.025n

.meas tran vdout0_13ck1280 FIND v(dout0_13) AT=645.025n

.meas tran vdout0_14ck1280 FIND v(dout0_14) AT=645.025n

.meas tran vdout0_15ck1280 FIND v(dout0_15) AT=645.025n

.meas tran vdout0_16ck1280 FIND v(dout0_16) AT=645.025n

.meas tran vdout0_17ck1280 FIND v(dout0_17) AT=645.025n

.meas tran vdout0_18ck1280 FIND v(dout0_18) AT=645.025n

.meas tran vdout0_19ck1280 FIND v(dout0_19) AT=645.025n

.meas tran vdout0_20ck1280 FIND v(dout0_20) AT=645.025n

.meas tran vdout0_21ck1280 FIND v(dout0_21) AT=645.025n

.meas tran vdout0_22ck1280 FIND v(dout0_22) AT=645.025n

.meas tran vdout0_23ck1280 FIND v(dout0_23) AT=645.025n

.meas tran vdout0_24ck1280 FIND v(dout0_24) AT=645.025n

.meas tran vdout0_25ck1280 FIND v(dout0_25) AT=645.025n

.meas tran vdout0_26ck1280 FIND v(dout0_26) AT=645.025n

.meas tran vdout0_27ck1280 FIND v(dout0_27) AT=645.025n

.meas tran vdout0_28ck1280 FIND v(dout0_28) AT=645.025n

.meas tran vdout0_29ck1280 FIND v(dout0_29) AT=645.025n

.meas tran vdout0_30ck1280 FIND v(dout0_30) AT=645.025n

.meas tran vdout0_31ck1280 FIND v(dout0_31) AT=645.025n

.meas tran vdout0_32ck1280 FIND v(dout0_32) AT=645.025n

.meas tran vdout0_33ck1280 FIND v(dout0_33) AT=645.025n

.meas tran vdout0_34ck1280 FIND v(dout0_34) AT=645.025n

.meas tran vdout0_35ck1280 FIND v(dout0_35) AT=645.025n

.meas tran vdout0_36ck1280 FIND v(dout0_36) AT=645.025n

.meas tran vdout0_37ck1280 FIND v(dout0_37) AT=645.025n

.meas tran vdout0_38ck1280 FIND v(dout0_38) AT=645.025n

.meas tran vdout0_39ck1280 FIND v(dout0_39) AT=645.025n

.meas tran vdout0_40ck1280 FIND v(dout0_40) AT=645.025n

.meas tran vdout0_41ck1280 FIND v(dout0_41) AT=645.025n

.meas tran vdout0_42ck1280 FIND v(dout0_42) AT=645.025n

.meas tran vdout0_43ck1280 FIND v(dout0_43) AT=645.025n

.meas tran vdout0_44ck1280 FIND v(dout0_44) AT=645.025n

.meas tran vdout0_45ck1280 FIND v(dout0_45) AT=645.025n

.meas tran vdout0_46ck1280 FIND v(dout0_46) AT=645.025n

.meas tran vdout0_47ck1280 FIND v(dout0_47) AT=645.025n

.meas tran vdout0_48ck1280 FIND v(dout0_48) AT=645.025n

.meas tran vdout0_49ck1280 FIND v(dout0_49) AT=645.025n

.meas tran vdout0_50ck1280 FIND v(dout0_50) AT=645.025n

.meas tran vdout0_51ck1280 FIND v(dout0_51) AT=645.025n

.meas tran vdout0_52ck1280 FIND v(dout0_52) AT=645.025n

.meas tran vdout0_53ck1280 FIND v(dout0_53) AT=645.025n

.meas tran vdout0_54ck1280 FIND v(dout0_54) AT=645.025n

.meas tran vdout0_55ck1280 FIND v(dout0_55) AT=645.025n

.meas tran vdout0_56ck1280 FIND v(dout0_56) AT=645.025n

.meas tran vdout0_57ck1280 FIND v(dout0_57) AT=645.025n

.meas tran vdout0_58ck1280 FIND v(dout0_58) AT=645.025n

.meas tran vdout0_59ck1280 FIND v(dout0_59) AT=645.025n

.meas tran vdout0_60ck1280 FIND v(dout0_60) AT=645.025n

.meas tran vdout0_61ck1280 FIND v(dout0_61) AT=645.025n

.meas tran vdout0_62ck1280 FIND v(dout0_62) AT=645.025n

.meas tran vdout0_63ck1280 FIND v(dout0_63) AT=645.025n

.meas tran vdout0_64ck1280 FIND v(dout0_64) AT=645.025n

.meas tran vdout0_65ck1280 FIND v(dout0_65) AT=645.025n

.meas tran vdout0_66ck1280 FIND v(dout0_66) AT=645.025n

.meas tran vdout0_67ck1280 FIND v(dout0_67) AT=645.025n

.meas tran vdout0_68ck1280 FIND v(dout0_68) AT=645.025n

.meas tran vdout0_69ck1280 FIND v(dout0_69) AT=645.025n

.meas tran vdout0_70ck1280 FIND v(dout0_70) AT=645.025n

.meas tran vdout0_71ck1280 FIND v(dout0_71) AT=645.025n

.meas tran vdout0_72ck1280 FIND v(dout0_72) AT=645.025n

.meas tran vdout0_73ck1280 FIND v(dout0_73) AT=645.025n

.meas tran vdout0_74ck1280 FIND v(dout0_74) AT=645.025n

.meas tran vdout0_75ck1280 FIND v(dout0_75) AT=645.025n

.meas tran vdout0_76ck1280 FIND v(dout0_76) AT=645.025n

.meas tran vdout0_77ck1280 FIND v(dout0_77) AT=645.025n

.meas tran vdout0_78ck1280 FIND v(dout0_78) AT=645.025n

.meas tran vdout0_79ck1280 FIND v(dout0_79) AT=645.025n

.meas tran vdout0_80ck1280 FIND v(dout0_80) AT=645.025n

.meas tran vdout0_81ck1280 FIND v(dout0_81) AT=645.025n

.meas tran vdout0_82ck1280 FIND v(dout0_82) AT=645.025n

.meas tran vdout0_83ck1280 FIND v(dout0_83) AT=645.025n

.meas tran vdout0_84ck1280 FIND v(dout0_84) AT=645.025n

.meas tran vdout0_85ck1280 FIND v(dout0_85) AT=645.025n

.meas tran vdout0_86ck1280 FIND v(dout0_86) AT=645.025n

.meas tran vdout0_87ck1280 FIND v(dout0_87) AT=645.025n

.meas tran vdout0_88ck1280 FIND v(dout0_88) AT=645.025n

.meas tran vdout0_89ck1280 FIND v(dout0_89) AT=645.025n

.meas tran vdout0_90ck1280 FIND v(dout0_90) AT=645.025n

.meas tran vdout0_91ck1280 FIND v(dout0_91) AT=645.025n

.meas tran vdout0_92ck1280 FIND v(dout0_92) AT=645.025n

.meas tran vdout0_93ck1280 FIND v(dout0_93) AT=645.025n

.meas tran vdout0_94ck1280 FIND v(dout0_94) AT=645.025n

.meas tran vdout0_95ck1280 FIND v(dout0_95) AT=645.025n

.meas tran vdout0_96ck1280 FIND v(dout0_96) AT=645.025n

.meas tran vdout0_97ck1280 FIND v(dout0_97) AT=645.025n

.meas tran vdout0_98ck1280 FIND v(dout0_98) AT=645.025n

.meas tran vdout0_99ck1280 FIND v(dout0_99) AT=645.025n

.meas tran vdout0_100ck1280 FIND v(dout0_100) AT=645.025n

.meas tran vdout0_101ck1280 FIND v(dout0_101) AT=645.025n

.meas tran vdout0_102ck1280 FIND v(dout0_102) AT=645.025n

.meas tran vdout0_103ck1280 FIND v(dout0_103) AT=645.025n

.meas tran vdout0_104ck1280 FIND v(dout0_104) AT=645.025n

.meas tran vdout0_105ck1280 FIND v(dout0_105) AT=645.025n

.meas tran vdout0_106ck1280 FIND v(dout0_106) AT=645.025n

.meas tran vdout0_107ck1280 FIND v(dout0_107) AT=645.025n

.meas tran vdout0_108ck1280 FIND v(dout0_108) AT=645.025n

.meas tran vdout0_109ck1280 FIND v(dout0_109) AT=645.025n

.meas tran vdout0_110ck1280 FIND v(dout0_110) AT=645.025n

.meas tran vdout0_111ck1280 FIND v(dout0_111) AT=645.025n

.meas tran vdout0_112ck1280 FIND v(dout0_112) AT=645.025n

.meas tran vdout0_113ck1280 FIND v(dout0_113) AT=645.025n

.meas tran vdout0_114ck1280 FIND v(dout0_114) AT=645.025n

.meas tran vdout0_115ck1280 FIND v(dout0_115) AT=645.025n

.meas tran vdout0_116ck1280 FIND v(dout0_116) AT=645.025n

.meas tran vdout0_117ck1280 FIND v(dout0_117) AT=645.025n

.meas tran vdout0_118ck1280 FIND v(dout0_118) AT=645.025n

.meas tran vdout0_119ck1280 FIND v(dout0_119) AT=645.025n

.meas tran vdout0_120ck1280 FIND v(dout0_120) AT=645.025n

.meas tran vdout0_121ck1280 FIND v(dout0_121) AT=645.025n

.meas tran vdout0_122ck1280 FIND v(dout0_122) AT=645.025n

.meas tran vdout0_123ck1280 FIND v(dout0_123) AT=645.025n

.meas tran vdout0_124ck1280 FIND v(dout0_124) AT=645.025n

.meas tran vdout0_125ck1280 FIND v(dout0_125) AT=645.025n

.meas tran vdout0_126ck1280 FIND v(dout0_126) AT=645.025n

.meas tran vdout0_127ck1280 FIND v(dout0_127) AT=645.025n

.meas tran vdout0_128ck1280 FIND v(dout0_128) AT=645.025n

.meas tran vdout0_129ck1280 FIND v(dout0_129) AT=645.025n

.meas tran vdout0_130ck1280 FIND v(dout0_130) AT=645.025n

.meas tran vdout0_131ck1280 FIND v(dout0_131) AT=645.025n

.meas tran vdout0_132ck1280 FIND v(dout0_132) AT=645.025n

.meas tran vdout0_133ck1280 FIND v(dout0_133) AT=645.025n

.meas tran vdout0_134ck1280 FIND v(dout0_134) AT=645.025n

.meas tran vdout0_135ck1280 FIND v(dout0_135) AT=645.025n

.meas tran vdout0_136ck1280 FIND v(dout0_136) AT=645.025n

.meas tran vdout0_137ck1280 FIND v(dout0_137) AT=645.025n

.meas tran vdout0_138ck1280 FIND v(dout0_138) AT=645.025n

.meas tran vdout0_139ck1280 FIND v(dout0_139) AT=645.025n

.meas tran vdout0_140ck1280 FIND v(dout0_140) AT=645.025n

.meas tran vdout0_141ck1280 FIND v(dout0_141) AT=645.025n

.meas tran vdout0_142ck1280 FIND v(dout0_142) AT=645.025n

.meas tran vdout0_143ck1280 FIND v(dout0_143) AT=645.025n

.meas tran vdout0_144ck1280 FIND v(dout0_144) AT=645.025n

.meas tran vdout0_145ck1280 FIND v(dout0_145) AT=645.025n

.meas tran vdout0_146ck1280 FIND v(dout0_146) AT=645.025n

.meas tran vdout0_147ck1280 FIND v(dout0_147) AT=645.025n

.meas tran vdout0_148ck1280 FIND v(dout0_148) AT=645.025n

.meas tran vdout0_149ck1280 FIND v(dout0_149) AT=645.025n

.meas tran vdout0_150ck1280 FIND v(dout0_150) AT=645.025n

.meas tran vdout0_151ck1280 FIND v(dout0_151) AT=645.025n

.meas tran vdout0_152ck1280 FIND v(dout0_152) AT=645.025n

.meas tran vdout0_153ck1280 FIND v(dout0_153) AT=645.025n

.meas tran vdout0_154ck1280 FIND v(dout0_154) AT=645.025n

.meas tran vdout0_155ck1280 FIND v(dout0_155) AT=645.025n

.meas tran vdout0_156ck1280 FIND v(dout0_156) AT=645.025n

.meas tran vdout0_157ck1280 FIND v(dout0_157) AT=645.025n

.meas tran vdout0_158ck1280 FIND v(dout0_158) AT=645.025n

.meas tran vdout0_159ck1280 FIND v(dout0_159) AT=645.025n

.meas tran vdout0_160ck1280 FIND v(dout0_160) AT=645.025n

.meas tran vdout0_161ck1280 FIND v(dout0_161) AT=645.025n

.meas tran vdout0_162ck1280 FIND v(dout0_162) AT=645.025n

.meas tran vdout0_163ck1280 FIND v(dout0_163) AT=645.025n

.meas tran vdout0_164ck1280 FIND v(dout0_164) AT=645.025n

.meas tran vdout0_165ck1280 FIND v(dout0_165) AT=645.025n

.meas tran vdout0_166ck1280 FIND v(dout0_166) AT=645.025n

.meas tran vdout0_167ck1280 FIND v(dout0_167) AT=645.025n

.meas tran vdout0_168ck1280 FIND v(dout0_168) AT=645.025n

.meas tran vdout0_169ck1280 FIND v(dout0_169) AT=645.025n

.meas tran vdout0_170ck1280 FIND v(dout0_170) AT=645.025n

.meas tran vdout0_171ck1280 FIND v(dout0_171) AT=645.025n

.meas tran vdout0_172ck1280 FIND v(dout0_172) AT=645.025n

.meas tran vdout0_173ck1280 FIND v(dout0_173) AT=645.025n

.meas tran vdout0_174ck1280 FIND v(dout0_174) AT=645.025n

.meas tran vdout0_175ck1280 FIND v(dout0_175) AT=645.025n

.meas tran vdout0_176ck1280 FIND v(dout0_176) AT=645.025n

.meas tran vdout0_177ck1280 FIND v(dout0_177) AT=645.025n

.meas tran vdout0_178ck1280 FIND v(dout0_178) AT=645.025n

.meas tran vdout0_179ck1280 FIND v(dout0_179) AT=645.025n

.meas tran vdout0_180ck1280 FIND v(dout0_180) AT=645.025n

.meas tran vdout0_181ck1280 FIND v(dout0_181) AT=645.025n

.meas tran vdout0_182ck1280 FIND v(dout0_182) AT=645.025n

.meas tran vdout0_183ck1280 FIND v(dout0_183) AT=645.025n

.meas tran vdout0_184ck1280 FIND v(dout0_184) AT=645.025n

.meas tran vdout0_185ck1280 FIND v(dout0_185) AT=645.025n

.meas tran vdout0_186ck1280 FIND v(dout0_186) AT=645.025n

.meas tran vdout0_187ck1280 FIND v(dout0_187) AT=645.025n

.meas tran vdout0_188ck1280 FIND v(dout0_188) AT=645.025n

.meas tran vdout0_189ck1280 FIND v(dout0_189) AT=645.025n

.meas tran vdout0_190ck1280 FIND v(dout0_190) AT=645.025n

.meas tran vdout0_191ck1280 FIND v(dout0_191) AT=645.025n

.meas tran vdout0_192ck1280 FIND v(dout0_192) AT=645.025n

.meas tran vdout0_193ck1280 FIND v(dout0_193) AT=645.025n

.meas tran vdout0_194ck1280 FIND v(dout0_194) AT=645.025n

.meas tran vdout0_195ck1280 FIND v(dout0_195) AT=645.025n

.meas tran vdout0_196ck1280 FIND v(dout0_196) AT=645.025n

.meas tran vdout0_197ck1280 FIND v(dout0_197) AT=645.025n

.meas tran vdout0_198ck1280 FIND v(dout0_198) AT=645.025n

.meas tran vdout0_199ck1280 FIND v(dout0_199) AT=645.025n

.meas tran vdout0_200ck1280 FIND v(dout0_200) AT=645.025n

.meas tran vdout0_201ck1280 FIND v(dout0_201) AT=645.025n

.meas tran vdout0_202ck1280 FIND v(dout0_202) AT=645.025n

.meas tran vdout0_203ck1280 FIND v(dout0_203) AT=645.025n

.meas tran vdout0_204ck1280 FIND v(dout0_204) AT=645.025n

.meas tran vdout0_205ck1280 FIND v(dout0_205) AT=645.025n

.meas tran vdout0_206ck1280 FIND v(dout0_206) AT=645.025n

.meas tran vdout0_207ck1280 FIND v(dout0_207) AT=645.025n

.meas tran vdout0_208ck1280 FIND v(dout0_208) AT=645.025n

.meas tran vdout0_209ck1280 FIND v(dout0_209) AT=645.025n

.meas tran vdout0_210ck1280 FIND v(dout0_210) AT=645.025n

.meas tran vdout0_211ck1280 FIND v(dout0_211) AT=645.025n

.meas tran vdout0_212ck1280 FIND v(dout0_212) AT=645.025n

.meas tran vdout0_213ck1280 FIND v(dout0_213) AT=645.025n

.meas tran vdout0_214ck1280 FIND v(dout0_214) AT=645.025n

.meas tran vdout0_215ck1280 FIND v(dout0_215) AT=645.025n

.meas tran vdout0_216ck1280 FIND v(dout0_216) AT=645.025n

.meas tran vdout0_217ck1280 FIND v(dout0_217) AT=645.025n

.meas tran vdout0_218ck1280 FIND v(dout0_218) AT=645.025n

.meas tran vdout0_219ck1280 FIND v(dout0_219) AT=645.025n

.meas tran vdout0_220ck1280 FIND v(dout0_220) AT=645.025n

.meas tran vdout0_221ck1280 FIND v(dout0_221) AT=645.025n

.meas tran vdout0_222ck1280 FIND v(dout0_222) AT=645.025n

.meas tran vdout0_223ck1280 FIND v(dout0_223) AT=645.025n

.meas tran vdout0_224ck1280 FIND v(dout0_224) AT=645.025n

.meas tran vdout0_225ck1280 FIND v(dout0_225) AT=645.025n

.meas tran vdout0_226ck1280 FIND v(dout0_226) AT=645.025n

.meas tran vdout0_227ck1280 FIND v(dout0_227) AT=645.025n

.meas tran vdout0_228ck1280 FIND v(dout0_228) AT=645.025n

.meas tran vdout0_229ck1280 FIND v(dout0_229) AT=645.025n

.meas tran vdout0_230ck1280 FIND v(dout0_230) AT=645.025n

.meas tran vdout0_231ck1280 FIND v(dout0_231) AT=645.025n

.meas tran vdout0_232ck1280 FIND v(dout0_232) AT=645.025n

.meas tran vdout0_233ck1280 FIND v(dout0_233) AT=645.025n

.meas tran vdout0_234ck1280 FIND v(dout0_234) AT=645.025n

.meas tran vdout0_235ck1280 FIND v(dout0_235) AT=645.025n

.meas tran vdout0_236ck1280 FIND v(dout0_236) AT=645.025n

.meas tran vdout0_237ck1280 FIND v(dout0_237) AT=645.025n

.meas tran vdout0_238ck1280 FIND v(dout0_238) AT=645.025n

.meas tran vdout0_239ck1280 FIND v(dout0_239) AT=645.025n

.meas tran vdout0_240ck1280 FIND v(dout0_240) AT=645.025n

.meas tran vdout0_241ck1280 FIND v(dout0_241) AT=645.025n

.meas tran vdout0_242ck1280 FIND v(dout0_242) AT=645.025n

.meas tran vdout0_243ck1280 FIND v(dout0_243) AT=645.025n

.meas tran vdout0_244ck1280 FIND v(dout0_244) AT=645.025n

.meas tran vdout0_245ck1280 FIND v(dout0_245) AT=645.025n

.meas tran vdout0_246ck1280 FIND v(dout0_246) AT=645.025n

.meas tran vdout0_247ck1280 FIND v(dout0_247) AT=645.025n

.meas tran vdout0_248ck1280 FIND v(dout0_248) AT=645.025n

.meas tran vdout0_249ck1280 FIND v(dout0_249) AT=645.025n

.meas tran vdout0_250ck1280 FIND v(dout0_250) AT=645.025n

.meas tran vdout0_251ck1280 FIND v(dout0_251) AT=645.025n

.meas tran vdout0_252ck1280 FIND v(dout0_252) AT=645.025n

.meas tran vdout0_253ck1280 FIND v(dout0_253) AT=645.025n

.meas tran vdout0_254ck1280 FIND v(dout0_254) AT=645.025n

.meas tran vdout0_255ck1280 FIND v(dout0_255) AT=645.025n

.meas tran vdout0_0ck1290 FIND v(dout0_0) AT=650.025n

.meas tran vdout0_1ck1290 FIND v(dout0_1) AT=650.025n

.meas tran vdout0_2ck1290 FIND v(dout0_2) AT=650.025n

.meas tran vdout0_3ck1290 FIND v(dout0_3) AT=650.025n

.meas tran vdout0_4ck1290 FIND v(dout0_4) AT=650.025n

.meas tran vdout0_5ck1290 FIND v(dout0_5) AT=650.025n

.meas tran vdout0_6ck1290 FIND v(dout0_6) AT=650.025n

.meas tran vdout0_7ck1290 FIND v(dout0_7) AT=650.025n

.meas tran vdout0_8ck1290 FIND v(dout0_8) AT=650.025n

.meas tran vdout0_9ck1290 FIND v(dout0_9) AT=650.025n

.meas tran vdout0_10ck1290 FIND v(dout0_10) AT=650.025n

.meas tran vdout0_11ck1290 FIND v(dout0_11) AT=650.025n

.meas tran vdout0_12ck1290 FIND v(dout0_12) AT=650.025n

.meas tran vdout0_13ck1290 FIND v(dout0_13) AT=650.025n

.meas tran vdout0_14ck1290 FIND v(dout0_14) AT=650.025n

.meas tran vdout0_15ck1290 FIND v(dout0_15) AT=650.025n

.meas tran vdout0_16ck1290 FIND v(dout0_16) AT=650.025n

.meas tran vdout0_17ck1290 FIND v(dout0_17) AT=650.025n

.meas tran vdout0_18ck1290 FIND v(dout0_18) AT=650.025n

.meas tran vdout0_19ck1290 FIND v(dout0_19) AT=650.025n

.meas tran vdout0_20ck1290 FIND v(dout0_20) AT=650.025n

.meas tran vdout0_21ck1290 FIND v(dout0_21) AT=650.025n

.meas tran vdout0_22ck1290 FIND v(dout0_22) AT=650.025n

.meas tran vdout0_23ck1290 FIND v(dout0_23) AT=650.025n

.meas tran vdout0_24ck1290 FIND v(dout0_24) AT=650.025n

.meas tran vdout0_25ck1290 FIND v(dout0_25) AT=650.025n

.meas tran vdout0_26ck1290 FIND v(dout0_26) AT=650.025n

.meas tran vdout0_27ck1290 FIND v(dout0_27) AT=650.025n

.meas tran vdout0_28ck1290 FIND v(dout0_28) AT=650.025n

.meas tran vdout0_29ck1290 FIND v(dout0_29) AT=650.025n

.meas tran vdout0_30ck1290 FIND v(dout0_30) AT=650.025n

.meas tran vdout0_31ck1290 FIND v(dout0_31) AT=650.025n

.meas tran vdout0_32ck1290 FIND v(dout0_32) AT=650.025n

.meas tran vdout0_33ck1290 FIND v(dout0_33) AT=650.025n

.meas tran vdout0_34ck1290 FIND v(dout0_34) AT=650.025n

.meas tran vdout0_35ck1290 FIND v(dout0_35) AT=650.025n

.meas tran vdout0_36ck1290 FIND v(dout0_36) AT=650.025n

.meas tran vdout0_37ck1290 FIND v(dout0_37) AT=650.025n

.meas tran vdout0_38ck1290 FIND v(dout0_38) AT=650.025n

.meas tran vdout0_39ck1290 FIND v(dout0_39) AT=650.025n

.meas tran vdout0_40ck1290 FIND v(dout0_40) AT=650.025n

.meas tran vdout0_41ck1290 FIND v(dout0_41) AT=650.025n

.meas tran vdout0_42ck1290 FIND v(dout0_42) AT=650.025n

.meas tran vdout0_43ck1290 FIND v(dout0_43) AT=650.025n

.meas tran vdout0_44ck1290 FIND v(dout0_44) AT=650.025n

.meas tran vdout0_45ck1290 FIND v(dout0_45) AT=650.025n

.meas tran vdout0_46ck1290 FIND v(dout0_46) AT=650.025n

.meas tran vdout0_47ck1290 FIND v(dout0_47) AT=650.025n

.meas tran vdout0_48ck1290 FIND v(dout0_48) AT=650.025n

.meas tran vdout0_49ck1290 FIND v(dout0_49) AT=650.025n

.meas tran vdout0_50ck1290 FIND v(dout0_50) AT=650.025n

.meas tran vdout0_51ck1290 FIND v(dout0_51) AT=650.025n

.meas tran vdout0_52ck1290 FIND v(dout0_52) AT=650.025n

.meas tran vdout0_53ck1290 FIND v(dout0_53) AT=650.025n

.meas tran vdout0_54ck1290 FIND v(dout0_54) AT=650.025n

.meas tran vdout0_55ck1290 FIND v(dout0_55) AT=650.025n

.meas tran vdout0_56ck1290 FIND v(dout0_56) AT=650.025n

.meas tran vdout0_57ck1290 FIND v(dout0_57) AT=650.025n

.meas tran vdout0_58ck1290 FIND v(dout0_58) AT=650.025n

.meas tran vdout0_59ck1290 FIND v(dout0_59) AT=650.025n

.meas tran vdout0_60ck1290 FIND v(dout0_60) AT=650.025n

.meas tran vdout0_61ck1290 FIND v(dout0_61) AT=650.025n

.meas tran vdout0_62ck1290 FIND v(dout0_62) AT=650.025n

.meas tran vdout0_63ck1290 FIND v(dout0_63) AT=650.025n

.meas tran vdout0_64ck1290 FIND v(dout0_64) AT=650.025n

.meas tran vdout0_65ck1290 FIND v(dout0_65) AT=650.025n

.meas tran vdout0_66ck1290 FIND v(dout0_66) AT=650.025n

.meas tran vdout0_67ck1290 FIND v(dout0_67) AT=650.025n

.meas tran vdout0_68ck1290 FIND v(dout0_68) AT=650.025n

.meas tran vdout0_69ck1290 FIND v(dout0_69) AT=650.025n

.meas tran vdout0_70ck1290 FIND v(dout0_70) AT=650.025n

.meas tran vdout0_71ck1290 FIND v(dout0_71) AT=650.025n

.meas tran vdout0_72ck1290 FIND v(dout0_72) AT=650.025n

.meas tran vdout0_73ck1290 FIND v(dout0_73) AT=650.025n

.meas tran vdout0_74ck1290 FIND v(dout0_74) AT=650.025n

.meas tran vdout0_75ck1290 FIND v(dout0_75) AT=650.025n

.meas tran vdout0_76ck1290 FIND v(dout0_76) AT=650.025n

.meas tran vdout0_77ck1290 FIND v(dout0_77) AT=650.025n

.meas tran vdout0_78ck1290 FIND v(dout0_78) AT=650.025n

.meas tran vdout0_79ck1290 FIND v(dout0_79) AT=650.025n

.meas tran vdout0_80ck1290 FIND v(dout0_80) AT=650.025n

.meas tran vdout0_81ck1290 FIND v(dout0_81) AT=650.025n

.meas tran vdout0_82ck1290 FIND v(dout0_82) AT=650.025n

.meas tran vdout0_83ck1290 FIND v(dout0_83) AT=650.025n

.meas tran vdout0_84ck1290 FIND v(dout0_84) AT=650.025n

.meas tran vdout0_85ck1290 FIND v(dout0_85) AT=650.025n

.meas tran vdout0_86ck1290 FIND v(dout0_86) AT=650.025n

.meas tran vdout0_87ck1290 FIND v(dout0_87) AT=650.025n

.meas tran vdout0_88ck1290 FIND v(dout0_88) AT=650.025n

.meas tran vdout0_89ck1290 FIND v(dout0_89) AT=650.025n

.meas tran vdout0_90ck1290 FIND v(dout0_90) AT=650.025n

.meas tran vdout0_91ck1290 FIND v(dout0_91) AT=650.025n

.meas tran vdout0_92ck1290 FIND v(dout0_92) AT=650.025n

.meas tran vdout0_93ck1290 FIND v(dout0_93) AT=650.025n

.meas tran vdout0_94ck1290 FIND v(dout0_94) AT=650.025n

.meas tran vdout0_95ck1290 FIND v(dout0_95) AT=650.025n

.meas tran vdout0_96ck1290 FIND v(dout0_96) AT=650.025n

.meas tran vdout0_97ck1290 FIND v(dout0_97) AT=650.025n

.meas tran vdout0_98ck1290 FIND v(dout0_98) AT=650.025n

.meas tran vdout0_99ck1290 FIND v(dout0_99) AT=650.025n

.meas tran vdout0_100ck1290 FIND v(dout0_100) AT=650.025n

.meas tran vdout0_101ck1290 FIND v(dout0_101) AT=650.025n

.meas tran vdout0_102ck1290 FIND v(dout0_102) AT=650.025n

.meas tran vdout0_103ck1290 FIND v(dout0_103) AT=650.025n

.meas tran vdout0_104ck1290 FIND v(dout0_104) AT=650.025n

.meas tran vdout0_105ck1290 FIND v(dout0_105) AT=650.025n

.meas tran vdout0_106ck1290 FIND v(dout0_106) AT=650.025n

.meas tran vdout0_107ck1290 FIND v(dout0_107) AT=650.025n

.meas tran vdout0_108ck1290 FIND v(dout0_108) AT=650.025n

.meas tran vdout0_109ck1290 FIND v(dout0_109) AT=650.025n

.meas tran vdout0_110ck1290 FIND v(dout0_110) AT=650.025n

.meas tran vdout0_111ck1290 FIND v(dout0_111) AT=650.025n

.meas tran vdout0_112ck1290 FIND v(dout0_112) AT=650.025n

.meas tran vdout0_113ck1290 FIND v(dout0_113) AT=650.025n

.meas tran vdout0_114ck1290 FIND v(dout0_114) AT=650.025n

.meas tran vdout0_115ck1290 FIND v(dout0_115) AT=650.025n

.meas tran vdout0_116ck1290 FIND v(dout0_116) AT=650.025n

.meas tran vdout0_117ck1290 FIND v(dout0_117) AT=650.025n

.meas tran vdout0_118ck1290 FIND v(dout0_118) AT=650.025n

.meas tran vdout0_119ck1290 FIND v(dout0_119) AT=650.025n

.meas tran vdout0_120ck1290 FIND v(dout0_120) AT=650.025n

.meas tran vdout0_121ck1290 FIND v(dout0_121) AT=650.025n

.meas tran vdout0_122ck1290 FIND v(dout0_122) AT=650.025n

.meas tran vdout0_123ck1290 FIND v(dout0_123) AT=650.025n

.meas tran vdout0_124ck1290 FIND v(dout0_124) AT=650.025n

.meas tran vdout0_125ck1290 FIND v(dout0_125) AT=650.025n

.meas tran vdout0_126ck1290 FIND v(dout0_126) AT=650.025n

.meas tran vdout0_127ck1290 FIND v(dout0_127) AT=650.025n

.meas tran vdout0_128ck1290 FIND v(dout0_128) AT=650.025n

.meas tran vdout0_129ck1290 FIND v(dout0_129) AT=650.025n

.meas tran vdout0_130ck1290 FIND v(dout0_130) AT=650.025n

.meas tran vdout0_131ck1290 FIND v(dout0_131) AT=650.025n

.meas tran vdout0_132ck1290 FIND v(dout0_132) AT=650.025n

.meas tran vdout0_133ck1290 FIND v(dout0_133) AT=650.025n

.meas tran vdout0_134ck1290 FIND v(dout0_134) AT=650.025n

.meas tran vdout0_135ck1290 FIND v(dout0_135) AT=650.025n

.meas tran vdout0_136ck1290 FIND v(dout0_136) AT=650.025n

.meas tran vdout0_137ck1290 FIND v(dout0_137) AT=650.025n

.meas tran vdout0_138ck1290 FIND v(dout0_138) AT=650.025n

.meas tran vdout0_139ck1290 FIND v(dout0_139) AT=650.025n

.meas tran vdout0_140ck1290 FIND v(dout0_140) AT=650.025n

.meas tran vdout0_141ck1290 FIND v(dout0_141) AT=650.025n

.meas tran vdout0_142ck1290 FIND v(dout0_142) AT=650.025n

.meas tran vdout0_143ck1290 FIND v(dout0_143) AT=650.025n

.meas tran vdout0_144ck1290 FIND v(dout0_144) AT=650.025n

.meas tran vdout0_145ck1290 FIND v(dout0_145) AT=650.025n

.meas tran vdout0_146ck1290 FIND v(dout0_146) AT=650.025n

.meas tran vdout0_147ck1290 FIND v(dout0_147) AT=650.025n

.meas tran vdout0_148ck1290 FIND v(dout0_148) AT=650.025n

.meas tran vdout0_149ck1290 FIND v(dout0_149) AT=650.025n

.meas tran vdout0_150ck1290 FIND v(dout0_150) AT=650.025n

.meas tran vdout0_151ck1290 FIND v(dout0_151) AT=650.025n

.meas tran vdout0_152ck1290 FIND v(dout0_152) AT=650.025n

.meas tran vdout0_153ck1290 FIND v(dout0_153) AT=650.025n

.meas tran vdout0_154ck1290 FIND v(dout0_154) AT=650.025n

.meas tran vdout0_155ck1290 FIND v(dout0_155) AT=650.025n

.meas tran vdout0_156ck1290 FIND v(dout0_156) AT=650.025n

.meas tran vdout0_157ck1290 FIND v(dout0_157) AT=650.025n

.meas tran vdout0_158ck1290 FIND v(dout0_158) AT=650.025n

.meas tran vdout0_159ck1290 FIND v(dout0_159) AT=650.025n

.meas tran vdout0_160ck1290 FIND v(dout0_160) AT=650.025n

.meas tran vdout0_161ck1290 FIND v(dout0_161) AT=650.025n

.meas tran vdout0_162ck1290 FIND v(dout0_162) AT=650.025n

.meas tran vdout0_163ck1290 FIND v(dout0_163) AT=650.025n

.meas tran vdout0_164ck1290 FIND v(dout0_164) AT=650.025n

.meas tran vdout0_165ck1290 FIND v(dout0_165) AT=650.025n

.meas tran vdout0_166ck1290 FIND v(dout0_166) AT=650.025n

.meas tran vdout0_167ck1290 FIND v(dout0_167) AT=650.025n

.meas tran vdout0_168ck1290 FIND v(dout0_168) AT=650.025n

.meas tran vdout0_169ck1290 FIND v(dout0_169) AT=650.025n

.meas tran vdout0_170ck1290 FIND v(dout0_170) AT=650.025n

.meas tran vdout0_171ck1290 FIND v(dout0_171) AT=650.025n

.meas tran vdout0_172ck1290 FIND v(dout0_172) AT=650.025n

.meas tran vdout0_173ck1290 FIND v(dout0_173) AT=650.025n

.meas tran vdout0_174ck1290 FIND v(dout0_174) AT=650.025n

.meas tran vdout0_175ck1290 FIND v(dout0_175) AT=650.025n

.meas tran vdout0_176ck1290 FIND v(dout0_176) AT=650.025n

.meas tran vdout0_177ck1290 FIND v(dout0_177) AT=650.025n

.meas tran vdout0_178ck1290 FIND v(dout0_178) AT=650.025n

.meas tran vdout0_179ck1290 FIND v(dout0_179) AT=650.025n

.meas tran vdout0_180ck1290 FIND v(dout0_180) AT=650.025n

.meas tran vdout0_181ck1290 FIND v(dout0_181) AT=650.025n

.meas tran vdout0_182ck1290 FIND v(dout0_182) AT=650.025n

.meas tran vdout0_183ck1290 FIND v(dout0_183) AT=650.025n

.meas tran vdout0_184ck1290 FIND v(dout0_184) AT=650.025n

.meas tran vdout0_185ck1290 FIND v(dout0_185) AT=650.025n

.meas tran vdout0_186ck1290 FIND v(dout0_186) AT=650.025n

.meas tran vdout0_187ck1290 FIND v(dout0_187) AT=650.025n

.meas tran vdout0_188ck1290 FIND v(dout0_188) AT=650.025n

.meas tran vdout0_189ck1290 FIND v(dout0_189) AT=650.025n

.meas tran vdout0_190ck1290 FIND v(dout0_190) AT=650.025n

.meas tran vdout0_191ck1290 FIND v(dout0_191) AT=650.025n

.meas tran vdout0_192ck1290 FIND v(dout0_192) AT=650.025n

.meas tran vdout0_193ck1290 FIND v(dout0_193) AT=650.025n

.meas tran vdout0_194ck1290 FIND v(dout0_194) AT=650.025n

.meas tran vdout0_195ck1290 FIND v(dout0_195) AT=650.025n

.meas tran vdout0_196ck1290 FIND v(dout0_196) AT=650.025n

.meas tran vdout0_197ck1290 FIND v(dout0_197) AT=650.025n

.meas tran vdout0_198ck1290 FIND v(dout0_198) AT=650.025n

.meas tran vdout0_199ck1290 FIND v(dout0_199) AT=650.025n

.meas tran vdout0_200ck1290 FIND v(dout0_200) AT=650.025n

.meas tran vdout0_201ck1290 FIND v(dout0_201) AT=650.025n

.meas tran vdout0_202ck1290 FIND v(dout0_202) AT=650.025n

.meas tran vdout0_203ck1290 FIND v(dout0_203) AT=650.025n

.meas tran vdout0_204ck1290 FIND v(dout0_204) AT=650.025n

.meas tran vdout0_205ck1290 FIND v(dout0_205) AT=650.025n

.meas tran vdout0_206ck1290 FIND v(dout0_206) AT=650.025n

.meas tran vdout0_207ck1290 FIND v(dout0_207) AT=650.025n

.meas tran vdout0_208ck1290 FIND v(dout0_208) AT=650.025n

.meas tran vdout0_209ck1290 FIND v(dout0_209) AT=650.025n

.meas tran vdout0_210ck1290 FIND v(dout0_210) AT=650.025n

.meas tran vdout0_211ck1290 FIND v(dout0_211) AT=650.025n

.meas tran vdout0_212ck1290 FIND v(dout0_212) AT=650.025n

.meas tran vdout0_213ck1290 FIND v(dout0_213) AT=650.025n

.meas tran vdout0_214ck1290 FIND v(dout0_214) AT=650.025n

.meas tran vdout0_215ck1290 FIND v(dout0_215) AT=650.025n

.meas tran vdout0_216ck1290 FIND v(dout0_216) AT=650.025n

.meas tran vdout0_217ck1290 FIND v(dout0_217) AT=650.025n

.meas tran vdout0_218ck1290 FIND v(dout0_218) AT=650.025n

.meas tran vdout0_219ck1290 FIND v(dout0_219) AT=650.025n

.meas tran vdout0_220ck1290 FIND v(dout0_220) AT=650.025n

.meas tran vdout0_221ck1290 FIND v(dout0_221) AT=650.025n

.meas tran vdout0_222ck1290 FIND v(dout0_222) AT=650.025n

.meas tran vdout0_223ck1290 FIND v(dout0_223) AT=650.025n

.meas tran vdout0_224ck1290 FIND v(dout0_224) AT=650.025n

.meas tran vdout0_225ck1290 FIND v(dout0_225) AT=650.025n

.meas tran vdout0_226ck1290 FIND v(dout0_226) AT=650.025n

.meas tran vdout0_227ck1290 FIND v(dout0_227) AT=650.025n

.meas tran vdout0_228ck1290 FIND v(dout0_228) AT=650.025n

.meas tran vdout0_229ck1290 FIND v(dout0_229) AT=650.025n

.meas tran vdout0_230ck1290 FIND v(dout0_230) AT=650.025n

.meas tran vdout0_231ck1290 FIND v(dout0_231) AT=650.025n

.meas tran vdout0_232ck1290 FIND v(dout0_232) AT=650.025n

.meas tran vdout0_233ck1290 FIND v(dout0_233) AT=650.025n

.meas tran vdout0_234ck1290 FIND v(dout0_234) AT=650.025n

.meas tran vdout0_235ck1290 FIND v(dout0_235) AT=650.025n

.meas tran vdout0_236ck1290 FIND v(dout0_236) AT=650.025n

.meas tran vdout0_237ck1290 FIND v(dout0_237) AT=650.025n

.meas tran vdout0_238ck1290 FIND v(dout0_238) AT=650.025n

.meas tran vdout0_239ck1290 FIND v(dout0_239) AT=650.025n

.meas tran vdout0_240ck1290 FIND v(dout0_240) AT=650.025n

.meas tran vdout0_241ck1290 FIND v(dout0_241) AT=650.025n

.meas tran vdout0_242ck1290 FIND v(dout0_242) AT=650.025n

.meas tran vdout0_243ck1290 FIND v(dout0_243) AT=650.025n

.meas tran vdout0_244ck1290 FIND v(dout0_244) AT=650.025n

.meas tran vdout0_245ck1290 FIND v(dout0_245) AT=650.025n

.meas tran vdout0_246ck1290 FIND v(dout0_246) AT=650.025n

.meas tran vdout0_247ck1290 FIND v(dout0_247) AT=650.025n

.meas tran vdout0_248ck1290 FIND v(dout0_248) AT=650.025n

.meas tran vdout0_249ck1290 FIND v(dout0_249) AT=650.025n

.meas tran vdout0_250ck1290 FIND v(dout0_250) AT=650.025n

.meas tran vdout0_251ck1290 FIND v(dout0_251) AT=650.025n

.meas tran vdout0_252ck1290 FIND v(dout0_252) AT=650.025n

.meas tran vdout0_253ck1290 FIND v(dout0_253) AT=650.025n

.meas tran vdout0_254ck1290 FIND v(dout0_254) AT=650.025n

.meas tran vdout0_255ck1290 FIND v(dout0_255) AT=650.025n

.meas tran vdout0_0ck1310 FIND v(dout0_0) AT=660.025n

.meas tran vdout0_1ck1310 FIND v(dout0_1) AT=660.025n

.meas tran vdout0_2ck1310 FIND v(dout0_2) AT=660.025n

.meas tran vdout0_3ck1310 FIND v(dout0_3) AT=660.025n

.meas tran vdout0_4ck1310 FIND v(dout0_4) AT=660.025n

.meas tran vdout0_5ck1310 FIND v(dout0_5) AT=660.025n

.meas tran vdout0_6ck1310 FIND v(dout0_6) AT=660.025n

.meas tran vdout0_7ck1310 FIND v(dout0_7) AT=660.025n

.meas tran vdout0_8ck1310 FIND v(dout0_8) AT=660.025n

.meas tran vdout0_9ck1310 FIND v(dout0_9) AT=660.025n

.meas tran vdout0_10ck1310 FIND v(dout0_10) AT=660.025n

.meas tran vdout0_11ck1310 FIND v(dout0_11) AT=660.025n

.meas tran vdout0_12ck1310 FIND v(dout0_12) AT=660.025n

.meas tran vdout0_13ck1310 FIND v(dout0_13) AT=660.025n

.meas tran vdout0_14ck1310 FIND v(dout0_14) AT=660.025n

.meas tran vdout0_15ck1310 FIND v(dout0_15) AT=660.025n

.meas tran vdout0_16ck1310 FIND v(dout0_16) AT=660.025n

.meas tran vdout0_17ck1310 FIND v(dout0_17) AT=660.025n

.meas tran vdout0_18ck1310 FIND v(dout0_18) AT=660.025n

.meas tran vdout0_19ck1310 FIND v(dout0_19) AT=660.025n

.meas tran vdout0_20ck1310 FIND v(dout0_20) AT=660.025n

.meas tran vdout0_21ck1310 FIND v(dout0_21) AT=660.025n

.meas tran vdout0_22ck1310 FIND v(dout0_22) AT=660.025n

.meas tran vdout0_23ck1310 FIND v(dout0_23) AT=660.025n

.meas tran vdout0_24ck1310 FIND v(dout0_24) AT=660.025n

.meas tran vdout0_25ck1310 FIND v(dout0_25) AT=660.025n

.meas tran vdout0_26ck1310 FIND v(dout0_26) AT=660.025n

.meas tran vdout0_27ck1310 FIND v(dout0_27) AT=660.025n

.meas tran vdout0_28ck1310 FIND v(dout0_28) AT=660.025n

.meas tran vdout0_29ck1310 FIND v(dout0_29) AT=660.025n

.meas tran vdout0_30ck1310 FIND v(dout0_30) AT=660.025n

.meas tran vdout0_31ck1310 FIND v(dout0_31) AT=660.025n

.meas tran vdout0_32ck1310 FIND v(dout0_32) AT=660.025n

.meas tran vdout0_33ck1310 FIND v(dout0_33) AT=660.025n

.meas tran vdout0_34ck1310 FIND v(dout0_34) AT=660.025n

.meas tran vdout0_35ck1310 FIND v(dout0_35) AT=660.025n

.meas tran vdout0_36ck1310 FIND v(dout0_36) AT=660.025n

.meas tran vdout0_37ck1310 FIND v(dout0_37) AT=660.025n

.meas tran vdout0_38ck1310 FIND v(dout0_38) AT=660.025n

.meas tran vdout0_39ck1310 FIND v(dout0_39) AT=660.025n

.meas tran vdout0_40ck1310 FIND v(dout0_40) AT=660.025n

.meas tran vdout0_41ck1310 FIND v(dout0_41) AT=660.025n

.meas tran vdout0_42ck1310 FIND v(dout0_42) AT=660.025n

.meas tran vdout0_43ck1310 FIND v(dout0_43) AT=660.025n

.meas tran vdout0_44ck1310 FIND v(dout0_44) AT=660.025n

.meas tran vdout0_45ck1310 FIND v(dout0_45) AT=660.025n

.meas tran vdout0_46ck1310 FIND v(dout0_46) AT=660.025n

.meas tran vdout0_47ck1310 FIND v(dout0_47) AT=660.025n

.meas tran vdout0_48ck1310 FIND v(dout0_48) AT=660.025n

.meas tran vdout0_49ck1310 FIND v(dout0_49) AT=660.025n

.meas tran vdout0_50ck1310 FIND v(dout0_50) AT=660.025n

.meas tran vdout0_51ck1310 FIND v(dout0_51) AT=660.025n

.meas tran vdout0_52ck1310 FIND v(dout0_52) AT=660.025n

.meas tran vdout0_53ck1310 FIND v(dout0_53) AT=660.025n

.meas tran vdout0_54ck1310 FIND v(dout0_54) AT=660.025n

.meas tran vdout0_55ck1310 FIND v(dout0_55) AT=660.025n

.meas tran vdout0_56ck1310 FIND v(dout0_56) AT=660.025n

.meas tran vdout0_57ck1310 FIND v(dout0_57) AT=660.025n

.meas tran vdout0_58ck1310 FIND v(dout0_58) AT=660.025n

.meas tran vdout0_59ck1310 FIND v(dout0_59) AT=660.025n

.meas tran vdout0_60ck1310 FIND v(dout0_60) AT=660.025n

.meas tran vdout0_61ck1310 FIND v(dout0_61) AT=660.025n

.meas tran vdout0_62ck1310 FIND v(dout0_62) AT=660.025n

.meas tran vdout0_63ck1310 FIND v(dout0_63) AT=660.025n

.meas tran vdout0_64ck1310 FIND v(dout0_64) AT=660.025n

.meas tran vdout0_65ck1310 FIND v(dout0_65) AT=660.025n

.meas tran vdout0_66ck1310 FIND v(dout0_66) AT=660.025n

.meas tran vdout0_67ck1310 FIND v(dout0_67) AT=660.025n

.meas tran vdout0_68ck1310 FIND v(dout0_68) AT=660.025n

.meas tran vdout0_69ck1310 FIND v(dout0_69) AT=660.025n

.meas tran vdout0_70ck1310 FIND v(dout0_70) AT=660.025n

.meas tran vdout0_71ck1310 FIND v(dout0_71) AT=660.025n

.meas tran vdout0_72ck1310 FIND v(dout0_72) AT=660.025n

.meas tran vdout0_73ck1310 FIND v(dout0_73) AT=660.025n

.meas tran vdout0_74ck1310 FIND v(dout0_74) AT=660.025n

.meas tran vdout0_75ck1310 FIND v(dout0_75) AT=660.025n

.meas tran vdout0_76ck1310 FIND v(dout0_76) AT=660.025n

.meas tran vdout0_77ck1310 FIND v(dout0_77) AT=660.025n

.meas tran vdout0_78ck1310 FIND v(dout0_78) AT=660.025n

.meas tran vdout0_79ck1310 FIND v(dout0_79) AT=660.025n

.meas tran vdout0_80ck1310 FIND v(dout0_80) AT=660.025n

.meas tran vdout0_81ck1310 FIND v(dout0_81) AT=660.025n

.meas tran vdout0_82ck1310 FIND v(dout0_82) AT=660.025n

.meas tran vdout0_83ck1310 FIND v(dout0_83) AT=660.025n

.meas tran vdout0_84ck1310 FIND v(dout0_84) AT=660.025n

.meas tran vdout0_85ck1310 FIND v(dout0_85) AT=660.025n

.meas tran vdout0_86ck1310 FIND v(dout0_86) AT=660.025n

.meas tran vdout0_87ck1310 FIND v(dout0_87) AT=660.025n

.meas tran vdout0_88ck1310 FIND v(dout0_88) AT=660.025n

.meas tran vdout0_89ck1310 FIND v(dout0_89) AT=660.025n

.meas tran vdout0_90ck1310 FIND v(dout0_90) AT=660.025n

.meas tran vdout0_91ck1310 FIND v(dout0_91) AT=660.025n

.meas tran vdout0_92ck1310 FIND v(dout0_92) AT=660.025n

.meas tran vdout0_93ck1310 FIND v(dout0_93) AT=660.025n

.meas tran vdout0_94ck1310 FIND v(dout0_94) AT=660.025n

.meas tran vdout0_95ck1310 FIND v(dout0_95) AT=660.025n

.meas tran vdout0_96ck1310 FIND v(dout0_96) AT=660.025n

.meas tran vdout0_97ck1310 FIND v(dout0_97) AT=660.025n

.meas tran vdout0_98ck1310 FIND v(dout0_98) AT=660.025n

.meas tran vdout0_99ck1310 FIND v(dout0_99) AT=660.025n

.meas tran vdout0_100ck1310 FIND v(dout0_100) AT=660.025n

.meas tran vdout0_101ck1310 FIND v(dout0_101) AT=660.025n

.meas tran vdout0_102ck1310 FIND v(dout0_102) AT=660.025n

.meas tran vdout0_103ck1310 FIND v(dout0_103) AT=660.025n

.meas tran vdout0_104ck1310 FIND v(dout0_104) AT=660.025n

.meas tran vdout0_105ck1310 FIND v(dout0_105) AT=660.025n

.meas tran vdout0_106ck1310 FIND v(dout0_106) AT=660.025n

.meas tran vdout0_107ck1310 FIND v(dout0_107) AT=660.025n

.meas tran vdout0_108ck1310 FIND v(dout0_108) AT=660.025n

.meas tran vdout0_109ck1310 FIND v(dout0_109) AT=660.025n

.meas tran vdout0_110ck1310 FIND v(dout0_110) AT=660.025n

.meas tran vdout0_111ck1310 FIND v(dout0_111) AT=660.025n

.meas tran vdout0_112ck1310 FIND v(dout0_112) AT=660.025n

.meas tran vdout0_113ck1310 FIND v(dout0_113) AT=660.025n

.meas tran vdout0_114ck1310 FIND v(dout0_114) AT=660.025n

.meas tran vdout0_115ck1310 FIND v(dout0_115) AT=660.025n

.meas tran vdout0_116ck1310 FIND v(dout0_116) AT=660.025n

.meas tran vdout0_117ck1310 FIND v(dout0_117) AT=660.025n

.meas tran vdout0_118ck1310 FIND v(dout0_118) AT=660.025n

.meas tran vdout0_119ck1310 FIND v(dout0_119) AT=660.025n

.meas tran vdout0_120ck1310 FIND v(dout0_120) AT=660.025n

.meas tran vdout0_121ck1310 FIND v(dout0_121) AT=660.025n

.meas tran vdout0_122ck1310 FIND v(dout0_122) AT=660.025n

.meas tran vdout0_123ck1310 FIND v(dout0_123) AT=660.025n

.meas tran vdout0_124ck1310 FIND v(dout0_124) AT=660.025n

.meas tran vdout0_125ck1310 FIND v(dout0_125) AT=660.025n

.meas tran vdout0_126ck1310 FIND v(dout0_126) AT=660.025n

.meas tran vdout0_127ck1310 FIND v(dout0_127) AT=660.025n

.meas tran vdout0_128ck1310 FIND v(dout0_128) AT=660.025n

.meas tran vdout0_129ck1310 FIND v(dout0_129) AT=660.025n

.meas tran vdout0_130ck1310 FIND v(dout0_130) AT=660.025n

.meas tran vdout0_131ck1310 FIND v(dout0_131) AT=660.025n

.meas tran vdout0_132ck1310 FIND v(dout0_132) AT=660.025n

.meas tran vdout0_133ck1310 FIND v(dout0_133) AT=660.025n

.meas tran vdout0_134ck1310 FIND v(dout0_134) AT=660.025n

.meas tran vdout0_135ck1310 FIND v(dout0_135) AT=660.025n

.meas tran vdout0_136ck1310 FIND v(dout0_136) AT=660.025n

.meas tran vdout0_137ck1310 FIND v(dout0_137) AT=660.025n

.meas tran vdout0_138ck1310 FIND v(dout0_138) AT=660.025n

.meas tran vdout0_139ck1310 FIND v(dout0_139) AT=660.025n

.meas tran vdout0_140ck1310 FIND v(dout0_140) AT=660.025n

.meas tran vdout0_141ck1310 FIND v(dout0_141) AT=660.025n

.meas tran vdout0_142ck1310 FIND v(dout0_142) AT=660.025n

.meas tran vdout0_143ck1310 FIND v(dout0_143) AT=660.025n

.meas tran vdout0_144ck1310 FIND v(dout0_144) AT=660.025n

.meas tran vdout0_145ck1310 FIND v(dout0_145) AT=660.025n

.meas tran vdout0_146ck1310 FIND v(dout0_146) AT=660.025n

.meas tran vdout0_147ck1310 FIND v(dout0_147) AT=660.025n

.meas tran vdout0_148ck1310 FIND v(dout0_148) AT=660.025n

.meas tran vdout0_149ck1310 FIND v(dout0_149) AT=660.025n

.meas tran vdout0_150ck1310 FIND v(dout0_150) AT=660.025n

.meas tran vdout0_151ck1310 FIND v(dout0_151) AT=660.025n

.meas tran vdout0_152ck1310 FIND v(dout0_152) AT=660.025n

.meas tran vdout0_153ck1310 FIND v(dout0_153) AT=660.025n

.meas tran vdout0_154ck1310 FIND v(dout0_154) AT=660.025n

.meas tran vdout0_155ck1310 FIND v(dout0_155) AT=660.025n

.meas tran vdout0_156ck1310 FIND v(dout0_156) AT=660.025n

.meas tran vdout0_157ck1310 FIND v(dout0_157) AT=660.025n

.meas tran vdout0_158ck1310 FIND v(dout0_158) AT=660.025n

.meas tran vdout0_159ck1310 FIND v(dout0_159) AT=660.025n

.meas tran vdout0_160ck1310 FIND v(dout0_160) AT=660.025n

.meas tran vdout0_161ck1310 FIND v(dout0_161) AT=660.025n

.meas tran vdout0_162ck1310 FIND v(dout0_162) AT=660.025n

.meas tran vdout0_163ck1310 FIND v(dout0_163) AT=660.025n

.meas tran vdout0_164ck1310 FIND v(dout0_164) AT=660.025n

.meas tran vdout0_165ck1310 FIND v(dout0_165) AT=660.025n

.meas tran vdout0_166ck1310 FIND v(dout0_166) AT=660.025n

.meas tran vdout0_167ck1310 FIND v(dout0_167) AT=660.025n

.meas tran vdout0_168ck1310 FIND v(dout0_168) AT=660.025n

.meas tran vdout0_169ck1310 FIND v(dout0_169) AT=660.025n

.meas tran vdout0_170ck1310 FIND v(dout0_170) AT=660.025n

.meas tran vdout0_171ck1310 FIND v(dout0_171) AT=660.025n

.meas tran vdout0_172ck1310 FIND v(dout0_172) AT=660.025n

.meas tran vdout0_173ck1310 FIND v(dout0_173) AT=660.025n

.meas tran vdout0_174ck1310 FIND v(dout0_174) AT=660.025n

.meas tran vdout0_175ck1310 FIND v(dout0_175) AT=660.025n

.meas tran vdout0_176ck1310 FIND v(dout0_176) AT=660.025n

.meas tran vdout0_177ck1310 FIND v(dout0_177) AT=660.025n

.meas tran vdout0_178ck1310 FIND v(dout0_178) AT=660.025n

.meas tran vdout0_179ck1310 FIND v(dout0_179) AT=660.025n

.meas tran vdout0_180ck1310 FIND v(dout0_180) AT=660.025n

.meas tran vdout0_181ck1310 FIND v(dout0_181) AT=660.025n

.meas tran vdout0_182ck1310 FIND v(dout0_182) AT=660.025n

.meas tran vdout0_183ck1310 FIND v(dout0_183) AT=660.025n

.meas tran vdout0_184ck1310 FIND v(dout0_184) AT=660.025n

.meas tran vdout0_185ck1310 FIND v(dout0_185) AT=660.025n

.meas tran vdout0_186ck1310 FIND v(dout0_186) AT=660.025n

.meas tran vdout0_187ck1310 FIND v(dout0_187) AT=660.025n

.meas tran vdout0_188ck1310 FIND v(dout0_188) AT=660.025n

.meas tran vdout0_189ck1310 FIND v(dout0_189) AT=660.025n

.meas tran vdout0_190ck1310 FIND v(dout0_190) AT=660.025n

.meas tran vdout0_191ck1310 FIND v(dout0_191) AT=660.025n

.meas tran vdout0_192ck1310 FIND v(dout0_192) AT=660.025n

.meas tran vdout0_193ck1310 FIND v(dout0_193) AT=660.025n

.meas tran vdout0_194ck1310 FIND v(dout0_194) AT=660.025n

.meas tran vdout0_195ck1310 FIND v(dout0_195) AT=660.025n

.meas tran vdout0_196ck1310 FIND v(dout0_196) AT=660.025n

.meas tran vdout0_197ck1310 FIND v(dout0_197) AT=660.025n

.meas tran vdout0_198ck1310 FIND v(dout0_198) AT=660.025n

.meas tran vdout0_199ck1310 FIND v(dout0_199) AT=660.025n

.meas tran vdout0_200ck1310 FIND v(dout0_200) AT=660.025n

.meas tran vdout0_201ck1310 FIND v(dout0_201) AT=660.025n

.meas tran vdout0_202ck1310 FIND v(dout0_202) AT=660.025n

.meas tran vdout0_203ck1310 FIND v(dout0_203) AT=660.025n

.meas tran vdout0_204ck1310 FIND v(dout0_204) AT=660.025n

.meas tran vdout0_205ck1310 FIND v(dout0_205) AT=660.025n

.meas tran vdout0_206ck1310 FIND v(dout0_206) AT=660.025n

.meas tran vdout0_207ck1310 FIND v(dout0_207) AT=660.025n

.meas tran vdout0_208ck1310 FIND v(dout0_208) AT=660.025n

.meas tran vdout0_209ck1310 FIND v(dout0_209) AT=660.025n

.meas tran vdout0_210ck1310 FIND v(dout0_210) AT=660.025n

.meas tran vdout0_211ck1310 FIND v(dout0_211) AT=660.025n

.meas tran vdout0_212ck1310 FIND v(dout0_212) AT=660.025n

.meas tran vdout0_213ck1310 FIND v(dout0_213) AT=660.025n

.meas tran vdout0_214ck1310 FIND v(dout0_214) AT=660.025n

.meas tran vdout0_215ck1310 FIND v(dout0_215) AT=660.025n

.meas tran vdout0_216ck1310 FIND v(dout0_216) AT=660.025n

.meas tran vdout0_217ck1310 FIND v(dout0_217) AT=660.025n

.meas tran vdout0_218ck1310 FIND v(dout0_218) AT=660.025n

.meas tran vdout0_219ck1310 FIND v(dout0_219) AT=660.025n

.meas tran vdout0_220ck1310 FIND v(dout0_220) AT=660.025n

.meas tran vdout0_221ck1310 FIND v(dout0_221) AT=660.025n

.meas tran vdout0_222ck1310 FIND v(dout0_222) AT=660.025n

.meas tran vdout0_223ck1310 FIND v(dout0_223) AT=660.025n

.meas tran vdout0_224ck1310 FIND v(dout0_224) AT=660.025n

.meas tran vdout0_225ck1310 FIND v(dout0_225) AT=660.025n

.meas tran vdout0_226ck1310 FIND v(dout0_226) AT=660.025n

.meas tran vdout0_227ck1310 FIND v(dout0_227) AT=660.025n

.meas tran vdout0_228ck1310 FIND v(dout0_228) AT=660.025n

.meas tran vdout0_229ck1310 FIND v(dout0_229) AT=660.025n

.meas tran vdout0_230ck1310 FIND v(dout0_230) AT=660.025n

.meas tran vdout0_231ck1310 FIND v(dout0_231) AT=660.025n

.meas tran vdout0_232ck1310 FIND v(dout0_232) AT=660.025n

.meas tran vdout0_233ck1310 FIND v(dout0_233) AT=660.025n

.meas tran vdout0_234ck1310 FIND v(dout0_234) AT=660.025n

.meas tran vdout0_235ck1310 FIND v(dout0_235) AT=660.025n

.meas tran vdout0_236ck1310 FIND v(dout0_236) AT=660.025n

.meas tran vdout0_237ck1310 FIND v(dout0_237) AT=660.025n

.meas tran vdout0_238ck1310 FIND v(dout0_238) AT=660.025n

.meas tran vdout0_239ck1310 FIND v(dout0_239) AT=660.025n

.meas tran vdout0_240ck1310 FIND v(dout0_240) AT=660.025n

.meas tran vdout0_241ck1310 FIND v(dout0_241) AT=660.025n

.meas tran vdout0_242ck1310 FIND v(dout0_242) AT=660.025n

.meas tran vdout0_243ck1310 FIND v(dout0_243) AT=660.025n

.meas tran vdout0_244ck1310 FIND v(dout0_244) AT=660.025n

.meas tran vdout0_245ck1310 FIND v(dout0_245) AT=660.025n

.meas tran vdout0_246ck1310 FIND v(dout0_246) AT=660.025n

.meas tran vdout0_247ck1310 FIND v(dout0_247) AT=660.025n

.meas tran vdout0_248ck1310 FIND v(dout0_248) AT=660.025n

.meas tran vdout0_249ck1310 FIND v(dout0_249) AT=660.025n

.meas tran vdout0_250ck1310 FIND v(dout0_250) AT=660.025n

.meas tran vdout0_251ck1310 FIND v(dout0_251) AT=660.025n

.meas tran vdout0_252ck1310 FIND v(dout0_252) AT=660.025n

.meas tran vdout0_253ck1310 FIND v(dout0_253) AT=660.025n

.meas tran vdout0_254ck1310 FIND v(dout0_254) AT=660.025n

.meas tran vdout0_255ck1310 FIND v(dout0_255) AT=660.025n

.meas tran vdout0_0ck1320 FIND v(dout0_0) AT=665.025n

.meas tran vdout0_1ck1320 FIND v(dout0_1) AT=665.025n

.meas tran vdout0_2ck1320 FIND v(dout0_2) AT=665.025n

.meas tran vdout0_3ck1320 FIND v(dout0_3) AT=665.025n

.meas tran vdout0_4ck1320 FIND v(dout0_4) AT=665.025n

.meas tran vdout0_5ck1320 FIND v(dout0_5) AT=665.025n

.meas tran vdout0_6ck1320 FIND v(dout0_6) AT=665.025n

.meas tran vdout0_7ck1320 FIND v(dout0_7) AT=665.025n

.meas tran vdout0_8ck1320 FIND v(dout0_8) AT=665.025n

.meas tran vdout0_9ck1320 FIND v(dout0_9) AT=665.025n

.meas tran vdout0_10ck1320 FIND v(dout0_10) AT=665.025n

.meas tran vdout0_11ck1320 FIND v(dout0_11) AT=665.025n

.meas tran vdout0_12ck1320 FIND v(dout0_12) AT=665.025n

.meas tran vdout0_13ck1320 FIND v(dout0_13) AT=665.025n

.meas tran vdout0_14ck1320 FIND v(dout0_14) AT=665.025n

.meas tran vdout0_15ck1320 FIND v(dout0_15) AT=665.025n

.meas tran vdout0_16ck1320 FIND v(dout0_16) AT=665.025n

.meas tran vdout0_17ck1320 FIND v(dout0_17) AT=665.025n

.meas tran vdout0_18ck1320 FIND v(dout0_18) AT=665.025n

.meas tran vdout0_19ck1320 FIND v(dout0_19) AT=665.025n

.meas tran vdout0_20ck1320 FIND v(dout0_20) AT=665.025n

.meas tran vdout0_21ck1320 FIND v(dout0_21) AT=665.025n

.meas tran vdout0_22ck1320 FIND v(dout0_22) AT=665.025n

.meas tran vdout0_23ck1320 FIND v(dout0_23) AT=665.025n

.meas tran vdout0_24ck1320 FIND v(dout0_24) AT=665.025n

.meas tran vdout0_25ck1320 FIND v(dout0_25) AT=665.025n

.meas tran vdout0_26ck1320 FIND v(dout0_26) AT=665.025n

.meas tran vdout0_27ck1320 FIND v(dout0_27) AT=665.025n

.meas tran vdout0_28ck1320 FIND v(dout0_28) AT=665.025n

.meas tran vdout0_29ck1320 FIND v(dout0_29) AT=665.025n

.meas tran vdout0_30ck1320 FIND v(dout0_30) AT=665.025n

.meas tran vdout0_31ck1320 FIND v(dout0_31) AT=665.025n

.meas tran vdout0_32ck1320 FIND v(dout0_32) AT=665.025n

.meas tran vdout0_33ck1320 FIND v(dout0_33) AT=665.025n

.meas tran vdout0_34ck1320 FIND v(dout0_34) AT=665.025n

.meas tran vdout0_35ck1320 FIND v(dout0_35) AT=665.025n

.meas tran vdout0_36ck1320 FIND v(dout0_36) AT=665.025n

.meas tran vdout0_37ck1320 FIND v(dout0_37) AT=665.025n

.meas tran vdout0_38ck1320 FIND v(dout0_38) AT=665.025n

.meas tran vdout0_39ck1320 FIND v(dout0_39) AT=665.025n

.meas tran vdout0_40ck1320 FIND v(dout0_40) AT=665.025n

.meas tran vdout0_41ck1320 FIND v(dout0_41) AT=665.025n

.meas tran vdout0_42ck1320 FIND v(dout0_42) AT=665.025n

.meas tran vdout0_43ck1320 FIND v(dout0_43) AT=665.025n

.meas tran vdout0_44ck1320 FIND v(dout0_44) AT=665.025n

.meas tran vdout0_45ck1320 FIND v(dout0_45) AT=665.025n

.meas tran vdout0_46ck1320 FIND v(dout0_46) AT=665.025n

.meas tran vdout0_47ck1320 FIND v(dout0_47) AT=665.025n

.meas tran vdout0_48ck1320 FIND v(dout0_48) AT=665.025n

.meas tran vdout0_49ck1320 FIND v(dout0_49) AT=665.025n

.meas tran vdout0_50ck1320 FIND v(dout0_50) AT=665.025n

.meas tran vdout0_51ck1320 FIND v(dout0_51) AT=665.025n

.meas tran vdout0_52ck1320 FIND v(dout0_52) AT=665.025n

.meas tran vdout0_53ck1320 FIND v(dout0_53) AT=665.025n

.meas tran vdout0_54ck1320 FIND v(dout0_54) AT=665.025n

.meas tran vdout0_55ck1320 FIND v(dout0_55) AT=665.025n

.meas tran vdout0_56ck1320 FIND v(dout0_56) AT=665.025n

.meas tran vdout0_57ck1320 FIND v(dout0_57) AT=665.025n

.meas tran vdout0_58ck1320 FIND v(dout0_58) AT=665.025n

.meas tran vdout0_59ck1320 FIND v(dout0_59) AT=665.025n

.meas tran vdout0_60ck1320 FIND v(dout0_60) AT=665.025n

.meas tran vdout0_61ck1320 FIND v(dout0_61) AT=665.025n

.meas tran vdout0_62ck1320 FIND v(dout0_62) AT=665.025n

.meas tran vdout0_63ck1320 FIND v(dout0_63) AT=665.025n

.meas tran vdout0_64ck1320 FIND v(dout0_64) AT=665.025n

.meas tran vdout0_65ck1320 FIND v(dout0_65) AT=665.025n

.meas tran vdout0_66ck1320 FIND v(dout0_66) AT=665.025n

.meas tran vdout0_67ck1320 FIND v(dout0_67) AT=665.025n

.meas tran vdout0_68ck1320 FIND v(dout0_68) AT=665.025n

.meas tran vdout0_69ck1320 FIND v(dout0_69) AT=665.025n

.meas tran vdout0_70ck1320 FIND v(dout0_70) AT=665.025n

.meas tran vdout0_71ck1320 FIND v(dout0_71) AT=665.025n

.meas tran vdout0_72ck1320 FIND v(dout0_72) AT=665.025n

.meas tran vdout0_73ck1320 FIND v(dout0_73) AT=665.025n

.meas tran vdout0_74ck1320 FIND v(dout0_74) AT=665.025n

.meas tran vdout0_75ck1320 FIND v(dout0_75) AT=665.025n

.meas tran vdout0_76ck1320 FIND v(dout0_76) AT=665.025n

.meas tran vdout0_77ck1320 FIND v(dout0_77) AT=665.025n

.meas tran vdout0_78ck1320 FIND v(dout0_78) AT=665.025n

.meas tran vdout0_79ck1320 FIND v(dout0_79) AT=665.025n

.meas tran vdout0_80ck1320 FIND v(dout0_80) AT=665.025n

.meas tran vdout0_81ck1320 FIND v(dout0_81) AT=665.025n

.meas tran vdout0_82ck1320 FIND v(dout0_82) AT=665.025n

.meas tran vdout0_83ck1320 FIND v(dout0_83) AT=665.025n

.meas tran vdout0_84ck1320 FIND v(dout0_84) AT=665.025n

.meas tran vdout0_85ck1320 FIND v(dout0_85) AT=665.025n

.meas tran vdout0_86ck1320 FIND v(dout0_86) AT=665.025n

.meas tran vdout0_87ck1320 FIND v(dout0_87) AT=665.025n

.meas tran vdout0_88ck1320 FIND v(dout0_88) AT=665.025n

.meas tran vdout0_89ck1320 FIND v(dout0_89) AT=665.025n

.meas tran vdout0_90ck1320 FIND v(dout0_90) AT=665.025n

.meas tran vdout0_91ck1320 FIND v(dout0_91) AT=665.025n

.meas tran vdout0_92ck1320 FIND v(dout0_92) AT=665.025n

.meas tran vdout0_93ck1320 FIND v(dout0_93) AT=665.025n

.meas tran vdout0_94ck1320 FIND v(dout0_94) AT=665.025n

.meas tran vdout0_95ck1320 FIND v(dout0_95) AT=665.025n

.meas tran vdout0_96ck1320 FIND v(dout0_96) AT=665.025n

.meas tran vdout0_97ck1320 FIND v(dout0_97) AT=665.025n

.meas tran vdout0_98ck1320 FIND v(dout0_98) AT=665.025n

.meas tran vdout0_99ck1320 FIND v(dout0_99) AT=665.025n

.meas tran vdout0_100ck1320 FIND v(dout0_100) AT=665.025n

.meas tran vdout0_101ck1320 FIND v(dout0_101) AT=665.025n

.meas tran vdout0_102ck1320 FIND v(dout0_102) AT=665.025n

.meas tran vdout0_103ck1320 FIND v(dout0_103) AT=665.025n

.meas tran vdout0_104ck1320 FIND v(dout0_104) AT=665.025n

.meas tran vdout0_105ck1320 FIND v(dout0_105) AT=665.025n

.meas tran vdout0_106ck1320 FIND v(dout0_106) AT=665.025n

.meas tran vdout0_107ck1320 FIND v(dout0_107) AT=665.025n

.meas tran vdout0_108ck1320 FIND v(dout0_108) AT=665.025n

.meas tran vdout0_109ck1320 FIND v(dout0_109) AT=665.025n

.meas tran vdout0_110ck1320 FIND v(dout0_110) AT=665.025n

.meas tran vdout0_111ck1320 FIND v(dout0_111) AT=665.025n

.meas tran vdout0_112ck1320 FIND v(dout0_112) AT=665.025n

.meas tran vdout0_113ck1320 FIND v(dout0_113) AT=665.025n

.meas tran vdout0_114ck1320 FIND v(dout0_114) AT=665.025n

.meas tran vdout0_115ck1320 FIND v(dout0_115) AT=665.025n

.meas tran vdout0_116ck1320 FIND v(dout0_116) AT=665.025n

.meas tran vdout0_117ck1320 FIND v(dout0_117) AT=665.025n

.meas tran vdout0_118ck1320 FIND v(dout0_118) AT=665.025n

.meas tran vdout0_119ck1320 FIND v(dout0_119) AT=665.025n

.meas tran vdout0_120ck1320 FIND v(dout0_120) AT=665.025n

.meas tran vdout0_121ck1320 FIND v(dout0_121) AT=665.025n

.meas tran vdout0_122ck1320 FIND v(dout0_122) AT=665.025n

.meas tran vdout0_123ck1320 FIND v(dout0_123) AT=665.025n

.meas tran vdout0_124ck1320 FIND v(dout0_124) AT=665.025n

.meas tran vdout0_125ck1320 FIND v(dout0_125) AT=665.025n

.meas tran vdout0_126ck1320 FIND v(dout0_126) AT=665.025n

.meas tran vdout0_127ck1320 FIND v(dout0_127) AT=665.025n

.meas tran vdout0_128ck1320 FIND v(dout0_128) AT=665.025n

.meas tran vdout0_129ck1320 FIND v(dout0_129) AT=665.025n

.meas tran vdout0_130ck1320 FIND v(dout0_130) AT=665.025n

.meas tran vdout0_131ck1320 FIND v(dout0_131) AT=665.025n

.meas tran vdout0_132ck1320 FIND v(dout0_132) AT=665.025n

.meas tran vdout0_133ck1320 FIND v(dout0_133) AT=665.025n

.meas tran vdout0_134ck1320 FIND v(dout0_134) AT=665.025n

.meas tran vdout0_135ck1320 FIND v(dout0_135) AT=665.025n

.meas tran vdout0_136ck1320 FIND v(dout0_136) AT=665.025n

.meas tran vdout0_137ck1320 FIND v(dout0_137) AT=665.025n

.meas tran vdout0_138ck1320 FIND v(dout0_138) AT=665.025n

.meas tran vdout0_139ck1320 FIND v(dout0_139) AT=665.025n

.meas tran vdout0_140ck1320 FIND v(dout0_140) AT=665.025n

.meas tran vdout0_141ck1320 FIND v(dout0_141) AT=665.025n

.meas tran vdout0_142ck1320 FIND v(dout0_142) AT=665.025n

.meas tran vdout0_143ck1320 FIND v(dout0_143) AT=665.025n

.meas tran vdout0_144ck1320 FIND v(dout0_144) AT=665.025n

.meas tran vdout0_145ck1320 FIND v(dout0_145) AT=665.025n

.meas tran vdout0_146ck1320 FIND v(dout0_146) AT=665.025n

.meas tran vdout0_147ck1320 FIND v(dout0_147) AT=665.025n

.meas tran vdout0_148ck1320 FIND v(dout0_148) AT=665.025n

.meas tran vdout0_149ck1320 FIND v(dout0_149) AT=665.025n

.meas tran vdout0_150ck1320 FIND v(dout0_150) AT=665.025n

.meas tran vdout0_151ck1320 FIND v(dout0_151) AT=665.025n

.meas tran vdout0_152ck1320 FIND v(dout0_152) AT=665.025n

.meas tran vdout0_153ck1320 FIND v(dout0_153) AT=665.025n

.meas tran vdout0_154ck1320 FIND v(dout0_154) AT=665.025n

.meas tran vdout0_155ck1320 FIND v(dout0_155) AT=665.025n

.meas tran vdout0_156ck1320 FIND v(dout0_156) AT=665.025n

.meas tran vdout0_157ck1320 FIND v(dout0_157) AT=665.025n

.meas tran vdout0_158ck1320 FIND v(dout0_158) AT=665.025n

.meas tran vdout0_159ck1320 FIND v(dout0_159) AT=665.025n

.meas tran vdout0_160ck1320 FIND v(dout0_160) AT=665.025n

.meas tran vdout0_161ck1320 FIND v(dout0_161) AT=665.025n

.meas tran vdout0_162ck1320 FIND v(dout0_162) AT=665.025n

.meas tran vdout0_163ck1320 FIND v(dout0_163) AT=665.025n

.meas tran vdout0_164ck1320 FIND v(dout0_164) AT=665.025n

.meas tran vdout0_165ck1320 FIND v(dout0_165) AT=665.025n

.meas tran vdout0_166ck1320 FIND v(dout0_166) AT=665.025n

.meas tran vdout0_167ck1320 FIND v(dout0_167) AT=665.025n

.meas tran vdout0_168ck1320 FIND v(dout0_168) AT=665.025n

.meas tran vdout0_169ck1320 FIND v(dout0_169) AT=665.025n

.meas tran vdout0_170ck1320 FIND v(dout0_170) AT=665.025n

.meas tran vdout0_171ck1320 FIND v(dout0_171) AT=665.025n

.meas tran vdout0_172ck1320 FIND v(dout0_172) AT=665.025n

.meas tran vdout0_173ck1320 FIND v(dout0_173) AT=665.025n

.meas tran vdout0_174ck1320 FIND v(dout0_174) AT=665.025n

.meas tran vdout0_175ck1320 FIND v(dout0_175) AT=665.025n

.meas tran vdout0_176ck1320 FIND v(dout0_176) AT=665.025n

.meas tran vdout0_177ck1320 FIND v(dout0_177) AT=665.025n

.meas tran vdout0_178ck1320 FIND v(dout0_178) AT=665.025n

.meas tran vdout0_179ck1320 FIND v(dout0_179) AT=665.025n

.meas tran vdout0_180ck1320 FIND v(dout0_180) AT=665.025n

.meas tran vdout0_181ck1320 FIND v(dout0_181) AT=665.025n

.meas tran vdout0_182ck1320 FIND v(dout0_182) AT=665.025n

.meas tran vdout0_183ck1320 FIND v(dout0_183) AT=665.025n

.meas tran vdout0_184ck1320 FIND v(dout0_184) AT=665.025n

.meas tran vdout0_185ck1320 FIND v(dout0_185) AT=665.025n

.meas tran vdout0_186ck1320 FIND v(dout0_186) AT=665.025n

.meas tran vdout0_187ck1320 FIND v(dout0_187) AT=665.025n

.meas tran vdout0_188ck1320 FIND v(dout0_188) AT=665.025n

.meas tran vdout0_189ck1320 FIND v(dout0_189) AT=665.025n

.meas tran vdout0_190ck1320 FIND v(dout0_190) AT=665.025n

.meas tran vdout0_191ck1320 FIND v(dout0_191) AT=665.025n

.meas tran vdout0_192ck1320 FIND v(dout0_192) AT=665.025n

.meas tran vdout0_193ck1320 FIND v(dout0_193) AT=665.025n

.meas tran vdout0_194ck1320 FIND v(dout0_194) AT=665.025n

.meas tran vdout0_195ck1320 FIND v(dout0_195) AT=665.025n

.meas tran vdout0_196ck1320 FIND v(dout0_196) AT=665.025n

.meas tran vdout0_197ck1320 FIND v(dout0_197) AT=665.025n

.meas tran vdout0_198ck1320 FIND v(dout0_198) AT=665.025n

.meas tran vdout0_199ck1320 FIND v(dout0_199) AT=665.025n

.meas tran vdout0_200ck1320 FIND v(dout0_200) AT=665.025n

.meas tran vdout0_201ck1320 FIND v(dout0_201) AT=665.025n

.meas tran vdout0_202ck1320 FIND v(dout0_202) AT=665.025n

.meas tran vdout0_203ck1320 FIND v(dout0_203) AT=665.025n

.meas tran vdout0_204ck1320 FIND v(dout0_204) AT=665.025n

.meas tran vdout0_205ck1320 FIND v(dout0_205) AT=665.025n

.meas tran vdout0_206ck1320 FIND v(dout0_206) AT=665.025n

.meas tran vdout0_207ck1320 FIND v(dout0_207) AT=665.025n

.meas tran vdout0_208ck1320 FIND v(dout0_208) AT=665.025n

.meas tran vdout0_209ck1320 FIND v(dout0_209) AT=665.025n

.meas tran vdout0_210ck1320 FIND v(dout0_210) AT=665.025n

.meas tran vdout0_211ck1320 FIND v(dout0_211) AT=665.025n

.meas tran vdout0_212ck1320 FIND v(dout0_212) AT=665.025n

.meas tran vdout0_213ck1320 FIND v(dout0_213) AT=665.025n

.meas tran vdout0_214ck1320 FIND v(dout0_214) AT=665.025n

.meas tran vdout0_215ck1320 FIND v(dout0_215) AT=665.025n

.meas tran vdout0_216ck1320 FIND v(dout0_216) AT=665.025n

.meas tran vdout0_217ck1320 FIND v(dout0_217) AT=665.025n

.meas tran vdout0_218ck1320 FIND v(dout0_218) AT=665.025n

.meas tran vdout0_219ck1320 FIND v(dout0_219) AT=665.025n

.meas tran vdout0_220ck1320 FIND v(dout0_220) AT=665.025n

.meas tran vdout0_221ck1320 FIND v(dout0_221) AT=665.025n

.meas tran vdout0_222ck1320 FIND v(dout0_222) AT=665.025n

.meas tran vdout0_223ck1320 FIND v(dout0_223) AT=665.025n

.meas tran vdout0_224ck1320 FIND v(dout0_224) AT=665.025n

.meas tran vdout0_225ck1320 FIND v(dout0_225) AT=665.025n

.meas tran vdout0_226ck1320 FIND v(dout0_226) AT=665.025n

.meas tran vdout0_227ck1320 FIND v(dout0_227) AT=665.025n

.meas tran vdout0_228ck1320 FIND v(dout0_228) AT=665.025n

.meas tran vdout0_229ck1320 FIND v(dout0_229) AT=665.025n

.meas tran vdout0_230ck1320 FIND v(dout0_230) AT=665.025n

.meas tran vdout0_231ck1320 FIND v(dout0_231) AT=665.025n

.meas tran vdout0_232ck1320 FIND v(dout0_232) AT=665.025n

.meas tran vdout0_233ck1320 FIND v(dout0_233) AT=665.025n

.meas tran vdout0_234ck1320 FIND v(dout0_234) AT=665.025n

.meas tran vdout0_235ck1320 FIND v(dout0_235) AT=665.025n

.meas tran vdout0_236ck1320 FIND v(dout0_236) AT=665.025n

.meas tran vdout0_237ck1320 FIND v(dout0_237) AT=665.025n

.meas tran vdout0_238ck1320 FIND v(dout0_238) AT=665.025n

.meas tran vdout0_239ck1320 FIND v(dout0_239) AT=665.025n

.meas tran vdout0_240ck1320 FIND v(dout0_240) AT=665.025n

.meas tran vdout0_241ck1320 FIND v(dout0_241) AT=665.025n

.meas tran vdout0_242ck1320 FIND v(dout0_242) AT=665.025n

.meas tran vdout0_243ck1320 FIND v(dout0_243) AT=665.025n

.meas tran vdout0_244ck1320 FIND v(dout0_244) AT=665.025n

.meas tran vdout0_245ck1320 FIND v(dout0_245) AT=665.025n

.meas tran vdout0_246ck1320 FIND v(dout0_246) AT=665.025n

.meas tran vdout0_247ck1320 FIND v(dout0_247) AT=665.025n

.meas tran vdout0_248ck1320 FIND v(dout0_248) AT=665.025n

.meas tran vdout0_249ck1320 FIND v(dout0_249) AT=665.025n

.meas tran vdout0_250ck1320 FIND v(dout0_250) AT=665.025n

.meas tran vdout0_251ck1320 FIND v(dout0_251) AT=665.025n

.meas tran vdout0_252ck1320 FIND v(dout0_252) AT=665.025n

.meas tran vdout0_253ck1320 FIND v(dout0_253) AT=665.025n

.meas tran vdout0_254ck1320 FIND v(dout0_254) AT=665.025n

.meas tran vdout0_255ck1320 FIND v(dout0_255) AT=665.025n

.meas tran vdout0_0ck1330 FIND v(dout0_0) AT=670.025n

.meas tran vdout0_1ck1330 FIND v(dout0_1) AT=670.025n

.meas tran vdout0_2ck1330 FIND v(dout0_2) AT=670.025n

.meas tran vdout0_3ck1330 FIND v(dout0_3) AT=670.025n

.meas tran vdout0_4ck1330 FIND v(dout0_4) AT=670.025n

.meas tran vdout0_5ck1330 FIND v(dout0_5) AT=670.025n

.meas tran vdout0_6ck1330 FIND v(dout0_6) AT=670.025n

.meas tran vdout0_7ck1330 FIND v(dout0_7) AT=670.025n

.meas tran vdout0_8ck1330 FIND v(dout0_8) AT=670.025n

.meas tran vdout0_9ck1330 FIND v(dout0_9) AT=670.025n

.meas tran vdout0_10ck1330 FIND v(dout0_10) AT=670.025n

.meas tran vdout0_11ck1330 FIND v(dout0_11) AT=670.025n

.meas tran vdout0_12ck1330 FIND v(dout0_12) AT=670.025n

.meas tran vdout0_13ck1330 FIND v(dout0_13) AT=670.025n

.meas tran vdout0_14ck1330 FIND v(dout0_14) AT=670.025n

.meas tran vdout0_15ck1330 FIND v(dout0_15) AT=670.025n

.meas tran vdout0_16ck1330 FIND v(dout0_16) AT=670.025n

.meas tran vdout0_17ck1330 FIND v(dout0_17) AT=670.025n

.meas tran vdout0_18ck1330 FIND v(dout0_18) AT=670.025n

.meas tran vdout0_19ck1330 FIND v(dout0_19) AT=670.025n

.meas tran vdout0_20ck1330 FIND v(dout0_20) AT=670.025n

.meas tran vdout0_21ck1330 FIND v(dout0_21) AT=670.025n

.meas tran vdout0_22ck1330 FIND v(dout0_22) AT=670.025n

.meas tran vdout0_23ck1330 FIND v(dout0_23) AT=670.025n

.meas tran vdout0_24ck1330 FIND v(dout0_24) AT=670.025n

.meas tran vdout0_25ck1330 FIND v(dout0_25) AT=670.025n

.meas tran vdout0_26ck1330 FIND v(dout0_26) AT=670.025n

.meas tran vdout0_27ck1330 FIND v(dout0_27) AT=670.025n

.meas tran vdout0_28ck1330 FIND v(dout0_28) AT=670.025n

.meas tran vdout0_29ck1330 FIND v(dout0_29) AT=670.025n

.meas tran vdout0_30ck1330 FIND v(dout0_30) AT=670.025n

.meas tran vdout0_31ck1330 FIND v(dout0_31) AT=670.025n

.meas tran vdout0_32ck1330 FIND v(dout0_32) AT=670.025n

.meas tran vdout0_33ck1330 FIND v(dout0_33) AT=670.025n

.meas tran vdout0_34ck1330 FIND v(dout0_34) AT=670.025n

.meas tran vdout0_35ck1330 FIND v(dout0_35) AT=670.025n

.meas tran vdout0_36ck1330 FIND v(dout0_36) AT=670.025n

.meas tran vdout0_37ck1330 FIND v(dout0_37) AT=670.025n

.meas tran vdout0_38ck1330 FIND v(dout0_38) AT=670.025n

.meas tran vdout0_39ck1330 FIND v(dout0_39) AT=670.025n

.meas tran vdout0_40ck1330 FIND v(dout0_40) AT=670.025n

.meas tran vdout0_41ck1330 FIND v(dout0_41) AT=670.025n

.meas tran vdout0_42ck1330 FIND v(dout0_42) AT=670.025n

.meas tran vdout0_43ck1330 FIND v(dout0_43) AT=670.025n

.meas tran vdout0_44ck1330 FIND v(dout0_44) AT=670.025n

.meas tran vdout0_45ck1330 FIND v(dout0_45) AT=670.025n

.meas tran vdout0_46ck1330 FIND v(dout0_46) AT=670.025n

.meas tran vdout0_47ck1330 FIND v(dout0_47) AT=670.025n

.meas tran vdout0_48ck1330 FIND v(dout0_48) AT=670.025n

.meas tran vdout0_49ck1330 FIND v(dout0_49) AT=670.025n

.meas tran vdout0_50ck1330 FIND v(dout0_50) AT=670.025n

.meas tran vdout0_51ck1330 FIND v(dout0_51) AT=670.025n

.meas tran vdout0_52ck1330 FIND v(dout0_52) AT=670.025n

.meas tran vdout0_53ck1330 FIND v(dout0_53) AT=670.025n

.meas tran vdout0_54ck1330 FIND v(dout0_54) AT=670.025n

.meas tran vdout0_55ck1330 FIND v(dout0_55) AT=670.025n

.meas tran vdout0_56ck1330 FIND v(dout0_56) AT=670.025n

.meas tran vdout0_57ck1330 FIND v(dout0_57) AT=670.025n

.meas tran vdout0_58ck1330 FIND v(dout0_58) AT=670.025n

.meas tran vdout0_59ck1330 FIND v(dout0_59) AT=670.025n

.meas tran vdout0_60ck1330 FIND v(dout0_60) AT=670.025n

.meas tran vdout0_61ck1330 FIND v(dout0_61) AT=670.025n

.meas tran vdout0_62ck1330 FIND v(dout0_62) AT=670.025n

.meas tran vdout0_63ck1330 FIND v(dout0_63) AT=670.025n

.meas tran vdout0_64ck1330 FIND v(dout0_64) AT=670.025n

.meas tran vdout0_65ck1330 FIND v(dout0_65) AT=670.025n

.meas tran vdout0_66ck1330 FIND v(dout0_66) AT=670.025n

.meas tran vdout0_67ck1330 FIND v(dout0_67) AT=670.025n

.meas tran vdout0_68ck1330 FIND v(dout0_68) AT=670.025n

.meas tran vdout0_69ck1330 FIND v(dout0_69) AT=670.025n

.meas tran vdout0_70ck1330 FIND v(dout0_70) AT=670.025n

.meas tran vdout0_71ck1330 FIND v(dout0_71) AT=670.025n

.meas tran vdout0_72ck1330 FIND v(dout0_72) AT=670.025n

.meas tran vdout0_73ck1330 FIND v(dout0_73) AT=670.025n

.meas tran vdout0_74ck1330 FIND v(dout0_74) AT=670.025n

.meas tran vdout0_75ck1330 FIND v(dout0_75) AT=670.025n

.meas tran vdout0_76ck1330 FIND v(dout0_76) AT=670.025n

.meas tran vdout0_77ck1330 FIND v(dout0_77) AT=670.025n

.meas tran vdout0_78ck1330 FIND v(dout0_78) AT=670.025n

.meas tran vdout0_79ck1330 FIND v(dout0_79) AT=670.025n

.meas tran vdout0_80ck1330 FIND v(dout0_80) AT=670.025n

.meas tran vdout0_81ck1330 FIND v(dout0_81) AT=670.025n

.meas tran vdout0_82ck1330 FIND v(dout0_82) AT=670.025n

.meas tran vdout0_83ck1330 FIND v(dout0_83) AT=670.025n

.meas tran vdout0_84ck1330 FIND v(dout0_84) AT=670.025n

.meas tran vdout0_85ck1330 FIND v(dout0_85) AT=670.025n

.meas tran vdout0_86ck1330 FIND v(dout0_86) AT=670.025n

.meas tran vdout0_87ck1330 FIND v(dout0_87) AT=670.025n

.meas tran vdout0_88ck1330 FIND v(dout0_88) AT=670.025n

.meas tran vdout0_89ck1330 FIND v(dout0_89) AT=670.025n

.meas tran vdout0_90ck1330 FIND v(dout0_90) AT=670.025n

.meas tran vdout0_91ck1330 FIND v(dout0_91) AT=670.025n

.meas tran vdout0_92ck1330 FIND v(dout0_92) AT=670.025n

.meas tran vdout0_93ck1330 FIND v(dout0_93) AT=670.025n

.meas tran vdout0_94ck1330 FIND v(dout0_94) AT=670.025n

.meas tran vdout0_95ck1330 FIND v(dout0_95) AT=670.025n

.meas tran vdout0_96ck1330 FIND v(dout0_96) AT=670.025n

.meas tran vdout0_97ck1330 FIND v(dout0_97) AT=670.025n

.meas tran vdout0_98ck1330 FIND v(dout0_98) AT=670.025n

.meas tran vdout0_99ck1330 FIND v(dout0_99) AT=670.025n

.meas tran vdout0_100ck1330 FIND v(dout0_100) AT=670.025n

.meas tran vdout0_101ck1330 FIND v(dout0_101) AT=670.025n

.meas tran vdout0_102ck1330 FIND v(dout0_102) AT=670.025n

.meas tran vdout0_103ck1330 FIND v(dout0_103) AT=670.025n

.meas tran vdout0_104ck1330 FIND v(dout0_104) AT=670.025n

.meas tran vdout0_105ck1330 FIND v(dout0_105) AT=670.025n

.meas tran vdout0_106ck1330 FIND v(dout0_106) AT=670.025n

.meas tran vdout0_107ck1330 FIND v(dout0_107) AT=670.025n

.meas tran vdout0_108ck1330 FIND v(dout0_108) AT=670.025n

.meas tran vdout0_109ck1330 FIND v(dout0_109) AT=670.025n

.meas tran vdout0_110ck1330 FIND v(dout0_110) AT=670.025n

.meas tran vdout0_111ck1330 FIND v(dout0_111) AT=670.025n

.meas tran vdout0_112ck1330 FIND v(dout0_112) AT=670.025n

.meas tran vdout0_113ck1330 FIND v(dout0_113) AT=670.025n

.meas tran vdout0_114ck1330 FIND v(dout0_114) AT=670.025n

.meas tran vdout0_115ck1330 FIND v(dout0_115) AT=670.025n

.meas tran vdout0_116ck1330 FIND v(dout0_116) AT=670.025n

.meas tran vdout0_117ck1330 FIND v(dout0_117) AT=670.025n

.meas tran vdout0_118ck1330 FIND v(dout0_118) AT=670.025n

.meas tran vdout0_119ck1330 FIND v(dout0_119) AT=670.025n

.meas tran vdout0_120ck1330 FIND v(dout0_120) AT=670.025n

.meas tran vdout0_121ck1330 FIND v(dout0_121) AT=670.025n

.meas tran vdout0_122ck1330 FIND v(dout0_122) AT=670.025n

.meas tran vdout0_123ck1330 FIND v(dout0_123) AT=670.025n

.meas tran vdout0_124ck1330 FIND v(dout0_124) AT=670.025n

.meas tran vdout0_125ck1330 FIND v(dout0_125) AT=670.025n

.meas tran vdout0_126ck1330 FIND v(dout0_126) AT=670.025n

.meas tran vdout0_127ck1330 FIND v(dout0_127) AT=670.025n

.meas tran vdout0_128ck1330 FIND v(dout0_128) AT=670.025n

.meas tran vdout0_129ck1330 FIND v(dout0_129) AT=670.025n

.meas tran vdout0_130ck1330 FIND v(dout0_130) AT=670.025n

.meas tran vdout0_131ck1330 FIND v(dout0_131) AT=670.025n

.meas tran vdout0_132ck1330 FIND v(dout0_132) AT=670.025n

.meas tran vdout0_133ck1330 FIND v(dout0_133) AT=670.025n

.meas tran vdout0_134ck1330 FIND v(dout0_134) AT=670.025n

.meas tran vdout0_135ck1330 FIND v(dout0_135) AT=670.025n

.meas tran vdout0_136ck1330 FIND v(dout0_136) AT=670.025n

.meas tran vdout0_137ck1330 FIND v(dout0_137) AT=670.025n

.meas tran vdout0_138ck1330 FIND v(dout0_138) AT=670.025n

.meas tran vdout0_139ck1330 FIND v(dout0_139) AT=670.025n

.meas tran vdout0_140ck1330 FIND v(dout0_140) AT=670.025n

.meas tran vdout0_141ck1330 FIND v(dout0_141) AT=670.025n

.meas tran vdout0_142ck1330 FIND v(dout0_142) AT=670.025n

.meas tran vdout0_143ck1330 FIND v(dout0_143) AT=670.025n

.meas tran vdout0_144ck1330 FIND v(dout0_144) AT=670.025n

.meas tran vdout0_145ck1330 FIND v(dout0_145) AT=670.025n

.meas tran vdout0_146ck1330 FIND v(dout0_146) AT=670.025n

.meas tran vdout0_147ck1330 FIND v(dout0_147) AT=670.025n

.meas tran vdout0_148ck1330 FIND v(dout0_148) AT=670.025n

.meas tran vdout0_149ck1330 FIND v(dout0_149) AT=670.025n

.meas tran vdout0_150ck1330 FIND v(dout0_150) AT=670.025n

.meas tran vdout0_151ck1330 FIND v(dout0_151) AT=670.025n

.meas tran vdout0_152ck1330 FIND v(dout0_152) AT=670.025n

.meas tran vdout0_153ck1330 FIND v(dout0_153) AT=670.025n

.meas tran vdout0_154ck1330 FIND v(dout0_154) AT=670.025n

.meas tran vdout0_155ck1330 FIND v(dout0_155) AT=670.025n

.meas tran vdout0_156ck1330 FIND v(dout0_156) AT=670.025n

.meas tran vdout0_157ck1330 FIND v(dout0_157) AT=670.025n

.meas tran vdout0_158ck1330 FIND v(dout0_158) AT=670.025n

.meas tran vdout0_159ck1330 FIND v(dout0_159) AT=670.025n

.meas tran vdout0_160ck1330 FIND v(dout0_160) AT=670.025n

.meas tran vdout0_161ck1330 FIND v(dout0_161) AT=670.025n

.meas tran vdout0_162ck1330 FIND v(dout0_162) AT=670.025n

.meas tran vdout0_163ck1330 FIND v(dout0_163) AT=670.025n

.meas tran vdout0_164ck1330 FIND v(dout0_164) AT=670.025n

.meas tran vdout0_165ck1330 FIND v(dout0_165) AT=670.025n

.meas tran vdout0_166ck1330 FIND v(dout0_166) AT=670.025n

.meas tran vdout0_167ck1330 FIND v(dout0_167) AT=670.025n

.meas tran vdout0_168ck1330 FIND v(dout0_168) AT=670.025n

.meas tran vdout0_169ck1330 FIND v(dout0_169) AT=670.025n

.meas tran vdout0_170ck1330 FIND v(dout0_170) AT=670.025n

.meas tran vdout0_171ck1330 FIND v(dout0_171) AT=670.025n

.meas tran vdout0_172ck1330 FIND v(dout0_172) AT=670.025n

.meas tran vdout0_173ck1330 FIND v(dout0_173) AT=670.025n

.meas tran vdout0_174ck1330 FIND v(dout0_174) AT=670.025n

.meas tran vdout0_175ck1330 FIND v(dout0_175) AT=670.025n

.meas tran vdout0_176ck1330 FIND v(dout0_176) AT=670.025n

.meas tran vdout0_177ck1330 FIND v(dout0_177) AT=670.025n

.meas tran vdout0_178ck1330 FIND v(dout0_178) AT=670.025n

.meas tran vdout0_179ck1330 FIND v(dout0_179) AT=670.025n

.meas tran vdout0_180ck1330 FIND v(dout0_180) AT=670.025n

.meas tran vdout0_181ck1330 FIND v(dout0_181) AT=670.025n

.meas tran vdout0_182ck1330 FIND v(dout0_182) AT=670.025n

.meas tran vdout0_183ck1330 FIND v(dout0_183) AT=670.025n

.meas tran vdout0_184ck1330 FIND v(dout0_184) AT=670.025n

.meas tran vdout0_185ck1330 FIND v(dout0_185) AT=670.025n

.meas tran vdout0_186ck1330 FIND v(dout0_186) AT=670.025n

.meas tran vdout0_187ck1330 FIND v(dout0_187) AT=670.025n

.meas tran vdout0_188ck1330 FIND v(dout0_188) AT=670.025n

.meas tran vdout0_189ck1330 FIND v(dout0_189) AT=670.025n

.meas tran vdout0_190ck1330 FIND v(dout0_190) AT=670.025n

.meas tran vdout0_191ck1330 FIND v(dout0_191) AT=670.025n

.meas tran vdout0_192ck1330 FIND v(dout0_192) AT=670.025n

.meas tran vdout0_193ck1330 FIND v(dout0_193) AT=670.025n

.meas tran vdout0_194ck1330 FIND v(dout0_194) AT=670.025n

.meas tran vdout0_195ck1330 FIND v(dout0_195) AT=670.025n

.meas tran vdout0_196ck1330 FIND v(dout0_196) AT=670.025n

.meas tran vdout0_197ck1330 FIND v(dout0_197) AT=670.025n

.meas tran vdout0_198ck1330 FIND v(dout0_198) AT=670.025n

.meas tran vdout0_199ck1330 FIND v(dout0_199) AT=670.025n

.meas tran vdout0_200ck1330 FIND v(dout0_200) AT=670.025n

.meas tran vdout0_201ck1330 FIND v(dout0_201) AT=670.025n

.meas tran vdout0_202ck1330 FIND v(dout0_202) AT=670.025n

.meas tran vdout0_203ck1330 FIND v(dout0_203) AT=670.025n

.meas tran vdout0_204ck1330 FIND v(dout0_204) AT=670.025n

.meas tran vdout0_205ck1330 FIND v(dout0_205) AT=670.025n

.meas tran vdout0_206ck1330 FIND v(dout0_206) AT=670.025n

.meas tran vdout0_207ck1330 FIND v(dout0_207) AT=670.025n

.meas tran vdout0_208ck1330 FIND v(dout0_208) AT=670.025n

.meas tran vdout0_209ck1330 FIND v(dout0_209) AT=670.025n

.meas tran vdout0_210ck1330 FIND v(dout0_210) AT=670.025n

.meas tran vdout0_211ck1330 FIND v(dout0_211) AT=670.025n

.meas tran vdout0_212ck1330 FIND v(dout0_212) AT=670.025n

.meas tran vdout0_213ck1330 FIND v(dout0_213) AT=670.025n

.meas tran vdout0_214ck1330 FIND v(dout0_214) AT=670.025n

.meas tran vdout0_215ck1330 FIND v(dout0_215) AT=670.025n

.meas tran vdout0_216ck1330 FIND v(dout0_216) AT=670.025n

.meas tran vdout0_217ck1330 FIND v(dout0_217) AT=670.025n

.meas tran vdout0_218ck1330 FIND v(dout0_218) AT=670.025n

.meas tran vdout0_219ck1330 FIND v(dout0_219) AT=670.025n

.meas tran vdout0_220ck1330 FIND v(dout0_220) AT=670.025n

.meas tran vdout0_221ck1330 FIND v(dout0_221) AT=670.025n

.meas tran vdout0_222ck1330 FIND v(dout0_222) AT=670.025n

.meas tran vdout0_223ck1330 FIND v(dout0_223) AT=670.025n

.meas tran vdout0_224ck1330 FIND v(dout0_224) AT=670.025n

.meas tran vdout0_225ck1330 FIND v(dout0_225) AT=670.025n

.meas tran vdout0_226ck1330 FIND v(dout0_226) AT=670.025n

.meas tran vdout0_227ck1330 FIND v(dout0_227) AT=670.025n

.meas tran vdout0_228ck1330 FIND v(dout0_228) AT=670.025n

.meas tran vdout0_229ck1330 FIND v(dout0_229) AT=670.025n

.meas tran vdout0_230ck1330 FIND v(dout0_230) AT=670.025n

.meas tran vdout0_231ck1330 FIND v(dout0_231) AT=670.025n

.meas tran vdout0_232ck1330 FIND v(dout0_232) AT=670.025n

.meas tran vdout0_233ck1330 FIND v(dout0_233) AT=670.025n

.meas tran vdout0_234ck1330 FIND v(dout0_234) AT=670.025n

.meas tran vdout0_235ck1330 FIND v(dout0_235) AT=670.025n

.meas tran vdout0_236ck1330 FIND v(dout0_236) AT=670.025n

.meas tran vdout0_237ck1330 FIND v(dout0_237) AT=670.025n

.meas tran vdout0_238ck1330 FIND v(dout0_238) AT=670.025n

.meas tran vdout0_239ck1330 FIND v(dout0_239) AT=670.025n

.meas tran vdout0_240ck1330 FIND v(dout0_240) AT=670.025n

.meas tran vdout0_241ck1330 FIND v(dout0_241) AT=670.025n

.meas tran vdout0_242ck1330 FIND v(dout0_242) AT=670.025n

.meas tran vdout0_243ck1330 FIND v(dout0_243) AT=670.025n

.meas tran vdout0_244ck1330 FIND v(dout0_244) AT=670.025n

.meas tran vdout0_245ck1330 FIND v(dout0_245) AT=670.025n

.meas tran vdout0_246ck1330 FIND v(dout0_246) AT=670.025n

.meas tran vdout0_247ck1330 FIND v(dout0_247) AT=670.025n

.meas tran vdout0_248ck1330 FIND v(dout0_248) AT=670.025n

.meas tran vdout0_249ck1330 FIND v(dout0_249) AT=670.025n

.meas tran vdout0_250ck1330 FIND v(dout0_250) AT=670.025n

.meas tran vdout0_251ck1330 FIND v(dout0_251) AT=670.025n

.meas tran vdout0_252ck1330 FIND v(dout0_252) AT=670.025n

.meas tran vdout0_253ck1330 FIND v(dout0_253) AT=670.025n

.meas tran vdout0_254ck1330 FIND v(dout0_254) AT=670.025n

.meas tran vdout0_255ck1330 FIND v(dout0_255) AT=670.025n

.meas tran vdout0_0ck1360 FIND v(dout0_0) AT=685.025n

.meas tran vdout0_1ck1360 FIND v(dout0_1) AT=685.025n

.meas tran vdout0_2ck1360 FIND v(dout0_2) AT=685.025n

.meas tran vdout0_3ck1360 FIND v(dout0_3) AT=685.025n

.meas tran vdout0_4ck1360 FIND v(dout0_4) AT=685.025n

.meas tran vdout0_5ck1360 FIND v(dout0_5) AT=685.025n

.meas tran vdout0_6ck1360 FIND v(dout0_6) AT=685.025n

.meas tran vdout0_7ck1360 FIND v(dout0_7) AT=685.025n

.meas tran vdout0_8ck1360 FIND v(dout0_8) AT=685.025n

.meas tran vdout0_9ck1360 FIND v(dout0_9) AT=685.025n

.meas tran vdout0_10ck1360 FIND v(dout0_10) AT=685.025n

.meas tran vdout0_11ck1360 FIND v(dout0_11) AT=685.025n

.meas tran vdout0_12ck1360 FIND v(dout0_12) AT=685.025n

.meas tran vdout0_13ck1360 FIND v(dout0_13) AT=685.025n

.meas tran vdout0_14ck1360 FIND v(dout0_14) AT=685.025n

.meas tran vdout0_15ck1360 FIND v(dout0_15) AT=685.025n

.meas tran vdout0_16ck1360 FIND v(dout0_16) AT=685.025n

.meas tran vdout0_17ck1360 FIND v(dout0_17) AT=685.025n

.meas tran vdout0_18ck1360 FIND v(dout0_18) AT=685.025n

.meas tran vdout0_19ck1360 FIND v(dout0_19) AT=685.025n

.meas tran vdout0_20ck1360 FIND v(dout0_20) AT=685.025n

.meas tran vdout0_21ck1360 FIND v(dout0_21) AT=685.025n

.meas tran vdout0_22ck1360 FIND v(dout0_22) AT=685.025n

.meas tran vdout0_23ck1360 FIND v(dout0_23) AT=685.025n

.meas tran vdout0_24ck1360 FIND v(dout0_24) AT=685.025n

.meas tran vdout0_25ck1360 FIND v(dout0_25) AT=685.025n

.meas tran vdout0_26ck1360 FIND v(dout0_26) AT=685.025n

.meas tran vdout0_27ck1360 FIND v(dout0_27) AT=685.025n

.meas tran vdout0_28ck1360 FIND v(dout0_28) AT=685.025n

.meas tran vdout0_29ck1360 FIND v(dout0_29) AT=685.025n

.meas tran vdout0_30ck1360 FIND v(dout0_30) AT=685.025n

.meas tran vdout0_31ck1360 FIND v(dout0_31) AT=685.025n

.meas tran vdout0_32ck1360 FIND v(dout0_32) AT=685.025n

.meas tran vdout0_33ck1360 FIND v(dout0_33) AT=685.025n

.meas tran vdout0_34ck1360 FIND v(dout0_34) AT=685.025n

.meas tran vdout0_35ck1360 FIND v(dout0_35) AT=685.025n

.meas tran vdout0_36ck1360 FIND v(dout0_36) AT=685.025n

.meas tran vdout0_37ck1360 FIND v(dout0_37) AT=685.025n

.meas tran vdout0_38ck1360 FIND v(dout0_38) AT=685.025n

.meas tran vdout0_39ck1360 FIND v(dout0_39) AT=685.025n

.meas tran vdout0_40ck1360 FIND v(dout0_40) AT=685.025n

.meas tran vdout0_41ck1360 FIND v(dout0_41) AT=685.025n

.meas tran vdout0_42ck1360 FIND v(dout0_42) AT=685.025n

.meas tran vdout0_43ck1360 FIND v(dout0_43) AT=685.025n

.meas tran vdout0_44ck1360 FIND v(dout0_44) AT=685.025n

.meas tran vdout0_45ck1360 FIND v(dout0_45) AT=685.025n

.meas tran vdout0_46ck1360 FIND v(dout0_46) AT=685.025n

.meas tran vdout0_47ck1360 FIND v(dout0_47) AT=685.025n

.meas tran vdout0_48ck1360 FIND v(dout0_48) AT=685.025n

.meas tran vdout0_49ck1360 FIND v(dout0_49) AT=685.025n

.meas tran vdout0_50ck1360 FIND v(dout0_50) AT=685.025n

.meas tran vdout0_51ck1360 FIND v(dout0_51) AT=685.025n

.meas tran vdout0_52ck1360 FIND v(dout0_52) AT=685.025n

.meas tran vdout0_53ck1360 FIND v(dout0_53) AT=685.025n

.meas tran vdout0_54ck1360 FIND v(dout0_54) AT=685.025n

.meas tran vdout0_55ck1360 FIND v(dout0_55) AT=685.025n

.meas tran vdout0_56ck1360 FIND v(dout0_56) AT=685.025n

.meas tran vdout0_57ck1360 FIND v(dout0_57) AT=685.025n

.meas tran vdout0_58ck1360 FIND v(dout0_58) AT=685.025n

.meas tran vdout0_59ck1360 FIND v(dout0_59) AT=685.025n

.meas tran vdout0_60ck1360 FIND v(dout0_60) AT=685.025n

.meas tran vdout0_61ck1360 FIND v(dout0_61) AT=685.025n

.meas tran vdout0_62ck1360 FIND v(dout0_62) AT=685.025n

.meas tran vdout0_63ck1360 FIND v(dout0_63) AT=685.025n

.meas tran vdout0_64ck1360 FIND v(dout0_64) AT=685.025n

.meas tran vdout0_65ck1360 FIND v(dout0_65) AT=685.025n

.meas tran vdout0_66ck1360 FIND v(dout0_66) AT=685.025n

.meas tran vdout0_67ck1360 FIND v(dout0_67) AT=685.025n

.meas tran vdout0_68ck1360 FIND v(dout0_68) AT=685.025n

.meas tran vdout0_69ck1360 FIND v(dout0_69) AT=685.025n

.meas tran vdout0_70ck1360 FIND v(dout0_70) AT=685.025n

.meas tran vdout0_71ck1360 FIND v(dout0_71) AT=685.025n

.meas tran vdout0_72ck1360 FIND v(dout0_72) AT=685.025n

.meas tran vdout0_73ck1360 FIND v(dout0_73) AT=685.025n

.meas tran vdout0_74ck1360 FIND v(dout0_74) AT=685.025n

.meas tran vdout0_75ck1360 FIND v(dout0_75) AT=685.025n

.meas tran vdout0_76ck1360 FIND v(dout0_76) AT=685.025n

.meas tran vdout0_77ck1360 FIND v(dout0_77) AT=685.025n

.meas tran vdout0_78ck1360 FIND v(dout0_78) AT=685.025n

.meas tran vdout0_79ck1360 FIND v(dout0_79) AT=685.025n

.meas tran vdout0_80ck1360 FIND v(dout0_80) AT=685.025n

.meas tran vdout0_81ck1360 FIND v(dout0_81) AT=685.025n

.meas tran vdout0_82ck1360 FIND v(dout0_82) AT=685.025n

.meas tran vdout0_83ck1360 FIND v(dout0_83) AT=685.025n

.meas tran vdout0_84ck1360 FIND v(dout0_84) AT=685.025n

.meas tran vdout0_85ck1360 FIND v(dout0_85) AT=685.025n

.meas tran vdout0_86ck1360 FIND v(dout0_86) AT=685.025n

.meas tran vdout0_87ck1360 FIND v(dout0_87) AT=685.025n

.meas tran vdout0_88ck1360 FIND v(dout0_88) AT=685.025n

.meas tran vdout0_89ck1360 FIND v(dout0_89) AT=685.025n

.meas tran vdout0_90ck1360 FIND v(dout0_90) AT=685.025n

.meas tran vdout0_91ck1360 FIND v(dout0_91) AT=685.025n

.meas tran vdout0_92ck1360 FIND v(dout0_92) AT=685.025n

.meas tran vdout0_93ck1360 FIND v(dout0_93) AT=685.025n

.meas tran vdout0_94ck1360 FIND v(dout0_94) AT=685.025n

.meas tran vdout0_95ck1360 FIND v(dout0_95) AT=685.025n

.meas tran vdout0_96ck1360 FIND v(dout0_96) AT=685.025n

.meas tran vdout0_97ck1360 FIND v(dout0_97) AT=685.025n

.meas tran vdout0_98ck1360 FIND v(dout0_98) AT=685.025n

.meas tran vdout0_99ck1360 FIND v(dout0_99) AT=685.025n

.meas tran vdout0_100ck1360 FIND v(dout0_100) AT=685.025n

.meas tran vdout0_101ck1360 FIND v(dout0_101) AT=685.025n

.meas tran vdout0_102ck1360 FIND v(dout0_102) AT=685.025n

.meas tran vdout0_103ck1360 FIND v(dout0_103) AT=685.025n

.meas tran vdout0_104ck1360 FIND v(dout0_104) AT=685.025n

.meas tran vdout0_105ck1360 FIND v(dout0_105) AT=685.025n

.meas tran vdout0_106ck1360 FIND v(dout0_106) AT=685.025n

.meas tran vdout0_107ck1360 FIND v(dout0_107) AT=685.025n

.meas tran vdout0_108ck1360 FIND v(dout0_108) AT=685.025n

.meas tran vdout0_109ck1360 FIND v(dout0_109) AT=685.025n

.meas tran vdout0_110ck1360 FIND v(dout0_110) AT=685.025n

.meas tran vdout0_111ck1360 FIND v(dout0_111) AT=685.025n

.meas tran vdout0_112ck1360 FIND v(dout0_112) AT=685.025n

.meas tran vdout0_113ck1360 FIND v(dout0_113) AT=685.025n

.meas tran vdout0_114ck1360 FIND v(dout0_114) AT=685.025n

.meas tran vdout0_115ck1360 FIND v(dout0_115) AT=685.025n

.meas tran vdout0_116ck1360 FIND v(dout0_116) AT=685.025n

.meas tran vdout0_117ck1360 FIND v(dout0_117) AT=685.025n

.meas tran vdout0_118ck1360 FIND v(dout0_118) AT=685.025n

.meas tran vdout0_119ck1360 FIND v(dout0_119) AT=685.025n

.meas tran vdout0_120ck1360 FIND v(dout0_120) AT=685.025n

.meas tran vdout0_121ck1360 FIND v(dout0_121) AT=685.025n

.meas tran vdout0_122ck1360 FIND v(dout0_122) AT=685.025n

.meas tran vdout0_123ck1360 FIND v(dout0_123) AT=685.025n

.meas tran vdout0_124ck1360 FIND v(dout0_124) AT=685.025n

.meas tran vdout0_125ck1360 FIND v(dout0_125) AT=685.025n

.meas tran vdout0_126ck1360 FIND v(dout0_126) AT=685.025n

.meas tran vdout0_127ck1360 FIND v(dout0_127) AT=685.025n

.meas tran vdout0_128ck1360 FIND v(dout0_128) AT=685.025n

.meas tran vdout0_129ck1360 FIND v(dout0_129) AT=685.025n

.meas tran vdout0_130ck1360 FIND v(dout0_130) AT=685.025n

.meas tran vdout0_131ck1360 FIND v(dout0_131) AT=685.025n

.meas tran vdout0_132ck1360 FIND v(dout0_132) AT=685.025n

.meas tran vdout0_133ck1360 FIND v(dout0_133) AT=685.025n

.meas tran vdout0_134ck1360 FIND v(dout0_134) AT=685.025n

.meas tran vdout0_135ck1360 FIND v(dout0_135) AT=685.025n

.meas tran vdout0_136ck1360 FIND v(dout0_136) AT=685.025n

.meas tran vdout0_137ck1360 FIND v(dout0_137) AT=685.025n

.meas tran vdout0_138ck1360 FIND v(dout0_138) AT=685.025n

.meas tran vdout0_139ck1360 FIND v(dout0_139) AT=685.025n

.meas tran vdout0_140ck1360 FIND v(dout0_140) AT=685.025n

.meas tran vdout0_141ck1360 FIND v(dout0_141) AT=685.025n

.meas tran vdout0_142ck1360 FIND v(dout0_142) AT=685.025n

.meas tran vdout0_143ck1360 FIND v(dout0_143) AT=685.025n

.meas tran vdout0_144ck1360 FIND v(dout0_144) AT=685.025n

.meas tran vdout0_145ck1360 FIND v(dout0_145) AT=685.025n

.meas tran vdout0_146ck1360 FIND v(dout0_146) AT=685.025n

.meas tran vdout0_147ck1360 FIND v(dout0_147) AT=685.025n

.meas tran vdout0_148ck1360 FIND v(dout0_148) AT=685.025n

.meas tran vdout0_149ck1360 FIND v(dout0_149) AT=685.025n

.meas tran vdout0_150ck1360 FIND v(dout0_150) AT=685.025n

.meas tran vdout0_151ck1360 FIND v(dout0_151) AT=685.025n

.meas tran vdout0_152ck1360 FIND v(dout0_152) AT=685.025n

.meas tran vdout0_153ck1360 FIND v(dout0_153) AT=685.025n

.meas tran vdout0_154ck1360 FIND v(dout0_154) AT=685.025n

.meas tran vdout0_155ck1360 FIND v(dout0_155) AT=685.025n

.meas tran vdout0_156ck1360 FIND v(dout0_156) AT=685.025n

.meas tran vdout0_157ck1360 FIND v(dout0_157) AT=685.025n

.meas tran vdout0_158ck1360 FIND v(dout0_158) AT=685.025n

.meas tran vdout0_159ck1360 FIND v(dout0_159) AT=685.025n

.meas tran vdout0_160ck1360 FIND v(dout0_160) AT=685.025n

.meas tran vdout0_161ck1360 FIND v(dout0_161) AT=685.025n

.meas tran vdout0_162ck1360 FIND v(dout0_162) AT=685.025n

.meas tran vdout0_163ck1360 FIND v(dout0_163) AT=685.025n

.meas tran vdout0_164ck1360 FIND v(dout0_164) AT=685.025n

.meas tran vdout0_165ck1360 FIND v(dout0_165) AT=685.025n

.meas tran vdout0_166ck1360 FIND v(dout0_166) AT=685.025n

.meas tran vdout0_167ck1360 FIND v(dout0_167) AT=685.025n

.meas tran vdout0_168ck1360 FIND v(dout0_168) AT=685.025n

.meas tran vdout0_169ck1360 FIND v(dout0_169) AT=685.025n

.meas tran vdout0_170ck1360 FIND v(dout0_170) AT=685.025n

.meas tran vdout0_171ck1360 FIND v(dout0_171) AT=685.025n

.meas tran vdout0_172ck1360 FIND v(dout0_172) AT=685.025n

.meas tran vdout0_173ck1360 FIND v(dout0_173) AT=685.025n

.meas tran vdout0_174ck1360 FIND v(dout0_174) AT=685.025n

.meas tran vdout0_175ck1360 FIND v(dout0_175) AT=685.025n

.meas tran vdout0_176ck1360 FIND v(dout0_176) AT=685.025n

.meas tran vdout0_177ck1360 FIND v(dout0_177) AT=685.025n

.meas tran vdout0_178ck1360 FIND v(dout0_178) AT=685.025n

.meas tran vdout0_179ck1360 FIND v(dout0_179) AT=685.025n

.meas tran vdout0_180ck1360 FIND v(dout0_180) AT=685.025n

.meas tran vdout0_181ck1360 FIND v(dout0_181) AT=685.025n

.meas tran vdout0_182ck1360 FIND v(dout0_182) AT=685.025n

.meas tran vdout0_183ck1360 FIND v(dout0_183) AT=685.025n

.meas tran vdout0_184ck1360 FIND v(dout0_184) AT=685.025n

.meas tran vdout0_185ck1360 FIND v(dout0_185) AT=685.025n

.meas tran vdout0_186ck1360 FIND v(dout0_186) AT=685.025n

.meas tran vdout0_187ck1360 FIND v(dout0_187) AT=685.025n

.meas tran vdout0_188ck1360 FIND v(dout0_188) AT=685.025n

.meas tran vdout0_189ck1360 FIND v(dout0_189) AT=685.025n

.meas tran vdout0_190ck1360 FIND v(dout0_190) AT=685.025n

.meas tran vdout0_191ck1360 FIND v(dout0_191) AT=685.025n

.meas tran vdout0_192ck1360 FIND v(dout0_192) AT=685.025n

.meas tran vdout0_193ck1360 FIND v(dout0_193) AT=685.025n

.meas tran vdout0_194ck1360 FIND v(dout0_194) AT=685.025n

.meas tran vdout0_195ck1360 FIND v(dout0_195) AT=685.025n

.meas tran vdout0_196ck1360 FIND v(dout0_196) AT=685.025n

.meas tran vdout0_197ck1360 FIND v(dout0_197) AT=685.025n

.meas tran vdout0_198ck1360 FIND v(dout0_198) AT=685.025n

.meas tran vdout0_199ck1360 FIND v(dout0_199) AT=685.025n

.meas tran vdout0_200ck1360 FIND v(dout0_200) AT=685.025n

.meas tran vdout0_201ck1360 FIND v(dout0_201) AT=685.025n

.meas tran vdout0_202ck1360 FIND v(dout0_202) AT=685.025n

.meas tran vdout0_203ck1360 FIND v(dout0_203) AT=685.025n

.meas tran vdout0_204ck1360 FIND v(dout0_204) AT=685.025n

.meas tran vdout0_205ck1360 FIND v(dout0_205) AT=685.025n

.meas tran vdout0_206ck1360 FIND v(dout0_206) AT=685.025n

.meas tran vdout0_207ck1360 FIND v(dout0_207) AT=685.025n

.meas tran vdout0_208ck1360 FIND v(dout0_208) AT=685.025n

.meas tran vdout0_209ck1360 FIND v(dout0_209) AT=685.025n

.meas tran vdout0_210ck1360 FIND v(dout0_210) AT=685.025n

.meas tran vdout0_211ck1360 FIND v(dout0_211) AT=685.025n

.meas tran vdout0_212ck1360 FIND v(dout0_212) AT=685.025n

.meas tran vdout0_213ck1360 FIND v(dout0_213) AT=685.025n

.meas tran vdout0_214ck1360 FIND v(dout0_214) AT=685.025n

.meas tran vdout0_215ck1360 FIND v(dout0_215) AT=685.025n

.meas tran vdout0_216ck1360 FIND v(dout0_216) AT=685.025n

.meas tran vdout0_217ck1360 FIND v(dout0_217) AT=685.025n

.meas tran vdout0_218ck1360 FIND v(dout0_218) AT=685.025n

.meas tran vdout0_219ck1360 FIND v(dout0_219) AT=685.025n

.meas tran vdout0_220ck1360 FIND v(dout0_220) AT=685.025n

.meas tran vdout0_221ck1360 FIND v(dout0_221) AT=685.025n

.meas tran vdout0_222ck1360 FIND v(dout0_222) AT=685.025n

.meas tran vdout0_223ck1360 FIND v(dout0_223) AT=685.025n

.meas tran vdout0_224ck1360 FIND v(dout0_224) AT=685.025n

.meas tran vdout0_225ck1360 FIND v(dout0_225) AT=685.025n

.meas tran vdout0_226ck1360 FIND v(dout0_226) AT=685.025n

.meas tran vdout0_227ck1360 FIND v(dout0_227) AT=685.025n

.meas tran vdout0_228ck1360 FIND v(dout0_228) AT=685.025n

.meas tran vdout0_229ck1360 FIND v(dout0_229) AT=685.025n

.meas tran vdout0_230ck1360 FIND v(dout0_230) AT=685.025n

.meas tran vdout0_231ck1360 FIND v(dout0_231) AT=685.025n

.meas tran vdout0_232ck1360 FIND v(dout0_232) AT=685.025n

.meas tran vdout0_233ck1360 FIND v(dout0_233) AT=685.025n

.meas tran vdout0_234ck1360 FIND v(dout0_234) AT=685.025n

.meas tran vdout0_235ck1360 FIND v(dout0_235) AT=685.025n

.meas tran vdout0_236ck1360 FIND v(dout0_236) AT=685.025n

.meas tran vdout0_237ck1360 FIND v(dout0_237) AT=685.025n

.meas tran vdout0_238ck1360 FIND v(dout0_238) AT=685.025n

.meas tran vdout0_239ck1360 FIND v(dout0_239) AT=685.025n

.meas tran vdout0_240ck1360 FIND v(dout0_240) AT=685.025n

.meas tran vdout0_241ck1360 FIND v(dout0_241) AT=685.025n

.meas tran vdout0_242ck1360 FIND v(dout0_242) AT=685.025n

.meas tran vdout0_243ck1360 FIND v(dout0_243) AT=685.025n

.meas tran vdout0_244ck1360 FIND v(dout0_244) AT=685.025n

.meas tran vdout0_245ck1360 FIND v(dout0_245) AT=685.025n

.meas tran vdout0_246ck1360 FIND v(dout0_246) AT=685.025n

.meas tran vdout0_247ck1360 FIND v(dout0_247) AT=685.025n

.meas tran vdout0_248ck1360 FIND v(dout0_248) AT=685.025n

.meas tran vdout0_249ck1360 FIND v(dout0_249) AT=685.025n

.meas tran vdout0_250ck1360 FIND v(dout0_250) AT=685.025n

.meas tran vdout0_251ck1360 FIND v(dout0_251) AT=685.025n

.meas tran vdout0_252ck1360 FIND v(dout0_252) AT=685.025n

.meas tran vdout0_253ck1360 FIND v(dout0_253) AT=685.025n

.meas tran vdout0_254ck1360 FIND v(dout0_254) AT=685.025n

.meas tran vdout0_255ck1360 FIND v(dout0_255) AT=685.025n

.meas tran vdout0_0ck1370 FIND v(dout0_0) AT=690.025n

.meas tran vdout0_1ck1370 FIND v(dout0_1) AT=690.025n

.meas tran vdout0_2ck1370 FIND v(dout0_2) AT=690.025n

.meas tran vdout0_3ck1370 FIND v(dout0_3) AT=690.025n

.meas tran vdout0_4ck1370 FIND v(dout0_4) AT=690.025n

.meas tran vdout0_5ck1370 FIND v(dout0_5) AT=690.025n

.meas tran vdout0_6ck1370 FIND v(dout0_6) AT=690.025n

.meas tran vdout0_7ck1370 FIND v(dout0_7) AT=690.025n

.meas tran vdout0_8ck1370 FIND v(dout0_8) AT=690.025n

.meas tran vdout0_9ck1370 FIND v(dout0_9) AT=690.025n

.meas tran vdout0_10ck1370 FIND v(dout0_10) AT=690.025n

.meas tran vdout0_11ck1370 FIND v(dout0_11) AT=690.025n

.meas tran vdout0_12ck1370 FIND v(dout0_12) AT=690.025n

.meas tran vdout0_13ck1370 FIND v(dout0_13) AT=690.025n

.meas tran vdout0_14ck1370 FIND v(dout0_14) AT=690.025n

.meas tran vdout0_15ck1370 FIND v(dout0_15) AT=690.025n

.meas tran vdout0_16ck1370 FIND v(dout0_16) AT=690.025n

.meas tran vdout0_17ck1370 FIND v(dout0_17) AT=690.025n

.meas tran vdout0_18ck1370 FIND v(dout0_18) AT=690.025n

.meas tran vdout0_19ck1370 FIND v(dout0_19) AT=690.025n

.meas tran vdout0_20ck1370 FIND v(dout0_20) AT=690.025n

.meas tran vdout0_21ck1370 FIND v(dout0_21) AT=690.025n

.meas tran vdout0_22ck1370 FIND v(dout0_22) AT=690.025n

.meas tran vdout0_23ck1370 FIND v(dout0_23) AT=690.025n

.meas tran vdout0_24ck1370 FIND v(dout0_24) AT=690.025n

.meas tran vdout0_25ck1370 FIND v(dout0_25) AT=690.025n

.meas tran vdout0_26ck1370 FIND v(dout0_26) AT=690.025n

.meas tran vdout0_27ck1370 FIND v(dout0_27) AT=690.025n

.meas tran vdout0_28ck1370 FIND v(dout0_28) AT=690.025n

.meas tran vdout0_29ck1370 FIND v(dout0_29) AT=690.025n

.meas tran vdout0_30ck1370 FIND v(dout0_30) AT=690.025n

.meas tran vdout0_31ck1370 FIND v(dout0_31) AT=690.025n

.meas tran vdout0_32ck1370 FIND v(dout0_32) AT=690.025n

.meas tran vdout0_33ck1370 FIND v(dout0_33) AT=690.025n

.meas tran vdout0_34ck1370 FIND v(dout0_34) AT=690.025n

.meas tran vdout0_35ck1370 FIND v(dout0_35) AT=690.025n

.meas tran vdout0_36ck1370 FIND v(dout0_36) AT=690.025n

.meas tran vdout0_37ck1370 FIND v(dout0_37) AT=690.025n

.meas tran vdout0_38ck1370 FIND v(dout0_38) AT=690.025n

.meas tran vdout0_39ck1370 FIND v(dout0_39) AT=690.025n

.meas tran vdout0_40ck1370 FIND v(dout0_40) AT=690.025n

.meas tran vdout0_41ck1370 FIND v(dout0_41) AT=690.025n

.meas tran vdout0_42ck1370 FIND v(dout0_42) AT=690.025n

.meas tran vdout0_43ck1370 FIND v(dout0_43) AT=690.025n

.meas tran vdout0_44ck1370 FIND v(dout0_44) AT=690.025n

.meas tran vdout0_45ck1370 FIND v(dout0_45) AT=690.025n

.meas tran vdout0_46ck1370 FIND v(dout0_46) AT=690.025n

.meas tran vdout0_47ck1370 FIND v(dout0_47) AT=690.025n

.meas tran vdout0_48ck1370 FIND v(dout0_48) AT=690.025n

.meas tran vdout0_49ck1370 FIND v(dout0_49) AT=690.025n

.meas tran vdout0_50ck1370 FIND v(dout0_50) AT=690.025n

.meas tran vdout0_51ck1370 FIND v(dout0_51) AT=690.025n

.meas tran vdout0_52ck1370 FIND v(dout0_52) AT=690.025n

.meas tran vdout0_53ck1370 FIND v(dout0_53) AT=690.025n

.meas tran vdout0_54ck1370 FIND v(dout0_54) AT=690.025n

.meas tran vdout0_55ck1370 FIND v(dout0_55) AT=690.025n

.meas tran vdout0_56ck1370 FIND v(dout0_56) AT=690.025n

.meas tran vdout0_57ck1370 FIND v(dout0_57) AT=690.025n

.meas tran vdout0_58ck1370 FIND v(dout0_58) AT=690.025n

.meas tran vdout0_59ck1370 FIND v(dout0_59) AT=690.025n

.meas tran vdout0_60ck1370 FIND v(dout0_60) AT=690.025n

.meas tran vdout0_61ck1370 FIND v(dout0_61) AT=690.025n

.meas tran vdout0_62ck1370 FIND v(dout0_62) AT=690.025n

.meas tran vdout0_63ck1370 FIND v(dout0_63) AT=690.025n

.meas tran vdout0_64ck1370 FIND v(dout0_64) AT=690.025n

.meas tran vdout0_65ck1370 FIND v(dout0_65) AT=690.025n

.meas tran vdout0_66ck1370 FIND v(dout0_66) AT=690.025n

.meas tran vdout0_67ck1370 FIND v(dout0_67) AT=690.025n

.meas tran vdout0_68ck1370 FIND v(dout0_68) AT=690.025n

.meas tran vdout0_69ck1370 FIND v(dout0_69) AT=690.025n

.meas tran vdout0_70ck1370 FIND v(dout0_70) AT=690.025n

.meas tran vdout0_71ck1370 FIND v(dout0_71) AT=690.025n

.meas tran vdout0_72ck1370 FIND v(dout0_72) AT=690.025n

.meas tran vdout0_73ck1370 FIND v(dout0_73) AT=690.025n

.meas tran vdout0_74ck1370 FIND v(dout0_74) AT=690.025n

.meas tran vdout0_75ck1370 FIND v(dout0_75) AT=690.025n

.meas tran vdout0_76ck1370 FIND v(dout0_76) AT=690.025n

.meas tran vdout0_77ck1370 FIND v(dout0_77) AT=690.025n

.meas tran vdout0_78ck1370 FIND v(dout0_78) AT=690.025n

.meas tran vdout0_79ck1370 FIND v(dout0_79) AT=690.025n

.meas tran vdout0_80ck1370 FIND v(dout0_80) AT=690.025n

.meas tran vdout0_81ck1370 FIND v(dout0_81) AT=690.025n

.meas tran vdout0_82ck1370 FIND v(dout0_82) AT=690.025n

.meas tran vdout0_83ck1370 FIND v(dout0_83) AT=690.025n

.meas tran vdout0_84ck1370 FIND v(dout0_84) AT=690.025n

.meas tran vdout0_85ck1370 FIND v(dout0_85) AT=690.025n

.meas tran vdout0_86ck1370 FIND v(dout0_86) AT=690.025n

.meas tran vdout0_87ck1370 FIND v(dout0_87) AT=690.025n

.meas tran vdout0_88ck1370 FIND v(dout0_88) AT=690.025n

.meas tran vdout0_89ck1370 FIND v(dout0_89) AT=690.025n

.meas tran vdout0_90ck1370 FIND v(dout0_90) AT=690.025n

.meas tran vdout0_91ck1370 FIND v(dout0_91) AT=690.025n

.meas tran vdout0_92ck1370 FIND v(dout0_92) AT=690.025n

.meas tran vdout0_93ck1370 FIND v(dout0_93) AT=690.025n

.meas tran vdout0_94ck1370 FIND v(dout0_94) AT=690.025n

.meas tran vdout0_95ck1370 FIND v(dout0_95) AT=690.025n

.meas tran vdout0_96ck1370 FIND v(dout0_96) AT=690.025n

.meas tran vdout0_97ck1370 FIND v(dout0_97) AT=690.025n

.meas tran vdout0_98ck1370 FIND v(dout0_98) AT=690.025n

.meas tran vdout0_99ck1370 FIND v(dout0_99) AT=690.025n

.meas tran vdout0_100ck1370 FIND v(dout0_100) AT=690.025n

.meas tran vdout0_101ck1370 FIND v(dout0_101) AT=690.025n

.meas tran vdout0_102ck1370 FIND v(dout0_102) AT=690.025n

.meas tran vdout0_103ck1370 FIND v(dout0_103) AT=690.025n

.meas tran vdout0_104ck1370 FIND v(dout0_104) AT=690.025n

.meas tran vdout0_105ck1370 FIND v(dout0_105) AT=690.025n

.meas tran vdout0_106ck1370 FIND v(dout0_106) AT=690.025n

.meas tran vdout0_107ck1370 FIND v(dout0_107) AT=690.025n

.meas tran vdout0_108ck1370 FIND v(dout0_108) AT=690.025n

.meas tran vdout0_109ck1370 FIND v(dout0_109) AT=690.025n

.meas tran vdout0_110ck1370 FIND v(dout0_110) AT=690.025n

.meas tran vdout0_111ck1370 FIND v(dout0_111) AT=690.025n

.meas tran vdout0_112ck1370 FIND v(dout0_112) AT=690.025n

.meas tran vdout0_113ck1370 FIND v(dout0_113) AT=690.025n

.meas tran vdout0_114ck1370 FIND v(dout0_114) AT=690.025n

.meas tran vdout0_115ck1370 FIND v(dout0_115) AT=690.025n

.meas tran vdout0_116ck1370 FIND v(dout0_116) AT=690.025n

.meas tran vdout0_117ck1370 FIND v(dout0_117) AT=690.025n

.meas tran vdout0_118ck1370 FIND v(dout0_118) AT=690.025n

.meas tran vdout0_119ck1370 FIND v(dout0_119) AT=690.025n

.meas tran vdout0_120ck1370 FIND v(dout0_120) AT=690.025n

.meas tran vdout0_121ck1370 FIND v(dout0_121) AT=690.025n

.meas tran vdout0_122ck1370 FIND v(dout0_122) AT=690.025n

.meas tran vdout0_123ck1370 FIND v(dout0_123) AT=690.025n

.meas tran vdout0_124ck1370 FIND v(dout0_124) AT=690.025n

.meas tran vdout0_125ck1370 FIND v(dout0_125) AT=690.025n

.meas tran vdout0_126ck1370 FIND v(dout0_126) AT=690.025n

.meas tran vdout0_127ck1370 FIND v(dout0_127) AT=690.025n

.meas tran vdout0_128ck1370 FIND v(dout0_128) AT=690.025n

.meas tran vdout0_129ck1370 FIND v(dout0_129) AT=690.025n

.meas tran vdout0_130ck1370 FIND v(dout0_130) AT=690.025n

.meas tran vdout0_131ck1370 FIND v(dout0_131) AT=690.025n

.meas tran vdout0_132ck1370 FIND v(dout0_132) AT=690.025n

.meas tran vdout0_133ck1370 FIND v(dout0_133) AT=690.025n

.meas tran vdout0_134ck1370 FIND v(dout0_134) AT=690.025n

.meas tran vdout0_135ck1370 FIND v(dout0_135) AT=690.025n

.meas tran vdout0_136ck1370 FIND v(dout0_136) AT=690.025n

.meas tran vdout0_137ck1370 FIND v(dout0_137) AT=690.025n

.meas tran vdout0_138ck1370 FIND v(dout0_138) AT=690.025n

.meas tran vdout0_139ck1370 FIND v(dout0_139) AT=690.025n

.meas tran vdout0_140ck1370 FIND v(dout0_140) AT=690.025n

.meas tran vdout0_141ck1370 FIND v(dout0_141) AT=690.025n

.meas tran vdout0_142ck1370 FIND v(dout0_142) AT=690.025n

.meas tran vdout0_143ck1370 FIND v(dout0_143) AT=690.025n

.meas tran vdout0_144ck1370 FIND v(dout0_144) AT=690.025n

.meas tran vdout0_145ck1370 FIND v(dout0_145) AT=690.025n

.meas tran vdout0_146ck1370 FIND v(dout0_146) AT=690.025n

.meas tran vdout0_147ck1370 FIND v(dout0_147) AT=690.025n

.meas tran vdout0_148ck1370 FIND v(dout0_148) AT=690.025n

.meas tran vdout0_149ck1370 FIND v(dout0_149) AT=690.025n

.meas tran vdout0_150ck1370 FIND v(dout0_150) AT=690.025n

.meas tran vdout0_151ck1370 FIND v(dout0_151) AT=690.025n

.meas tran vdout0_152ck1370 FIND v(dout0_152) AT=690.025n

.meas tran vdout0_153ck1370 FIND v(dout0_153) AT=690.025n

.meas tran vdout0_154ck1370 FIND v(dout0_154) AT=690.025n

.meas tran vdout0_155ck1370 FIND v(dout0_155) AT=690.025n

.meas tran vdout0_156ck1370 FIND v(dout0_156) AT=690.025n

.meas tran vdout0_157ck1370 FIND v(dout0_157) AT=690.025n

.meas tran vdout0_158ck1370 FIND v(dout0_158) AT=690.025n

.meas tran vdout0_159ck1370 FIND v(dout0_159) AT=690.025n

.meas tran vdout0_160ck1370 FIND v(dout0_160) AT=690.025n

.meas tran vdout0_161ck1370 FIND v(dout0_161) AT=690.025n

.meas tran vdout0_162ck1370 FIND v(dout0_162) AT=690.025n

.meas tran vdout0_163ck1370 FIND v(dout0_163) AT=690.025n

.meas tran vdout0_164ck1370 FIND v(dout0_164) AT=690.025n

.meas tran vdout0_165ck1370 FIND v(dout0_165) AT=690.025n

.meas tran vdout0_166ck1370 FIND v(dout0_166) AT=690.025n

.meas tran vdout0_167ck1370 FIND v(dout0_167) AT=690.025n

.meas tran vdout0_168ck1370 FIND v(dout0_168) AT=690.025n

.meas tran vdout0_169ck1370 FIND v(dout0_169) AT=690.025n

.meas tran vdout0_170ck1370 FIND v(dout0_170) AT=690.025n

.meas tran vdout0_171ck1370 FIND v(dout0_171) AT=690.025n

.meas tran vdout0_172ck1370 FIND v(dout0_172) AT=690.025n

.meas tran vdout0_173ck1370 FIND v(dout0_173) AT=690.025n

.meas tran vdout0_174ck1370 FIND v(dout0_174) AT=690.025n

.meas tran vdout0_175ck1370 FIND v(dout0_175) AT=690.025n

.meas tran vdout0_176ck1370 FIND v(dout0_176) AT=690.025n

.meas tran vdout0_177ck1370 FIND v(dout0_177) AT=690.025n

.meas tran vdout0_178ck1370 FIND v(dout0_178) AT=690.025n

.meas tran vdout0_179ck1370 FIND v(dout0_179) AT=690.025n

.meas tran vdout0_180ck1370 FIND v(dout0_180) AT=690.025n

.meas tran vdout0_181ck1370 FIND v(dout0_181) AT=690.025n

.meas tran vdout0_182ck1370 FIND v(dout0_182) AT=690.025n

.meas tran vdout0_183ck1370 FIND v(dout0_183) AT=690.025n

.meas tran vdout0_184ck1370 FIND v(dout0_184) AT=690.025n

.meas tran vdout0_185ck1370 FIND v(dout0_185) AT=690.025n

.meas tran vdout0_186ck1370 FIND v(dout0_186) AT=690.025n

.meas tran vdout0_187ck1370 FIND v(dout0_187) AT=690.025n

.meas tran vdout0_188ck1370 FIND v(dout0_188) AT=690.025n

.meas tran vdout0_189ck1370 FIND v(dout0_189) AT=690.025n

.meas tran vdout0_190ck1370 FIND v(dout0_190) AT=690.025n

.meas tran vdout0_191ck1370 FIND v(dout0_191) AT=690.025n

.meas tran vdout0_192ck1370 FIND v(dout0_192) AT=690.025n

.meas tran vdout0_193ck1370 FIND v(dout0_193) AT=690.025n

.meas tran vdout0_194ck1370 FIND v(dout0_194) AT=690.025n

.meas tran vdout0_195ck1370 FIND v(dout0_195) AT=690.025n

.meas tran vdout0_196ck1370 FIND v(dout0_196) AT=690.025n

.meas tran vdout0_197ck1370 FIND v(dout0_197) AT=690.025n

.meas tran vdout0_198ck1370 FIND v(dout0_198) AT=690.025n

.meas tran vdout0_199ck1370 FIND v(dout0_199) AT=690.025n

.meas tran vdout0_200ck1370 FIND v(dout0_200) AT=690.025n

.meas tran vdout0_201ck1370 FIND v(dout0_201) AT=690.025n

.meas tran vdout0_202ck1370 FIND v(dout0_202) AT=690.025n

.meas tran vdout0_203ck1370 FIND v(dout0_203) AT=690.025n

.meas tran vdout0_204ck1370 FIND v(dout0_204) AT=690.025n

.meas tran vdout0_205ck1370 FIND v(dout0_205) AT=690.025n

.meas tran vdout0_206ck1370 FIND v(dout0_206) AT=690.025n

.meas tran vdout0_207ck1370 FIND v(dout0_207) AT=690.025n

.meas tran vdout0_208ck1370 FIND v(dout0_208) AT=690.025n

.meas tran vdout0_209ck1370 FIND v(dout0_209) AT=690.025n

.meas tran vdout0_210ck1370 FIND v(dout0_210) AT=690.025n

.meas tran vdout0_211ck1370 FIND v(dout0_211) AT=690.025n

.meas tran vdout0_212ck1370 FIND v(dout0_212) AT=690.025n

.meas tran vdout0_213ck1370 FIND v(dout0_213) AT=690.025n

.meas tran vdout0_214ck1370 FIND v(dout0_214) AT=690.025n

.meas tran vdout0_215ck1370 FIND v(dout0_215) AT=690.025n

.meas tran vdout0_216ck1370 FIND v(dout0_216) AT=690.025n

.meas tran vdout0_217ck1370 FIND v(dout0_217) AT=690.025n

.meas tran vdout0_218ck1370 FIND v(dout0_218) AT=690.025n

.meas tran vdout0_219ck1370 FIND v(dout0_219) AT=690.025n

.meas tran vdout0_220ck1370 FIND v(dout0_220) AT=690.025n

.meas tran vdout0_221ck1370 FIND v(dout0_221) AT=690.025n

.meas tran vdout0_222ck1370 FIND v(dout0_222) AT=690.025n

.meas tran vdout0_223ck1370 FIND v(dout0_223) AT=690.025n

.meas tran vdout0_224ck1370 FIND v(dout0_224) AT=690.025n

.meas tran vdout0_225ck1370 FIND v(dout0_225) AT=690.025n

.meas tran vdout0_226ck1370 FIND v(dout0_226) AT=690.025n

.meas tran vdout0_227ck1370 FIND v(dout0_227) AT=690.025n

.meas tran vdout0_228ck1370 FIND v(dout0_228) AT=690.025n

.meas tran vdout0_229ck1370 FIND v(dout0_229) AT=690.025n

.meas tran vdout0_230ck1370 FIND v(dout0_230) AT=690.025n

.meas tran vdout0_231ck1370 FIND v(dout0_231) AT=690.025n

.meas tran vdout0_232ck1370 FIND v(dout0_232) AT=690.025n

.meas tran vdout0_233ck1370 FIND v(dout0_233) AT=690.025n

.meas tran vdout0_234ck1370 FIND v(dout0_234) AT=690.025n

.meas tran vdout0_235ck1370 FIND v(dout0_235) AT=690.025n

.meas tran vdout0_236ck1370 FIND v(dout0_236) AT=690.025n

.meas tran vdout0_237ck1370 FIND v(dout0_237) AT=690.025n

.meas tran vdout0_238ck1370 FIND v(dout0_238) AT=690.025n

.meas tran vdout0_239ck1370 FIND v(dout0_239) AT=690.025n

.meas tran vdout0_240ck1370 FIND v(dout0_240) AT=690.025n

.meas tran vdout0_241ck1370 FIND v(dout0_241) AT=690.025n

.meas tran vdout0_242ck1370 FIND v(dout0_242) AT=690.025n

.meas tran vdout0_243ck1370 FIND v(dout0_243) AT=690.025n

.meas tran vdout0_244ck1370 FIND v(dout0_244) AT=690.025n

.meas tran vdout0_245ck1370 FIND v(dout0_245) AT=690.025n

.meas tran vdout0_246ck1370 FIND v(dout0_246) AT=690.025n

.meas tran vdout0_247ck1370 FIND v(dout0_247) AT=690.025n

.meas tran vdout0_248ck1370 FIND v(dout0_248) AT=690.025n

.meas tran vdout0_249ck1370 FIND v(dout0_249) AT=690.025n

.meas tran vdout0_250ck1370 FIND v(dout0_250) AT=690.025n

.meas tran vdout0_251ck1370 FIND v(dout0_251) AT=690.025n

.meas tran vdout0_252ck1370 FIND v(dout0_252) AT=690.025n

.meas tran vdout0_253ck1370 FIND v(dout0_253) AT=690.025n

.meas tran vdout0_254ck1370 FIND v(dout0_254) AT=690.025n

.meas tran vdout0_255ck1370 FIND v(dout0_255) AT=690.025n

.meas tran vdout0_0ck1440 FIND v(dout0_0) AT=725.025n

.meas tran vdout0_1ck1440 FIND v(dout0_1) AT=725.025n

.meas tran vdout0_2ck1440 FIND v(dout0_2) AT=725.025n

.meas tran vdout0_3ck1440 FIND v(dout0_3) AT=725.025n

.meas tran vdout0_4ck1440 FIND v(dout0_4) AT=725.025n

.meas tran vdout0_5ck1440 FIND v(dout0_5) AT=725.025n

.meas tran vdout0_6ck1440 FIND v(dout0_6) AT=725.025n

.meas tran vdout0_7ck1440 FIND v(dout0_7) AT=725.025n

.meas tran vdout0_8ck1440 FIND v(dout0_8) AT=725.025n

.meas tran vdout0_9ck1440 FIND v(dout0_9) AT=725.025n

.meas tran vdout0_10ck1440 FIND v(dout0_10) AT=725.025n

.meas tran vdout0_11ck1440 FIND v(dout0_11) AT=725.025n

.meas tran vdout0_12ck1440 FIND v(dout0_12) AT=725.025n

.meas tran vdout0_13ck1440 FIND v(dout0_13) AT=725.025n

.meas tran vdout0_14ck1440 FIND v(dout0_14) AT=725.025n

.meas tran vdout0_15ck1440 FIND v(dout0_15) AT=725.025n

.meas tran vdout0_16ck1440 FIND v(dout0_16) AT=725.025n

.meas tran vdout0_17ck1440 FIND v(dout0_17) AT=725.025n

.meas tran vdout0_18ck1440 FIND v(dout0_18) AT=725.025n

.meas tran vdout0_19ck1440 FIND v(dout0_19) AT=725.025n

.meas tran vdout0_20ck1440 FIND v(dout0_20) AT=725.025n

.meas tran vdout0_21ck1440 FIND v(dout0_21) AT=725.025n

.meas tran vdout0_22ck1440 FIND v(dout0_22) AT=725.025n

.meas tran vdout0_23ck1440 FIND v(dout0_23) AT=725.025n

.meas tran vdout0_24ck1440 FIND v(dout0_24) AT=725.025n

.meas tran vdout0_25ck1440 FIND v(dout0_25) AT=725.025n

.meas tran vdout0_26ck1440 FIND v(dout0_26) AT=725.025n

.meas tran vdout0_27ck1440 FIND v(dout0_27) AT=725.025n

.meas tran vdout0_28ck1440 FIND v(dout0_28) AT=725.025n

.meas tran vdout0_29ck1440 FIND v(dout0_29) AT=725.025n

.meas tran vdout0_30ck1440 FIND v(dout0_30) AT=725.025n

.meas tran vdout0_31ck1440 FIND v(dout0_31) AT=725.025n

.meas tran vdout0_32ck1440 FIND v(dout0_32) AT=725.025n

.meas tran vdout0_33ck1440 FIND v(dout0_33) AT=725.025n

.meas tran vdout0_34ck1440 FIND v(dout0_34) AT=725.025n

.meas tran vdout0_35ck1440 FIND v(dout0_35) AT=725.025n

.meas tran vdout0_36ck1440 FIND v(dout0_36) AT=725.025n

.meas tran vdout0_37ck1440 FIND v(dout0_37) AT=725.025n

.meas tran vdout0_38ck1440 FIND v(dout0_38) AT=725.025n

.meas tran vdout0_39ck1440 FIND v(dout0_39) AT=725.025n

.meas tran vdout0_40ck1440 FIND v(dout0_40) AT=725.025n

.meas tran vdout0_41ck1440 FIND v(dout0_41) AT=725.025n

.meas tran vdout0_42ck1440 FIND v(dout0_42) AT=725.025n

.meas tran vdout0_43ck1440 FIND v(dout0_43) AT=725.025n

.meas tran vdout0_44ck1440 FIND v(dout0_44) AT=725.025n

.meas tran vdout0_45ck1440 FIND v(dout0_45) AT=725.025n

.meas tran vdout0_46ck1440 FIND v(dout0_46) AT=725.025n

.meas tran vdout0_47ck1440 FIND v(dout0_47) AT=725.025n

.meas tran vdout0_48ck1440 FIND v(dout0_48) AT=725.025n

.meas tran vdout0_49ck1440 FIND v(dout0_49) AT=725.025n

.meas tran vdout0_50ck1440 FIND v(dout0_50) AT=725.025n

.meas tran vdout0_51ck1440 FIND v(dout0_51) AT=725.025n

.meas tran vdout0_52ck1440 FIND v(dout0_52) AT=725.025n

.meas tran vdout0_53ck1440 FIND v(dout0_53) AT=725.025n

.meas tran vdout0_54ck1440 FIND v(dout0_54) AT=725.025n

.meas tran vdout0_55ck1440 FIND v(dout0_55) AT=725.025n

.meas tran vdout0_56ck1440 FIND v(dout0_56) AT=725.025n

.meas tran vdout0_57ck1440 FIND v(dout0_57) AT=725.025n

.meas tran vdout0_58ck1440 FIND v(dout0_58) AT=725.025n

.meas tran vdout0_59ck1440 FIND v(dout0_59) AT=725.025n

.meas tran vdout0_60ck1440 FIND v(dout0_60) AT=725.025n

.meas tran vdout0_61ck1440 FIND v(dout0_61) AT=725.025n

.meas tran vdout0_62ck1440 FIND v(dout0_62) AT=725.025n

.meas tran vdout0_63ck1440 FIND v(dout0_63) AT=725.025n

.meas tran vdout0_64ck1440 FIND v(dout0_64) AT=725.025n

.meas tran vdout0_65ck1440 FIND v(dout0_65) AT=725.025n

.meas tran vdout0_66ck1440 FIND v(dout0_66) AT=725.025n

.meas tran vdout0_67ck1440 FIND v(dout0_67) AT=725.025n

.meas tran vdout0_68ck1440 FIND v(dout0_68) AT=725.025n

.meas tran vdout0_69ck1440 FIND v(dout0_69) AT=725.025n

.meas tran vdout0_70ck1440 FIND v(dout0_70) AT=725.025n

.meas tran vdout0_71ck1440 FIND v(dout0_71) AT=725.025n

.meas tran vdout0_72ck1440 FIND v(dout0_72) AT=725.025n

.meas tran vdout0_73ck1440 FIND v(dout0_73) AT=725.025n

.meas tran vdout0_74ck1440 FIND v(dout0_74) AT=725.025n

.meas tran vdout0_75ck1440 FIND v(dout0_75) AT=725.025n

.meas tran vdout0_76ck1440 FIND v(dout0_76) AT=725.025n

.meas tran vdout0_77ck1440 FIND v(dout0_77) AT=725.025n

.meas tran vdout0_78ck1440 FIND v(dout0_78) AT=725.025n

.meas tran vdout0_79ck1440 FIND v(dout0_79) AT=725.025n

.meas tran vdout0_80ck1440 FIND v(dout0_80) AT=725.025n

.meas tran vdout0_81ck1440 FIND v(dout0_81) AT=725.025n

.meas tran vdout0_82ck1440 FIND v(dout0_82) AT=725.025n

.meas tran vdout0_83ck1440 FIND v(dout0_83) AT=725.025n

.meas tran vdout0_84ck1440 FIND v(dout0_84) AT=725.025n

.meas tran vdout0_85ck1440 FIND v(dout0_85) AT=725.025n

.meas tran vdout0_86ck1440 FIND v(dout0_86) AT=725.025n

.meas tran vdout0_87ck1440 FIND v(dout0_87) AT=725.025n

.meas tran vdout0_88ck1440 FIND v(dout0_88) AT=725.025n

.meas tran vdout0_89ck1440 FIND v(dout0_89) AT=725.025n

.meas tran vdout0_90ck1440 FIND v(dout0_90) AT=725.025n

.meas tran vdout0_91ck1440 FIND v(dout0_91) AT=725.025n

.meas tran vdout0_92ck1440 FIND v(dout0_92) AT=725.025n

.meas tran vdout0_93ck1440 FIND v(dout0_93) AT=725.025n

.meas tran vdout0_94ck1440 FIND v(dout0_94) AT=725.025n

.meas tran vdout0_95ck1440 FIND v(dout0_95) AT=725.025n

.meas tran vdout0_96ck1440 FIND v(dout0_96) AT=725.025n

.meas tran vdout0_97ck1440 FIND v(dout0_97) AT=725.025n

.meas tran vdout0_98ck1440 FIND v(dout0_98) AT=725.025n

.meas tran vdout0_99ck1440 FIND v(dout0_99) AT=725.025n

.meas tran vdout0_100ck1440 FIND v(dout0_100) AT=725.025n

.meas tran vdout0_101ck1440 FIND v(dout0_101) AT=725.025n

.meas tran vdout0_102ck1440 FIND v(dout0_102) AT=725.025n

.meas tran vdout0_103ck1440 FIND v(dout0_103) AT=725.025n

.meas tran vdout0_104ck1440 FIND v(dout0_104) AT=725.025n

.meas tran vdout0_105ck1440 FIND v(dout0_105) AT=725.025n

.meas tran vdout0_106ck1440 FIND v(dout0_106) AT=725.025n

.meas tran vdout0_107ck1440 FIND v(dout0_107) AT=725.025n

.meas tran vdout0_108ck1440 FIND v(dout0_108) AT=725.025n

.meas tran vdout0_109ck1440 FIND v(dout0_109) AT=725.025n

.meas tran vdout0_110ck1440 FIND v(dout0_110) AT=725.025n

.meas tran vdout0_111ck1440 FIND v(dout0_111) AT=725.025n

.meas tran vdout0_112ck1440 FIND v(dout0_112) AT=725.025n

.meas tran vdout0_113ck1440 FIND v(dout0_113) AT=725.025n

.meas tran vdout0_114ck1440 FIND v(dout0_114) AT=725.025n

.meas tran vdout0_115ck1440 FIND v(dout0_115) AT=725.025n

.meas tran vdout0_116ck1440 FIND v(dout0_116) AT=725.025n

.meas tran vdout0_117ck1440 FIND v(dout0_117) AT=725.025n

.meas tran vdout0_118ck1440 FIND v(dout0_118) AT=725.025n

.meas tran vdout0_119ck1440 FIND v(dout0_119) AT=725.025n

.meas tran vdout0_120ck1440 FIND v(dout0_120) AT=725.025n

.meas tran vdout0_121ck1440 FIND v(dout0_121) AT=725.025n

.meas tran vdout0_122ck1440 FIND v(dout0_122) AT=725.025n

.meas tran vdout0_123ck1440 FIND v(dout0_123) AT=725.025n

.meas tran vdout0_124ck1440 FIND v(dout0_124) AT=725.025n

.meas tran vdout0_125ck1440 FIND v(dout0_125) AT=725.025n

.meas tran vdout0_126ck1440 FIND v(dout0_126) AT=725.025n

.meas tran vdout0_127ck1440 FIND v(dout0_127) AT=725.025n

.meas tran vdout0_128ck1440 FIND v(dout0_128) AT=725.025n

.meas tran vdout0_129ck1440 FIND v(dout0_129) AT=725.025n

.meas tran vdout0_130ck1440 FIND v(dout0_130) AT=725.025n

.meas tran vdout0_131ck1440 FIND v(dout0_131) AT=725.025n

.meas tran vdout0_132ck1440 FIND v(dout0_132) AT=725.025n

.meas tran vdout0_133ck1440 FIND v(dout0_133) AT=725.025n

.meas tran vdout0_134ck1440 FIND v(dout0_134) AT=725.025n

.meas tran vdout0_135ck1440 FIND v(dout0_135) AT=725.025n

.meas tran vdout0_136ck1440 FIND v(dout0_136) AT=725.025n

.meas tran vdout0_137ck1440 FIND v(dout0_137) AT=725.025n

.meas tran vdout0_138ck1440 FIND v(dout0_138) AT=725.025n

.meas tran vdout0_139ck1440 FIND v(dout0_139) AT=725.025n

.meas tran vdout0_140ck1440 FIND v(dout0_140) AT=725.025n

.meas tran vdout0_141ck1440 FIND v(dout0_141) AT=725.025n

.meas tran vdout0_142ck1440 FIND v(dout0_142) AT=725.025n

.meas tran vdout0_143ck1440 FIND v(dout0_143) AT=725.025n

.meas tran vdout0_144ck1440 FIND v(dout0_144) AT=725.025n

.meas tran vdout0_145ck1440 FIND v(dout0_145) AT=725.025n

.meas tran vdout0_146ck1440 FIND v(dout0_146) AT=725.025n

.meas tran vdout0_147ck1440 FIND v(dout0_147) AT=725.025n

.meas tran vdout0_148ck1440 FIND v(dout0_148) AT=725.025n

.meas tran vdout0_149ck1440 FIND v(dout0_149) AT=725.025n

.meas tran vdout0_150ck1440 FIND v(dout0_150) AT=725.025n

.meas tran vdout0_151ck1440 FIND v(dout0_151) AT=725.025n

.meas tran vdout0_152ck1440 FIND v(dout0_152) AT=725.025n

.meas tran vdout0_153ck1440 FIND v(dout0_153) AT=725.025n

.meas tran vdout0_154ck1440 FIND v(dout0_154) AT=725.025n

.meas tran vdout0_155ck1440 FIND v(dout0_155) AT=725.025n

.meas tran vdout0_156ck1440 FIND v(dout0_156) AT=725.025n

.meas tran vdout0_157ck1440 FIND v(dout0_157) AT=725.025n

.meas tran vdout0_158ck1440 FIND v(dout0_158) AT=725.025n

.meas tran vdout0_159ck1440 FIND v(dout0_159) AT=725.025n

.meas tran vdout0_160ck1440 FIND v(dout0_160) AT=725.025n

.meas tran vdout0_161ck1440 FIND v(dout0_161) AT=725.025n

.meas tran vdout0_162ck1440 FIND v(dout0_162) AT=725.025n

.meas tran vdout0_163ck1440 FIND v(dout0_163) AT=725.025n

.meas tran vdout0_164ck1440 FIND v(dout0_164) AT=725.025n

.meas tran vdout0_165ck1440 FIND v(dout0_165) AT=725.025n

.meas tran vdout0_166ck1440 FIND v(dout0_166) AT=725.025n

.meas tran vdout0_167ck1440 FIND v(dout0_167) AT=725.025n

.meas tran vdout0_168ck1440 FIND v(dout0_168) AT=725.025n

.meas tran vdout0_169ck1440 FIND v(dout0_169) AT=725.025n

.meas tran vdout0_170ck1440 FIND v(dout0_170) AT=725.025n

.meas tran vdout0_171ck1440 FIND v(dout0_171) AT=725.025n

.meas tran vdout0_172ck1440 FIND v(dout0_172) AT=725.025n

.meas tran vdout0_173ck1440 FIND v(dout0_173) AT=725.025n

.meas tran vdout0_174ck1440 FIND v(dout0_174) AT=725.025n

.meas tran vdout0_175ck1440 FIND v(dout0_175) AT=725.025n

.meas tran vdout0_176ck1440 FIND v(dout0_176) AT=725.025n

.meas tran vdout0_177ck1440 FIND v(dout0_177) AT=725.025n

.meas tran vdout0_178ck1440 FIND v(dout0_178) AT=725.025n

.meas tran vdout0_179ck1440 FIND v(dout0_179) AT=725.025n

.meas tran vdout0_180ck1440 FIND v(dout0_180) AT=725.025n

.meas tran vdout0_181ck1440 FIND v(dout0_181) AT=725.025n

.meas tran vdout0_182ck1440 FIND v(dout0_182) AT=725.025n

.meas tran vdout0_183ck1440 FIND v(dout0_183) AT=725.025n

.meas tran vdout0_184ck1440 FIND v(dout0_184) AT=725.025n

.meas tran vdout0_185ck1440 FIND v(dout0_185) AT=725.025n

.meas tran vdout0_186ck1440 FIND v(dout0_186) AT=725.025n

.meas tran vdout0_187ck1440 FIND v(dout0_187) AT=725.025n

.meas tran vdout0_188ck1440 FIND v(dout0_188) AT=725.025n

.meas tran vdout0_189ck1440 FIND v(dout0_189) AT=725.025n

.meas tran vdout0_190ck1440 FIND v(dout0_190) AT=725.025n

.meas tran vdout0_191ck1440 FIND v(dout0_191) AT=725.025n

.meas tran vdout0_192ck1440 FIND v(dout0_192) AT=725.025n

.meas tran vdout0_193ck1440 FIND v(dout0_193) AT=725.025n

.meas tran vdout0_194ck1440 FIND v(dout0_194) AT=725.025n

.meas tran vdout0_195ck1440 FIND v(dout0_195) AT=725.025n

.meas tran vdout0_196ck1440 FIND v(dout0_196) AT=725.025n

.meas tran vdout0_197ck1440 FIND v(dout0_197) AT=725.025n

.meas tran vdout0_198ck1440 FIND v(dout0_198) AT=725.025n

.meas tran vdout0_199ck1440 FIND v(dout0_199) AT=725.025n

.meas tran vdout0_200ck1440 FIND v(dout0_200) AT=725.025n

.meas tran vdout0_201ck1440 FIND v(dout0_201) AT=725.025n

.meas tran vdout0_202ck1440 FIND v(dout0_202) AT=725.025n

.meas tran vdout0_203ck1440 FIND v(dout0_203) AT=725.025n

.meas tran vdout0_204ck1440 FIND v(dout0_204) AT=725.025n

.meas tran vdout0_205ck1440 FIND v(dout0_205) AT=725.025n

.meas tran vdout0_206ck1440 FIND v(dout0_206) AT=725.025n

.meas tran vdout0_207ck1440 FIND v(dout0_207) AT=725.025n

.meas tran vdout0_208ck1440 FIND v(dout0_208) AT=725.025n

.meas tran vdout0_209ck1440 FIND v(dout0_209) AT=725.025n

.meas tran vdout0_210ck1440 FIND v(dout0_210) AT=725.025n

.meas tran vdout0_211ck1440 FIND v(dout0_211) AT=725.025n

.meas tran vdout0_212ck1440 FIND v(dout0_212) AT=725.025n

.meas tran vdout0_213ck1440 FIND v(dout0_213) AT=725.025n

.meas tran vdout0_214ck1440 FIND v(dout0_214) AT=725.025n

.meas tran vdout0_215ck1440 FIND v(dout0_215) AT=725.025n

.meas tran vdout0_216ck1440 FIND v(dout0_216) AT=725.025n

.meas tran vdout0_217ck1440 FIND v(dout0_217) AT=725.025n

.meas tran vdout0_218ck1440 FIND v(dout0_218) AT=725.025n

.meas tran vdout0_219ck1440 FIND v(dout0_219) AT=725.025n

.meas tran vdout0_220ck1440 FIND v(dout0_220) AT=725.025n

.meas tran vdout0_221ck1440 FIND v(dout0_221) AT=725.025n

.meas tran vdout0_222ck1440 FIND v(dout0_222) AT=725.025n

.meas tran vdout0_223ck1440 FIND v(dout0_223) AT=725.025n

.meas tran vdout0_224ck1440 FIND v(dout0_224) AT=725.025n

.meas tran vdout0_225ck1440 FIND v(dout0_225) AT=725.025n

.meas tran vdout0_226ck1440 FIND v(dout0_226) AT=725.025n

.meas tran vdout0_227ck1440 FIND v(dout0_227) AT=725.025n

.meas tran vdout0_228ck1440 FIND v(dout0_228) AT=725.025n

.meas tran vdout0_229ck1440 FIND v(dout0_229) AT=725.025n

.meas tran vdout0_230ck1440 FIND v(dout0_230) AT=725.025n

.meas tran vdout0_231ck1440 FIND v(dout0_231) AT=725.025n

.meas tran vdout0_232ck1440 FIND v(dout0_232) AT=725.025n

.meas tran vdout0_233ck1440 FIND v(dout0_233) AT=725.025n

.meas tran vdout0_234ck1440 FIND v(dout0_234) AT=725.025n

.meas tran vdout0_235ck1440 FIND v(dout0_235) AT=725.025n

.meas tran vdout0_236ck1440 FIND v(dout0_236) AT=725.025n

.meas tran vdout0_237ck1440 FIND v(dout0_237) AT=725.025n

.meas tran vdout0_238ck1440 FIND v(dout0_238) AT=725.025n

.meas tran vdout0_239ck1440 FIND v(dout0_239) AT=725.025n

.meas tran vdout0_240ck1440 FIND v(dout0_240) AT=725.025n

.meas tran vdout0_241ck1440 FIND v(dout0_241) AT=725.025n

.meas tran vdout0_242ck1440 FIND v(dout0_242) AT=725.025n

.meas tran vdout0_243ck1440 FIND v(dout0_243) AT=725.025n

.meas tran vdout0_244ck1440 FIND v(dout0_244) AT=725.025n

.meas tran vdout0_245ck1440 FIND v(dout0_245) AT=725.025n

.meas tran vdout0_246ck1440 FIND v(dout0_246) AT=725.025n

.meas tran vdout0_247ck1440 FIND v(dout0_247) AT=725.025n

.meas tran vdout0_248ck1440 FIND v(dout0_248) AT=725.025n

.meas tran vdout0_249ck1440 FIND v(dout0_249) AT=725.025n

.meas tran vdout0_250ck1440 FIND v(dout0_250) AT=725.025n

.meas tran vdout0_251ck1440 FIND v(dout0_251) AT=725.025n

.meas tran vdout0_252ck1440 FIND v(dout0_252) AT=725.025n

.meas tran vdout0_253ck1440 FIND v(dout0_253) AT=725.025n

.meas tran vdout0_254ck1440 FIND v(dout0_254) AT=725.025n

.meas tran vdout0_255ck1440 FIND v(dout0_255) AT=725.025n

.meas tran vdout0_0ck1450 FIND v(dout0_0) AT=730.025n

.meas tran vdout0_1ck1450 FIND v(dout0_1) AT=730.025n

.meas tran vdout0_2ck1450 FIND v(dout0_2) AT=730.025n

.meas tran vdout0_3ck1450 FIND v(dout0_3) AT=730.025n

.meas tran vdout0_4ck1450 FIND v(dout0_4) AT=730.025n

.meas tran vdout0_5ck1450 FIND v(dout0_5) AT=730.025n

.meas tran vdout0_6ck1450 FIND v(dout0_6) AT=730.025n

.meas tran vdout0_7ck1450 FIND v(dout0_7) AT=730.025n

.meas tran vdout0_8ck1450 FIND v(dout0_8) AT=730.025n

.meas tran vdout0_9ck1450 FIND v(dout0_9) AT=730.025n

.meas tran vdout0_10ck1450 FIND v(dout0_10) AT=730.025n

.meas tran vdout0_11ck1450 FIND v(dout0_11) AT=730.025n

.meas tran vdout0_12ck1450 FIND v(dout0_12) AT=730.025n

.meas tran vdout0_13ck1450 FIND v(dout0_13) AT=730.025n

.meas tran vdout0_14ck1450 FIND v(dout0_14) AT=730.025n

.meas tran vdout0_15ck1450 FIND v(dout0_15) AT=730.025n

.meas tran vdout0_16ck1450 FIND v(dout0_16) AT=730.025n

.meas tran vdout0_17ck1450 FIND v(dout0_17) AT=730.025n

.meas tran vdout0_18ck1450 FIND v(dout0_18) AT=730.025n

.meas tran vdout0_19ck1450 FIND v(dout0_19) AT=730.025n

.meas tran vdout0_20ck1450 FIND v(dout0_20) AT=730.025n

.meas tran vdout0_21ck1450 FIND v(dout0_21) AT=730.025n

.meas tran vdout0_22ck1450 FIND v(dout0_22) AT=730.025n

.meas tran vdout0_23ck1450 FIND v(dout0_23) AT=730.025n

.meas tran vdout0_24ck1450 FIND v(dout0_24) AT=730.025n

.meas tran vdout0_25ck1450 FIND v(dout0_25) AT=730.025n

.meas tran vdout0_26ck1450 FIND v(dout0_26) AT=730.025n

.meas tran vdout0_27ck1450 FIND v(dout0_27) AT=730.025n

.meas tran vdout0_28ck1450 FIND v(dout0_28) AT=730.025n

.meas tran vdout0_29ck1450 FIND v(dout0_29) AT=730.025n

.meas tran vdout0_30ck1450 FIND v(dout0_30) AT=730.025n

.meas tran vdout0_31ck1450 FIND v(dout0_31) AT=730.025n

.meas tran vdout0_32ck1450 FIND v(dout0_32) AT=730.025n

.meas tran vdout0_33ck1450 FIND v(dout0_33) AT=730.025n

.meas tran vdout0_34ck1450 FIND v(dout0_34) AT=730.025n

.meas tran vdout0_35ck1450 FIND v(dout0_35) AT=730.025n

.meas tran vdout0_36ck1450 FIND v(dout0_36) AT=730.025n

.meas tran vdout0_37ck1450 FIND v(dout0_37) AT=730.025n

.meas tran vdout0_38ck1450 FIND v(dout0_38) AT=730.025n

.meas tran vdout0_39ck1450 FIND v(dout0_39) AT=730.025n

.meas tran vdout0_40ck1450 FIND v(dout0_40) AT=730.025n

.meas tran vdout0_41ck1450 FIND v(dout0_41) AT=730.025n

.meas tran vdout0_42ck1450 FIND v(dout0_42) AT=730.025n

.meas tran vdout0_43ck1450 FIND v(dout0_43) AT=730.025n

.meas tran vdout0_44ck1450 FIND v(dout0_44) AT=730.025n

.meas tran vdout0_45ck1450 FIND v(dout0_45) AT=730.025n

.meas tran vdout0_46ck1450 FIND v(dout0_46) AT=730.025n

.meas tran vdout0_47ck1450 FIND v(dout0_47) AT=730.025n

.meas tran vdout0_48ck1450 FIND v(dout0_48) AT=730.025n

.meas tran vdout0_49ck1450 FIND v(dout0_49) AT=730.025n

.meas tran vdout0_50ck1450 FIND v(dout0_50) AT=730.025n

.meas tran vdout0_51ck1450 FIND v(dout0_51) AT=730.025n

.meas tran vdout0_52ck1450 FIND v(dout0_52) AT=730.025n

.meas tran vdout0_53ck1450 FIND v(dout0_53) AT=730.025n

.meas tran vdout0_54ck1450 FIND v(dout0_54) AT=730.025n

.meas tran vdout0_55ck1450 FIND v(dout0_55) AT=730.025n

.meas tran vdout0_56ck1450 FIND v(dout0_56) AT=730.025n

.meas tran vdout0_57ck1450 FIND v(dout0_57) AT=730.025n

.meas tran vdout0_58ck1450 FIND v(dout0_58) AT=730.025n

.meas tran vdout0_59ck1450 FIND v(dout0_59) AT=730.025n

.meas tran vdout0_60ck1450 FIND v(dout0_60) AT=730.025n

.meas tran vdout0_61ck1450 FIND v(dout0_61) AT=730.025n

.meas tran vdout0_62ck1450 FIND v(dout0_62) AT=730.025n

.meas tran vdout0_63ck1450 FIND v(dout0_63) AT=730.025n

.meas tran vdout0_64ck1450 FIND v(dout0_64) AT=730.025n

.meas tran vdout0_65ck1450 FIND v(dout0_65) AT=730.025n

.meas tran vdout0_66ck1450 FIND v(dout0_66) AT=730.025n

.meas tran vdout0_67ck1450 FIND v(dout0_67) AT=730.025n

.meas tran vdout0_68ck1450 FIND v(dout0_68) AT=730.025n

.meas tran vdout0_69ck1450 FIND v(dout0_69) AT=730.025n

.meas tran vdout0_70ck1450 FIND v(dout0_70) AT=730.025n

.meas tran vdout0_71ck1450 FIND v(dout0_71) AT=730.025n

.meas tran vdout0_72ck1450 FIND v(dout0_72) AT=730.025n

.meas tran vdout0_73ck1450 FIND v(dout0_73) AT=730.025n

.meas tran vdout0_74ck1450 FIND v(dout0_74) AT=730.025n

.meas tran vdout0_75ck1450 FIND v(dout0_75) AT=730.025n

.meas tran vdout0_76ck1450 FIND v(dout0_76) AT=730.025n

.meas tran vdout0_77ck1450 FIND v(dout0_77) AT=730.025n

.meas tran vdout0_78ck1450 FIND v(dout0_78) AT=730.025n

.meas tran vdout0_79ck1450 FIND v(dout0_79) AT=730.025n

.meas tran vdout0_80ck1450 FIND v(dout0_80) AT=730.025n

.meas tran vdout0_81ck1450 FIND v(dout0_81) AT=730.025n

.meas tran vdout0_82ck1450 FIND v(dout0_82) AT=730.025n

.meas tran vdout0_83ck1450 FIND v(dout0_83) AT=730.025n

.meas tran vdout0_84ck1450 FIND v(dout0_84) AT=730.025n

.meas tran vdout0_85ck1450 FIND v(dout0_85) AT=730.025n

.meas tran vdout0_86ck1450 FIND v(dout0_86) AT=730.025n

.meas tran vdout0_87ck1450 FIND v(dout0_87) AT=730.025n

.meas tran vdout0_88ck1450 FIND v(dout0_88) AT=730.025n

.meas tran vdout0_89ck1450 FIND v(dout0_89) AT=730.025n

.meas tran vdout0_90ck1450 FIND v(dout0_90) AT=730.025n

.meas tran vdout0_91ck1450 FIND v(dout0_91) AT=730.025n

.meas tran vdout0_92ck1450 FIND v(dout0_92) AT=730.025n

.meas tran vdout0_93ck1450 FIND v(dout0_93) AT=730.025n

.meas tran vdout0_94ck1450 FIND v(dout0_94) AT=730.025n

.meas tran vdout0_95ck1450 FIND v(dout0_95) AT=730.025n

.meas tran vdout0_96ck1450 FIND v(dout0_96) AT=730.025n

.meas tran vdout0_97ck1450 FIND v(dout0_97) AT=730.025n

.meas tran vdout0_98ck1450 FIND v(dout0_98) AT=730.025n

.meas tran vdout0_99ck1450 FIND v(dout0_99) AT=730.025n

.meas tran vdout0_100ck1450 FIND v(dout0_100) AT=730.025n

.meas tran vdout0_101ck1450 FIND v(dout0_101) AT=730.025n

.meas tran vdout0_102ck1450 FIND v(dout0_102) AT=730.025n

.meas tran vdout0_103ck1450 FIND v(dout0_103) AT=730.025n

.meas tran vdout0_104ck1450 FIND v(dout0_104) AT=730.025n

.meas tran vdout0_105ck1450 FIND v(dout0_105) AT=730.025n

.meas tran vdout0_106ck1450 FIND v(dout0_106) AT=730.025n

.meas tran vdout0_107ck1450 FIND v(dout0_107) AT=730.025n

.meas tran vdout0_108ck1450 FIND v(dout0_108) AT=730.025n

.meas tran vdout0_109ck1450 FIND v(dout0_109) AT=730.025n

.meas tran vdout0_110ck1450 FIND v(dout0_110) AT=730.025n

.meas tran vdout0_111ck1450 FIND v(dout0_111) AT=730.025n

.meas tran vdout0_112ck1450 FIND v(dout0_112) AT=730.025n

.meas tran vdout0_113ck1450 FIND v(dout0_113) AT=730.025n

.meas tran vdout0_114ck1450 FIND v(dout0_114) AT=730.025n

.meas tran vdout0_115ck1450 FIND v(dout0_115) AT=730.025n

.meas tran vdout0_116ck1450 FIND v(dout0_116) AT=730.025n

.meas tran vdout0_117ck1450 FIND v(dout0_117) AT=730.025n

.meas tran vdout0_118ck1450 FIND v(dout0_118) AT=730.025n

.meas tran vdout0_119ck1450 FIND v(dout0_119) AT=730.025n

.meas tran vdout0_120ck1450 FIND v(dout0_120) AT=730.025n

.meas tran vdout0_121ck1450 FIND v(dout0_121) AT=730.025n

.meas tran vdout0_122ck1450 FIND v(dout0_122) AT=730.025n

.meas tran vdout0_123ck1450 FIND v(dout0_123) AT=730.025n

.meas tran vdout0_124ck1450 FIND v(dout0_124) AT=730.025n

.meas tran vdout0_125ck1450 FIND v(dout0_125) AT=730.025n

.meas tran vdout0_126ck1450 FIND v(dout0_126) AT=730.025n

.meas tran vdout0_127ck1450 FIND v(dout0_127) AT=730.025n

.meas tran vdout0_128ck1450 FIND v(dout0_128) AT=730.025n

.meas tran vdout0_129ck1450 FIND v(dout0_129) AT=730.025n

.meas tran vdout0_130ck1450 FIND v(dout0_130) AT=730.025n

.meas tran vdout0_131ck1450 FIND v(dout0_131) AT=730.025n

.meas tran vdout0_132ck1450 FIND v(dout0_132) AT=730.025n

.meas tran vdout0_133ck1450 FIND v(dout0_133) AT=730.025n

.meas tran vdout0_134ck1450 FIND v(dout0_134) AT=730.025n

.meas tran vdout0_135ck1450 FIND v(dout0_135) AT=730.025n

.meas tran vdout0_136ck1450 FIND v(dout0_136) AT=730.025n

.meas tran vdout0_137ck1450 FIND v(dout0_137) AT=730.025n

.meas tran vdout0_138ck1450 FIND v(dout0_138) AT=730.025n

.meas tran vdout0_139ck1450 FIND v(dout0_139) AT=730.025n

.meas tran vdout0_140ck1450 FIND v(dout0_140) AT=730.025n

.meas tran vdout0_141ck1450 FIND v(dout0_141) AT=730.025n

.meas tran vdout0_142ck1450 FIND v(dout0_142) AT=730.025n

.meas tran vdout0_143ck1450 FIND v(dout0_143) AT=730.025n

.meas tran vdout0_144ck1450 FIND v(dout0_144) AT=730.025n

.meas tran vdout0_145ck1450 FIND v(dout0_145) AT=730.025n

.meas tran vdout0_146ck1450 FIND v(dout0_146) AT=730.025n

.meas tran vdout0_147ck1450 FIND v(dout0_147) AT=730.025n

.meas tran vdout0_148ck1450 FIND v(dout0_148) AT=730.025n

.meas tran vdout0_149ck1450 FIND v(dout0_149) AT=730.025n

.meas tran vdout0_150ck1450 FIND v(dout0_150) AT=730.025n

.meas tran vdout0_151ck1450 FIND v(dout0_151) AT=730.025n

.meas tran vdout0_152ck1450 FIND v(dout0_152) AT=730.025n

.meas tran vdout0_153ck1450 FIND v(dout0_153) AT=730.025n

.meas tran vdout0_154ck1450 FIND v(dout0_154) AT=730.025n

.meas tran vdout0_155ck1450 FIND v(dout0_155) AT=730.025n

.meas tran vdout0_156ck1450 FIND v(dout0_156) AT=730.025n

.meas tran vdout0_157ck1450 FIND v(dout0_157) AT=730.025n

.meas tran vdout0_158ck1450 FIND v(dout0_158) AT=730.025n

.meas tran vdout0_159ck1450 FIND v(dout0_159) AT=730.025n

.meas tran vdout0_160ck1450 FIND v(dout0_160) AT=730.025n

.meas tran vdout0_161ck1450 FIND v(dout0_161) AT=730.025n

.meas tran vdout0_162ck1450 FIND v(dout0_162) AT=730.025n

.meas tran vdout0_163ck1450 FIND v(dout0_163) AT=730.025n

.meas tran vdout0_164ck1450 FIND v(dout0_164) AT=730.025n

.meas tran vdout0_165ck1450 FIND v(dout0_165) AT=730.025n

.meas tran vdout0_166ck1450 FIND v(dout0_166) AT=730.025n

.meas tran vdout0_167ck1450 FIND v(dout0_167) AT=730.025n

.meas tran vdout0_168ck1450 FIND v(dout0_168) AT=730.025n

.meas tran vdout0_169ck1450 FIND v(dout0_169) AT=730.025n

.meas tran vdout0_170ck1450 FIND v(dout0_170) AT=730.025n

.meas tran vdout0_171ck1450 FIND v(dout0_171) AT=730.025n

.meas tran vdout0_172ck1450 FIND v(dout0_172) AT=730.025n

.meas tran vdout0_173ck1450 FIND v(dout0_173) AT=730.025n

.meas tran vdout0_174ck1450 FIND v(dout0_174) AT=730.025n

.meas tran vdout0_175ck1450 FIND v(dout0_175) AT=730.025n

.meas tran vdout0_176ck1450 FIND v(dout0_176) AT=730.025n

.meas tran vdout0_177ck1450 FIND v(dout0_177) AT=730.025n

.meas tran vdout0_178ck1450 FIND v(dout0_178) AT=730.025n

.meas tran vdout0_179ck1450 FIND v(dout0_179) AT=730.025n

.meas tran vdout0_180ck1450 FIND v(dout0_180) AT=730.025n

.meas tran vdout0_181ck1450 FIND v(dout0_181) AT=730.025n

.meas tran vdout0_182ck1450 FIND v(dout0_182) AT=730.025n

.meas tran vdout0_183ck1450 FIND v(dout0_183) AT=730.025n

.meas tran vdout0_184ck1450 FIND v(dout0_184) AT=730.025n

.meas tran vdout0_185ck1450 FIND v(dout0_185) AT=730.025n

.meas tran vdout0_186ck1450 FIND v(dout0_186) AT=730.025n

.meas tran vdout0_187ck1450 FIND v(dout0_187) AT=730.025n

.meas tran vdout0_188ck1450 FIND v(dout0_188) AT=730.025n

.meas tran vdout0_189ck1450 FIND v(dout0_189) AT=730.025n

.meas tran vdout0_190ck1450 FIND v(dout0_190) AT=730.025n

.meas tran vdout0_191ck1450 FIND v(dout0_191) AT=730.025n

.meas tran vdout0_192ck1450 FIND v(dout0_192) AT=730.025n

.meas tran vdout0_193ck1450 FIND v(dout0_193) AT=730.025n

.meas tran vdout0_194ck1450 FIND v(dout0_194) AT=730.025n

.meas tran vdout0_195ck1450 FIND v(dout0_195) AT=730.025n

.meas tran vdout0_196ck1450 FIND v(dout0_196) AT=730.025n

.meas tran vdout0_197ck1450 FIND v(dout0_197) AT=730.025n

.meas tran vdout0_198ck1450 FIND v(dout0_198) AT=730.025n

.meas tran vdout0_199ck1450 FIND v(dout0_199) AT=730.025n

.meas tran vdout0_200ck1450 FIND v(dout0_200) AT=730.025n

.meas tran vdout0_201ck1450 FIND v(dout0_201) AT=730.025n

.meas tran vdout0_202ck1450 FIND v(dout0_202) AT=730.025n

.meas tran vdout0_203ck1450 FIND v(dout0_203) AT=730.025n

.meas tran vdout0_204ck1450 FIND v(dout0_204) AT=730.025n

.meas tran vdout0_205ck1450 FIND v(dout0_205) AT=730.025n

.meas tran vdout0_206ck1450 FIND v(dout0_206) AT=730.025n

.meas tran vdout0_207ck1450 FIND v(dout0_207) AT=730.025n

.meas tran vdout0_208ck1450 FIND v(dout0_208) AT=730.025n

.meas tran vdout0_209ck1450 FIND v(dout0_209) AT=730.025n

.meas tran vdout0_210ck1450 FIND v(dout0_210) AT=730.025n

.meas tran vdout0_211ck1450 FIND v(dout0_211) AT=730.025n

.meas tran vdout0_212ck1450 FIND v(dout0_212) AT=730.025n

.meas tran vdout0_213ck1450 FIND v(dout0_213) AT=730.025n

.meas tran vdout0_214ck1450 FIND v(dout0_214) AT=730.025n

.meas tran vdout0_215ck1450 FIND v(dout0_215) AT=730.025n

.meas tran vdout0_216ck1450 FIND v(dout0_216) AT=730.025n

.meas tran vdout0_217ck1450 FIND v(dout0_217) AT=730.025n

.meas tran vdout0_218ck1450 FIND v(dout0_218) AT=730.025n

.meas tran vdout0_219ck1450 FIND v(dout0_219) AT=730.025n

.meas tran vdout0_220ck1450 FIND v(dout0_220) AT=730.025n

.meas tran vdout0_221ck1450 FIND v(dout0_221) AT=730.025n

.meas tran vdout0_222ck1450 FIND v(dout0_222) AT=730.025n

.meas tran vdout0_223ck1450 FIND v(dout0_223) AT=730.025n

.meas tran vdout0_224ck1450 FIND v(dout0_224) AT=730.025n

.meas tran vdout0_225ck1450 FIND v(dout0_225) AT=730.025n

.meas tran vdout0_226ck1450 FIND v(dout0_226) AT=730.025n

.meas tran vdout0_227ck1450 FIND v(dout0_227) AT=730.025n

.meas tran vdout0_228ck1450 FIND v(dout0_228) AT=730.025n

.meas tran vdout0_229ck1450 FIND v(dout0_229) AT=730.025n

.meas tran vdout0_230ck1450 FIND v(dout0_230) AT=730.025n

.meas tran vdout0_231ck1450 FIND v(dout0_231) AT=730.025n

.meas tran vdout0_232ck1450 FIND v(dout0_232) AT=730.025n

.meas tran vdout0_233ck1450 FIND v(dout0_233) AT=730.025n

.meas tran vdout0_234ck1450 FIND v(dout0_234) AT=730.025n

.meas tran vdout0_235ck1450 FIND v(dout0_235) AT=730.025n

.meas tran vdout0_236ck1450 FIND v(dout0_236) AT=730.025n

.meas tran vdout0_237ck1450 FIND v(dout0_237) AT=730.025n

.meas tran vdout0_238ck1450 FIND v(dout0_238) AT=730.025n

.meas tran vdout0_239ck1450 FIND v(dout0_239) AT=730.025n

.meas tran vdout0_240ck1450 FIND v(dout0_240) AT=730.025n

.meas tran vdout0_241ck1450 FIND v(dout0_241) AT=730.025n

.meas tran vdout0_242ck1450 FIND v(dout0_242) AT=730.025n

.meas tran vdout0_243ck1450 FIND v(dout0_243) AT=730.025n

.meas tran vdout0_244ck1450 FIND v(dout0_244) AT=730.025n

.meas tran vdout0_245ck1450 FIND v(dout0_245) AT=730.025n

.meas tran vdout0_246ck1450 FIND v(dout0_246) AT=730.025n

.meas tran vdout0_247ck1450 FIND v(dout0_247) AT=730.025n

.meas tran vdout0_248ck1450 FIND v(dout0_248) AT=730.025n

.meas tran vdout0_249ck1450 FIND v(dout0_249) AT=730.025n

.meas tran vdout0_250ck1450 FIND v(dout0_250) AT=730.025n

.meas tran vdout0_251ck1450 FIND v(dout0_251) AT=730.025n

.meas tran vdout0_252ck1450 FIND v(dout0_252) AT=730.025n

.meas tran vdout0_253ck1450 FIND v(dout0_253) AT=730.025n

.meas tran vdout0_254ck1450 FIND v(dout0_254) AT=730.025n

.meas tran vdout0_255ck1450 FIND v(dout0_255) AT=730.025n

.meas tran vdout0_0ck1460 FIND v(dout0_0) AT=735.025n

.meas tran vdout0_1ck1460 FIND v(dout0_1) AT=735.025n

.meas tran vdout0_2ck1460 FIND v(dout0_2) AT=735.025n

.meas tran vdout0_3ck1460 FIND v(dout0_3) AT=735.025n

.meas tran vdout0_4ck1460 FIND v(dout0_4) AT=735.025n

.meas tran vdout0_5ck1460 FIND v(dout0_5) AT=735.025n

.meas tran vdout0_6ck1460 FIND v(dout0_6) AT=735.025n

.meas tran vdout0_7ck1460 FIND v(dout0_7) AT=735.025n

.meas tran vdout0_8ck1460 FIND v(dout0_8) AT=735.025n

.meas tran vdout0_9ck1460 FIND v(dout0_9) AT=735.025n

.meas tran vdout0_10ck1460 FIND v(dout0_10) AT=735.025n

.meas tran vdout0_11ck1460 FIND v(dout0_11) AT=735.025n

.meas tran vdout0_12ck1460 FIND v(dout0_12) AT=735.025n

.meas tran vdout0_13ck1460 FIND v(dout0_13) AT=735.025n

.meas tran vdout0_14ck1460 FIND v(dout0_14) AT=735.025n

.meas tran vdout0_15ck1460 FIND v(dout0_15) AT=735.025n

.meas tran vdout0_16ck1460 FIND v(dout0_16) AT=735.025n

.meas tran vdout0_17ck1460 FIND v(dout0_17) AT=735.025n

.meas tran vdout0_18ck1460 FIND v(dout0_18) AT=735.025n

.meas tran vdout0_19ck1460 FIND v(dout0_19) AT=735.025n

.meas tran vdout0_20ck1460 FIND v(dout0_20) AT=735.025n

.meas tran vdout0_21ck1460 FIND v(dout0_21) AT=735.025n

.meas tran vdout0_22ck1460 FIND v(dout0_22) AT=735.025n

.meas tran vdout0_23ck1460 FIND v(dout0_23) AT=735.025n

.meas tran vdout0_24ck1460 FIND v(dout0_24) AT=735.025n

.meas tran vdout0_25ck1460 FIND v(dout0_25) AT=735.025n

.meas tran vdout0_26ck1460 FIND v(dout0_26) AT=735.025n

.meas tran vdout0_27ck1460 FIND v(dout0_27) AT=735.025n

.meas tran vdout0_28ck1460 FIND v(dout0_28) AT=735.025n

.meas tran vdout0_29ck1460 FIND v(dout0_29) AT=735.025n

.meas tran vdout0_30ck1460 FIND v(dout0_30) AT=735.025n

.meas tran vdout0_31ck1460 FIND v(dout0_31) AT=735.025n

.meas tran vdout0_32ck1460 FIND v(dout0_32) AT=735.025n

.meas tran vdout0_33ck1460 FIND v(dout0_33) AT=735.025n

.meas tran vdout0_34ck1460 FIND v(dout0_34) AT=735.025n

.meas tran vdout0_35ck1460 FIND v(dout0_35) AT=735.025n

.meas tran vdout0_36ck1460 FIND v(dout0_36) AT=735.025n

.meas tran vdout0_37ck1460 FIND v(dout0_37) AT=735.025n

.meas tran vdout0_38ck1460 FIND v(dout0_38) AT=735.025n

.meas tran vdout0_39ck1460 FIND v(dout0_39) AT=735.025n

.meas tran vdout0_40ck1460 FIND v(dout0_40) AT=735.025n

.meas tran vdout0_41ck1460 FIND v(dout0_41) AT=735.025n

.meas tran vdout0_42ck1460 FIND v(dout0_42) AT=735.025n

.meas tran vdout0_43ck1460 FIND v(dout0_43) AT=735.025n

.meas tran vdout0_44ck1460 FIND v(dout0_44) AT=735.025n

.meas tran vdout0_45ck1460 FIND v(dout0_45) AT=735.025n

.meas tran vdout0_46ck1460 FIND v(dout0_46) AT=735.025n

.meas tran vdout0_47ck1460 FIND v(dout0_47) AT=735.025n

.meas tran vdout0_48ck1460 FIND v(dout0_48) AT=735.025n

.meas tran vdout0_49ck1460 FIND v(dout0_49) AT=735.025n

.meas tran vdout0_50ck1460 FIND v(dout0_50) AT=735.025n

.meas tran vdout0_51ck1460 FIND v(dout0_51) AT=735.025n

.meas tran vdout0_52ck1460 FIND v(dout0_52) AT=735.025n

.meas tran vdout0_53ck1460 FIND v(dout0_53) AT=735.025n

.meas tran vdout0_54ck1460 FIND v(dout0_54) AT=735.025n

.meas tran vdout0_55ck1460 FIND v(dout0_55) AT=735.025n

.meas tran vdout0_56ck1460 FIND v(dout0_56) AT=735.025n

.meas tran vdout0_57ck1460 FIND v(dout0_57) AT=735.025n

.meas tran vdout0_58ck1460 FIND v(dout0_58) AT=735.025n

.meas tran vdout0_59ck1460 FIND v(dout0_59) AT=735.025n

.meas tran vdout0_60ck1460 FIND v(dout0_60) AT=735.025n

.meas tran vdout0_61ck1460 FIND v(dout0_61) AT=735.025n

.meas tran vdout0_62ck1460 FIND v(dout0_62) AT=735.025n

.meas tran vdout0_63ck1460 FIND v(dout0_63) AT=735.025n

.meas tran vdout0_64ck1460 FIND v(dout0_64) AT=735.025n

.meas tran vdout0_65ck1460 FIND v(dout0_65) AT=735.025n

.meas tran vdout0_66ck1460 FIND v(dout0_66) AT=735.025n

.meas tran vdout0_67ck1460 FIND v(dout0_67) AT=735.025n

.meas tran vdout0_68ck1460 FIND v(dout0_68) AT=735.025n

.meas tran vdout0_69ck1460 FIND v(dout0_69) AT=735.025n

.meas tran vdout0_70ck1460 FIND v(dout0_70) AT=735.025n

.meas tran vdout0_71ck1460 FIND v(dout0_71) AT=735.025n

.meas tran vdout0_72ck1460 FIND v(dout0_72) AT=735.025n

.meas tran vdout0_73ck1460 FIND v(dout0_73) AT=735.025n

.meas tran vdout0_74ck1460 FIND v(dout0_74) AT=735.025n

.meas tran vdout0_75ck1460 FIND v(dout0_75) AT=735.025n

.meas tran vdout0_76ck1460 FIND v(dout0_76) AT=735.025n

.meas tran vdout0_77ck1460 FIND v(dout0_77) AT=735.025n

.meas tran vdout0_78ck1460 FIND v(dout0_78) AT=735.025n

.meas tran vdout0_79ck1460 FIND v(dout0_79) AT=735.025n

.meas tran vdout0_80ck1460 FIND v(dout0_80) AT=735.025n

.meas tran vdout0_81ck1460 FIND v(dout0_81) AT=735.025n

.meas tran vdout0_82ck1460 FIND v(dout0_82) AT=735.025n

.meas tran vdout0_83ck1460 FIND v(dout0_83) AT=735.025n

.meas tran vdout0_84ck1460 FIND v(dout0_84) AT=735.025n

.meas tran vdout0_85ck1460 FIND v(dout0_85) AT=735.025n

.meas tran vdout0_86ck1460 FIND v(dout0_86) AT=735.025n

.meas tran vdout0_87ck1460 FIND v(dout0_87) AT=735.025n

.meas tran vdout0_88ck1460 FIND v(dout0_88) AT=735.025n

.meas tran vdout0_89ck1460 FIND v(dout0_89) AT=735.025n

.meas tran vdout0_90ck1460 FIND v(dout0_90) AT=735.025n

.meas tran vdout0_91ck1460 FIND v(dout0_91) AT=735.025n

.meas tran vdout0_92ck1460 FIND v(dout0_92) AT=735.025n

.meas tran vdout0_93ck1460 FIND v(dout0_93) AT=735.025n

.meas tran vdout0_94ck1460 FIND v(dout0_94) AT=735.025n

.meas tran vdout0_95ck1460 FIND v(dout0_95) AT=735.025n

.meas tran vdout0_96ck1460 FIND v(dout0_96) AT=735.025n

.meas tran vdout0_97ck1460 FIND v(dout0_97) AT=735.025n

.meas tran vdout0_98ck1460 FIND v(dout0_98) AT=735.025n

.meas tran vdout0_99ck1460 FIND v(dout0_99) AT=735.025n

.meas tran vdout0_100ck1460 FIND v(dout0_100) AT=735.025n

.meas tran vdout0_101ck1460 FIND v(dout0_101) AT=735.025n

.meas tran vdout0_102ck1460 FIND v(dout0_102) AT=735.025n

.meas tran vdout0_103ck1460 FIND v(dout0_103) AT=735.025n

.meas tran vdout0_104ck1460 FIND v(dout0_104) AT=735.025n

.meas tran vdout0_105ck1460 FIND v(dout0_105) AT=735.025n

.meas tran vdout0_106ck1460 FIND v(dout0_106) AT=735.025n

.meas tran vdout0_107ck1460 FIND v(dout0_107) AT=735.025n

.meas tran vdout0_108ck1460 FIND v(dout0_108) AT=735.025n

.meas tran vdout0_109ck1460 FIND v(dout0_109) AT=735.025n

.meas tran vdout0_110ck1460 FIND v(dout0_110) AT=735.025n

.meas tran vdout0_111ck1460 FIND v(dout0_111) AT=735.025n

.meas tran vdout0_112ck1460 FIND v(dout0_112) AT=735.025n

.meas tran vdout0_113ck1460 FIND v(dout0_113) AT=735.025n

.meas tran vdout0_114ck1460 FIND v(dout0_114) AT=735.025n

.meas tran vdout0_115ck1460 FIND v(dout0_115) AT=735.025n

.meas tran vdout0_116ck1460 FIND v(dout0_116) AT=735.025n

.meas tran vdout0_117ck1460 FIND v(dout0_117) AT=735.025n

.meas tran vdout0_118ck1460 FIND v(dout0_118) AT=735.025n

.meas tran vdout0_119ck1460 FIND v(dout0_119) AT=735.025n

.meas tran vdout0_120ck1460 FIND v(dout0_120) AT=735.025n

.meas tran vdout0_121ck1460 FIND v(dout0_121) AT=735.025n

.meas tran vdout0_122ck1460 FIND v(dout0_122) AT=735.025n

.meas tran vdout0_123ck1460 FIND v(dout0_123) AT=735.025n

.meas tran vdout0_124ck1460 FIND v(dout0_124) AT=735.025n

.meas tran vdout0_125ck1460 FIND v(dout0_125) AT=735.025n

.meas tran vdout0_126ck1460 FIND v(dout0_126) AT=735.025n

.meas tran vdout0_127ck1460 FIND v(dout0_127) AT=735.025n

.meas tran vdout0_128ck1460 FIND v(dout0_128) AT=735.025n

.meas tran vdout0_129ck1460 FIND v(dout0_129) AT=735.025n

.meas tran vdout0_130ck1460 FIND v(dout0_130) AT=735.025n

.meas tran vdout0_131ck1460 FIND v(dout0_131) AT=735.025n

.meas tran vdout0_132ck1460 FIND v(dout0_132) AT=735.025n

.meas tran vdout0_133ck1460 FIND v(dout0_133) AT=735.025n

.meas tran vdout0_134ck1460 FIND v(dout0_134) AT=735.025n

.meas tran vdout0_135ck1460 FIND v(dout0_135) AT=735.025n

.meas tran vdout0_136ck1460 FIND v(dout0_136) AT=735.025n

.meas tran vdout0_137ck1460 FIND v(dout0_137) AT=735.025n

.meas tran vdout0_138ck1460 FIND v(dout0_138) AT=735.025n

.meas tran vdout0_139ck1460 FIND v(dout0_139) AT=735.025n

.meas tran vdout0_140ck1460 FIND v(dout0_140) AT=735.025n

.meas tran vdout0_141ck1460 FIND v(dout0_141) AT=735.025n

.meas tran vdout0_142ck1460 FIND v(dout0_142) AT=735.025n

.meas tran vdout0_143ck1460 FIND v(dout0_143) AT=735.025n

.meas tran vdout0_144ck1460 FIND v(dout0_144) AT=735.025n

.meas tran vdout0_145ck1460 FIND v(dout0_145) AT=735.025n

.meas tran vdout0_146ck1460 FIND v(dout0_146) AT=735.025n

.meas tran vdout0_147ck1460 FIND v(dout0_147) AT=735.025n

.meas tran vdout0_148ck1460 FIND v(dout0_148) AT=735.025n

.meas tran vdout0_149ck1460 FIND v(dout0_149) AT=735.025n

.meas tran vdout0_150ck1460 FIND v(dout0_150) AT=735.025n

.meas tran vdout0_151ck1460 FIND v(dout0_151) AT=735.025n

.meas tran vdout0_152ck1460 FIND v(dout0_152) AT=735.025n

.meas tran vdout0_153ck1460 FIND v(dout0_153) AT=735.025n

.meas tran vdout0_154ck1460 FIND v(dout0_154) AT=735.025n

.meas tran vdout0_155ck1460 FIND v(dout0_155) AT=735.025n

.meas tran vdout0_156ck1460 FIND v(dout0_156) AT=735.025n

.meas tran vdout0_157ck1460 FIND v(dout0_157) AT=735.025n

.meas tran vdout0_158ck1460 FIND v(dout0_158) AT=735.025n

.meas tran vdout0_159ck1460 FIND v(dout0_159) AT=735.025n

.meas tran vdout0_160ck1460 FIND v(dout0_160) AT=735.025n

.meas tran vdout0_161ck1460 FIND v(dout0_161) AT=735.025n

.meas tran vdout0_162ck1460 FIND v(dout0_162) AT=735.025n

.meas tran vdout0_163ck1460 FIND v(dout0_163) AT=735.025n

.meas tran vdout0_164ck1460 FIND v(dout0_164) AT=735.025n

.meas tran vdout0_165ck1460 FIND v(dout0_165) AT=735.025n

.meas tran vdout0_166ck1460 FIND v(dout0_166) AT=735.025n

.meas tran vdout0_167ck1460 FIND v(dout0_167) AT=735.025n

.meas tran vdout0_168ck1460 FIND v(dout0_168) AT=735.025n

.meas tran vdout0_169ck1460 FIND v(dout0_169) AT=735.025n

.meas tran vdout0_170ck1460 FIND v(dout0_170) AT=735.025n

.meas tran vdout0_171ck1460 FIND v(dout0_171) AT=735.025n

.meas tran vdout0_172ck1460 FIND v(dout0_172) AT=735.025n

.meas tran vdout0_173ck1460 FIND v(dout0_173) AT=735.025n

.meas tran vdout0_174ck1460 FIND v(dout0_174) AT=735.025n

.meas tran vdout0_175ck1460 FIND v(dout0_175) AT=735.025n

.meas tran vdout0_176ck1460 FIND v(dout0_176) AT=735.025n

.meas tran vdout0_177ck1460 FIND v(dout0_177) AT=735.025n

.meas tran vdout0_178ck1460 FIND v(dout0_178) AT=735.025n

.meas tran vdout0_179ck1460 FIND v(dout0_179) AT=735.025n

.meas tran vdout0_180ck1460 FIND v(dout0_180) AT=735.025n

.meas tran vdout0_181ck1460 FIND v(dout0_181) AT=735.025n

.meas tran vdout0_182ck1460 FIND v(dout0_182) AT=735.025n

.meas tran vdout0_183ck1460 FIND v(dout0_183) AT=735.025n

.meas tran vdout0_184ck1460 FIND v(dout0_184) AT=735.025n

.meas tran vdout0_185ck1460 FIND v(dout0_185) AT=735.025n

.meas tran vdout0_186ck1460 FIND v(dout0_186) AT=735.025n

.meas tran vdout0_187ck1460 FIND v(dout0_187) AT=735.025n

.meas tran vdout0_188ck1460 FIND v(dout0_188) AT=735.025n

.meas tran vdout0_189ck1460 FIND v(dout0_189) AT=735.025n

.meas tran vdout0_190ck1460 FIND v(dout0_190) AT=735.025n

.meas tran vdout0_191ck1460 FIND v(dout0_191) AT=735.025n

.meas tran vdout0_192ck1460 FIND v(dout0_192) AT=735.025n

.meas tran vdout0_193ck1460 FIND v(dout0_193) AT=735.025n

.meas tran vdout0_194ck1460 FIND v(dout0_194) AT=735.025n

.meas tran vdout0_195ck1460 FIND v(dout0_195) AT=735.025n

.meas tran vdout0_196ck1460 FIND v(dout0_196) AT=735.025n

.meas tran vdout0_197ck1460 FIND v(dout0_197) AT=735.025n

.meas tran vdout0_198ck1460 FIND v(dout0_198) AT=735.025n

.meas tran vdout0_199ck1460 FIND v(dout0_199) AT=735.025n

.meas tran vdout0_200ck1460 FIND v(dout0_200) AT=735.025n

.meas tran vdout0_201ck1460 FIND v(dout0_201) AT=735.025n

.meas tran vdout0_202ck1460 FIND v(dout0_202) AT=735.025n

.meas tran vdout0_203ck1460 FIND v(dout0_203) AT=735.025n

.meas tran vdout0_204ck1460 FIND v(dout0_204) AT=735.025n

.meas tran vdout0_205ck1460 FIND v(dout0_205) AT=735.025n

.meas tran vdout0_206ck1460 FIND v(dout0_206) AT=735.025n

.meas tran vdout0_207ck1460 FIND v(dout0_207) AT=735.025n

.meas tran vdout0_208ck1460 FIND v(dout0_208) AT=735.025n

.meas tran vdout0_209ck1460 FIND v(dout0_209) AT=735.025n

.meas tran vdout0_210ck1460 FIND v(dout0_210) AT=735.025n

.meas tran vdout0_211ck1460 FIND v(dout0_211) AT=735.025n

.meas tran vdout0_212ck1460 FIND v(dout0_212) AT=735.025n

.meas tran vdout0_213ck1460 FIND v(dout0_213) AT=735.025n

.meas tran vdout0_214ck1460 FIND v(dout0_214) AT=735.025n

.meas tran vdout0_215ck1460 FIND v(dout0_215) AT=735.025n

.meas tran vdout0_216ck1460 FIND v(dout0_216) AT=735.025n

.meas tran vdout0_217ck1460 FIND v(dout0_217) AT=735.025n

.meas tran vdout0_218ck1460 FIND v(dout0_218) AT=735.025n

.meas tran vdout0_219ck1460 FIND v(dout0_219) AT=735.025n

.meas tran vdout0_220ck1460 FIND v(dout0_220) AT=735.025n

.meas tran vdout0_221ck1460 FIND v(dout0_221) AT=735.025n

.meas tran vdout0_222ck1460 FIND v(dout0_222) AT=735.025n

.meas tran vdout0_223ck1460 FIND v(dout0_223) AT=735.025n

.meas tran vdout0_224ck1460 FIND v(dout0_224) AT=735.025n

.meas tran vdout0_225ck1460 FIND v(dout0_225) AT=735.025n

.meas tran vdout0_226ck1460 FIND v(dout0_226) AT=735.025n

.meas tran vdout0_227ck1460 FIND v(dout0_227) AT=735.025n

.meas tran vdout0_228ck1460 FIND v(dout0_228) AT=735.025n

.meas tran vdout0_229ck1460 FIND v(dout0_229) AT=735.025n

.meas tran vdout0_230ck1460 FIND v(dout0_230) AT=735.025n

.meas tran vdout0_231ck1460 FIND v(dout0_231) AT=735.025n

.meas tran vdout0_232ck1460 FIND v(dout0_232) AT=735.025n

.meas tran vdout0_233ck1460 FIND v(dout0_233) AT=735.025n

.meas tran vdout0_234ck1460 FIND v(dout0_234) AT=735.025n

.meas tran vdout0_235ck1460 FIND v(dout0_235) AT=735.025n

.meas tran vdout0_236ck1460 FIND v(dout0_236) AT=735.025n

.meas tran vdout0_237ck1460 FIND v(dout0_237) AT=735.025n

.meas tran vdout0_238ck1460 FIND v(dout0_238) AT=735.025n

.meas tran vdout0_239ck1460 FIND v(dout0_239) AT=735.025n

.meas tran vdout0_240ck1460 FIND v(dout0_240) AT=735.025n

.meas tran vdout0_241ck1460 FIND v(dout0_241) AT=735.025n

.meas tran vdout0_242ck1460 FIND v(dout0_242) AT=735.025n

.meas tran vdout0_243ck1460 FIND v(dout0_243) AT=735.025n

.meas tran vdout0_244ck1460 FIND v(dout0_244) AT=735.025n

.meas tran vdout0_245ck1460 FIND v(dout0_245) AT=735.025n

.meas tran vdout0_246ck1460 FIND v(dout0_246) AT=735.025n

.meas tran vdout0_247ck1460 FIND v(dout0_247) AT=735.025n

.meas tran vdout0_248ck1460 FIND v(dout0_248) AT=735.025n

.meas tran vdout0_249ck1460 FIND v(dout0_249) AT=735.025n

.meas tran vdout0_250ck1460 FIND v(dout0_250) AT=735.025n

.meas tran vdout0_251ck1460 FIND v(dout0_251) AT=735.025n

.meas tran vdout0_252ck1460 FIND v(dout0_252) AT=735.025n

.meas tran vdout0_253ck1460 FIND v(dout0_253) AT=735.025n

.meas tran vdout0_254ck1460 FIND v(dout0_254) AT=735.025n

.meas tran vdout0_255ck1460 FIND v(dout0_255) AT=735.025n

.meas tran vdout0_0ck1470 FIND v(dout0_0) AT=740.025n

.meas tran vdout0_1ck1470 FIND v(dout0_1) AT=740.025n

.meas tran vdout0_2ck1470 FIND v(dout0_2) AT=740.025n

.meas tran vdout0_3ck1470 FIND v(dout0_3) AT=740.025n

.meas tran vdout0_4ck1470 FIND v(dout0_4) AT=740.025n

.meas tran vdout0_5ck1470 FIND v(dout0_5) AT=740.025n

.meas tran vdout0_6ck1470 FIND v(dout0_6) AT=740.025n

.meas tran vdout0_7ck1470 FIND v(dout0_7) AT=740.025n

.meas tran vdout0_8ck1470 FIND v(dout0_8) AT=740.025n

.meas tran vdout0_9ck1470 FIND v(dout0_9) AT=740.025n

.meas tran vdout0_10ck1470 FIND v(dout0_10) AT=740.025n

.meas tran vdout0_11ck1470 FIND v(dout0_11) AT=740.025n

.meas tran vdout0_12ck1470 FIND v(dout0_12) AT=740.025n

.meas tran vdout0_13ck1470 FIND v(dout0_13) AT=740.025n

.meas tran vdout0_14ck1470 FIND v(dout0_14) AT=740.025n

.meas tran vdout0_15ck1470 FIND v(dout0_15) AT=740.025n

.meas tran vdout0_16ck1470 FIND v(dout0_16) AT=740.025n

.meas tran vdout0_17ck1470 FIND v(dout0_17) AT=740.025n

.meas tran vdout0_18ck1470 FIND v(dout0_18) AT=740.025n

.meas tran vdout0_19ck1470 FIND v(dout0_19) AT=740.025n

.meas tran vdout0_20ck1470 FIND v(dout0_20) AT=740.025n

.meas tran vdout0_21ck1470 FIND v(dout0_21) AT=740.025n

.meas tran vdout0_22ck1470 FIND v(dout0_22) AT=740.025n

.meas tran vdout0_23ck1470 FIND v(dout0_23) AT=740.025n

.meas tran vdout0_24ck1470 FIND v(dout0_24) AT=740.025n

.meas tran vdout0_25ck1470 FIND v(dout0_25) AT=740.025n

.meas tran vdout0_26ck1470 FIND v(dout0_26) AT=740.025n

.meas tran vdout0_27ck1470 FIND v(dout0_27) AT=740.025n

.meas tran vdout0_28ck1470 FIND v(dout0_28) AT=740.025n

.meas tran vdout0_29ck1470 FIND v(dout0_29) AT=740.025n

.meas tran vdout0_30ck1470 FIND v(dout0_30) AT=740.025n

.meas tran vdout0_31ck1470 FIND v(dout0_31) AT=740.025n

.meas tran vdout0_32ck1470 FIND v(dout0_32) AT=740.025n

.meas tran vdout0_33ck1470 FIND v(dout0_33) AT=740.025n

.meas tran vdout0_34ck1470 FIND v(dout0_34) AT=740.025n

.meas tran vdout0_35ck1470 FIND v(dout0_35) AT=740.025n

.meas tran vdout0_36ck1470 FIND v(dout0_36) AT=740.025n

.meas tran vdout0_37ck1470 FIND v(dout0_37) AT=740.025n

.meas tran vdout0_38ck1470 FIND v(dout0_38) AT=740.025n

.meas tran vdout0_39ck1470 FIND v(dout0_39) AT=740.025n

.meas tran vdout0_40ck1470 FIND v(dout0_40) AT=740.025n

.meas tran vdout0_41ck1470 FIND v(dout0_41) AT=740.025n

.meas tran vdout0_42ck1470 FIND v(dout0_42) AT=740.025n

.meas tran vdout0_43ck1470 FIND v(dout0_43) AT=740.025n

.meas tran vdout0_44ck1470 FIND v(dout0_44) AT=740.025n

.meas tran vdout0_45ck1470 FIND v(dout0_45) AT=740.025n

.meas tran vdout0_46ck1470 FIND v(dout0_46) AT=740.025n

.meas tran vdout0_47ck1470 FIND v(dout0_47) AT=740.025n

.meas tran vdout0_48ck1470 FIND v(dout0_48) AT=740.025n

.meas tran vdout0_49ck1470 FIND v(dout0_49) AT=740.025n

.meas tran vdout0_50ck1470 FIND v(dout0_50) AT=740.025n

.meas tran vdout0_51ck1470 FIND v(dout0_51) AT=740.025n

.meas tran vdout0_52ck1470 FIND v(dout0_52) AT=740.025n

.meas tran vdout0_53ck1470 FIND v(dout0_53) AT=740.025n

.meas tran vdout0_54ck1470 FIND v(dout0_54) AT=740.025n

.meas tran vdout0_55ck1470 FIND v(dout0_55) AT=740.025n

.meas tran vdout0_56ck1470 FIND v(dout0_56) AT=740.025n

.meas tran vdout0_57ck1470 FIND v(dout0_57) AT=740.025n

.meas tran vdout0_58ck1470 FIND v(dout0_58) AT=740.025n

.meas tran vdout0_59ck1470 FIND v(dout0_59) AT=740.025n

.meas tran vdout0_60ck1470 FIND v(dout0_60) AT=740.025n

.meas tran vdout0_61ck1470 FIND v(dout0_61) AT=740.025n

.meas tran vdout0_62ck1470 FIND v(dout0_62) AT=740.025n

.meas tran vdout0_63ck1470 FIND v(dout0_63) AT=740.025n

.meas tran vdout0_64ck1470 FIND v(dout0_64) AT=740.025n

.meas tran vdout0_65ck1470 FIND v(dout0_65) AT=740.025n

.meas tran vdout0_66ck1470 FIND v(dout0_66) AT=740.025n

.meas tran vdout0_67ck1470 FIND v(dout0_67) AT=740.025n

.meas tran vdout0_68ck1470 FIND v(dout0_68) AT=740.025n

.meas tran vdout0_69ck1470 FIND v(dout0_69) AT=740.025n

.meas tran vdout0_70ck1470 FIND v(dout0_70) AT=740.025n

.meas tran vdout0_71ck1470 FIND v(dout0_71) AT=740.025n

.meas tran vdout0_72ck1470 FIND v(dout0_72) AT=740.025n

.meas tran vdout0_73ck1470 FIND v(dout0_73) AT=740.025n

.meas tran vdout0_74ck1470 FIND v(dout0_74) AT=740.025n

.meas tran vdout0_75ck1470 FIND v(dout0_75) AT=740.025n

.meas tran vdout0_76ck1470 FIND v(dout0_76) AT=740.025n

.meas tran vdout0_77ck1470 FIND v(dout0_77) AT=740.025n

.meas tran vdout0_78ck1470 FIND v(dout0_78) AT=740.025n

.meas tran vdout0_79ck1470 FIND v(dout0_79) AT=740.025n

.meas tran vdout0_80ck1470 FIND v(dout0_80) AT=740.025n

.meas tran vdout0_81ck1470 FIND v(dout0_81) AT=740.025n

.meas tran vdout0_82ck1470 FIND v(dout0_82) AT=740.025n

.meas tran vdout0_83ck1470 FIND v(dout0_83) AT=740.025n

.meas tran vdout0_84ck1470 FIND v(dout0_84) AT=740.025n

.meas tran vdout0_85ck1470 FIND v(dout0_85) AT=740.025n

.meas tran vdout0_86ck1470 FIND v(dout0_86) AT=740.025n

.meas tran vdout0_87ck1470 FIND v(dout0_87) AT=740.025n

.meas tran vdout0_88ck1470 FIND v(dout0_88) AT=740.025n

.meas tran vdout0_89ck1470 FIND v(dout0_89) AT=740.025n

.meas tran vdout0_90ck1470 FIND v(dout0_90) AT=740.025n

.meas tran vdout0_91ck1470 FIND v(dout0_91) AT=740.025n

.meas tran vdout0_92ck1470 FIND v(dout0_92) AT=740.025n

.meas tran vdout0_93ck1470 FIND v(dout0_93) AT=740.025n

.meas tran vdout0_94ck1470 FIND v(dout0_94) AT=740.025n

.meas tran vdout0_95ck1470 FIND v(dout0_95) AT=740.025n

.meas tran vdout0_96ck1470 FIND v(dout0_96) AT=740.025n

.meas tran vdout0_97ck1470 FIND v(dout0_97) AT=740.025n

.meas tran vdout0_98ck1470 FIND v(dout0_98) AT=740.025n

.meas tran vdout0_99ck1470 FIND v(dout0_99) AT=740.025n

.meas tran vdout0_100ck1470 FIND v(dout0_100) AT=740.025n

.meas tran vdout0_101ck1470 FIND v(dout0_101) AT=740.025n

.meas tran vdout0_102ck1470 FIND v(dout0_102) AT=740.025n

.meas tran vdout0_103ck1470 FIND v(dout0_103) AT=740.025n

.meas tran vdout0_104ck1470 FIND v(dout0_104) AT=740.025n

.meas tran vdout0_105ck1470 FIND v(dout0_105) AT=740.025n

.meas tran vdout0_106ck1470 FIND v(dout0_106) AT=740.025n

.meas tran vdout0_107ck1470 FIND v(dout0_107) AT=740.025n

.meas tran vdout0_108ck1470 FIND v(dout0_108) AT=740.025n

.meas tran vdout0_109ck1470 FIND v(dout0_109) AT=740.025n

.meas tran vdout0_110ck1470 FIND v(dout0_110) AT=740.025n

.meas tran vdout0_111ck1470 FIND v(dout0_111) AT=740.025n

.meas tran vdout0_112ck1470 FIND v(dout0_112) AT=740.025n

.meas tran vdout0_113ck1470 FIND v(dout0_113) AT=740.025n

.meas tran vdout0_114ck1470 FIND v(dout0_114) AT=740.025n

.meas tran vdout0_115ck1470 FIND v(dout0_115) AT=740.025n

.meas tran vdout0_116ck1470 FIND v(dout0_116) AT=740.025n

.meas tran vdout0_117ck1470 FIND v(dout0_117) AT=740.025n

.meas tran vdout0_118ck1470 FIND v(dout0_118) AT=740.025n

.meas tran vdout0_119ck1470 FIND v(dout0_119) AT=740.025n

.meas tran vdout0_120ck1470 FIND v(dout0_120) AT=740.025n

.meas tran vdout0_121ck1470 FIND v(dout0_121) AT=740.025n

.meas tran vdout0_122ck1470 FIND v(dout0_122) AT=740.025n

.meas tran vdout0_123ck1470 FIND v(dout0_123) AT=740.025n

.meas tran vdout0_124ck1470 FIND v(dout0_124) AT=740.025n

.meas tran vdout0_125ck1470 FIND v(dout0_125) AT=740.025n

.meas tran vdout0_126ck1470 FIND v(dout0_126) AT=740.025n

.meas tran vdout0_127ck1470 FIND v(dout0_127) AT=740.025n

.meas tran vdout0_128ck1470 FIND v(dout0_128) AT=740.025n

.meas tran vdout0_129ck1470 FIND v(dout0_129) AT=740.025n

.meas tran vdout0_130ck1470 FIND v(dout0_130) AT=740.025n

.meas tran vdout0_131ck1470 FIND v(dout0_131) AT=740.025n

.meas tran vdout0_132ck1470 FIND v(dout0_132) AT=740.025n

.meas tran vdout0_133ck1470 FIND v(dout0_133) AT=740.025n

.meas tran vdout0_134ck1470 FIND v(dout0_134) AT=740.025n

.meas tran vdout0_135ck1470 FIND v(dout0_135) AT=740.025n

.meas tran vdout0_136ck1470 FIND v(dout0_136) AT=740.025n

.meas tran vdout0_137ck1470 FIND v(dout0_137) AT=740.025n

.meas tran vdout0_138ck1470 FIND v(dout0_138) AT=740.025n

.meas tran vdout0_139ck1470 FIND v(dout0_139) AT=740.025n

.meas tran vdout0_140ck1470 FIND v(dout0_140) AT=740.025n

.meas tran vdout0_141ck1470 FIND v(dout0_141) AT=740.025n

.meas tran vdout0_142ck1470 FIND v(dout0_142) AT=740.025n

.meas tran vdout0_143ck1470 FIND v(dout0_143) AT=740.025n

.meas tran vdout0_144ck1470 FIND v(dout0_144) AT=740.025n

.meas tran vdout0_145ck1470 FIND v(dout0_145) AT=740.025n

.meas tran vdout0_146ck1470 FIND v(dout0_146) AT=740.025n

.meas tran vdout0_147ck1470 FIND v(dout0_147) AT=740.025n

.meas tran vdout0_148ck1470 FIND v(dout0_148) AT=740.025n

.meas tran vdout0_149ck1470 FIND v(dout0_149) AT=740.025n

.meas tran vdout0_150ck1470 FIND v(dout0_150) AT=740.025n

.meas tran vdout0_151ck1470 FIND v(dout0_151) AT=740.025n

.meas tran vdout0_152ck1470 FIND v(dout0_152) AT=740.025n

.meas tran vdout0_153ck1470 FIND v(dout0_153) AT=740.025n

.meas tran vdout0_154ck1470 FIND v(dout0_154) AT=740.025n

.meas tran vdout0_155ck1470 FIND v(dout0_155) AT=740.025n

.meas tran vdout0_156ck1470 FIND v(dout0_156) AT=740.025n

.meas tran vdout0_157ck1470 FIND v(dout0_157) AT=740.025n

.meas tran vdout0_158ck1470 FIND v(dout0_158) AT=740.025n

.meas tran vdout0_159ck1470 FIND v(dout0_159) AT=740.025n

.meas tran vdout0_160ck1470 FIND v(dout0_160) AT=740.025n

.meas tran vdout0_161ck1470 FIND v(dout0_161) AT=740.025n

.meas tran vdout0_162ck1470 FIND v(dout0_162) AT=740.025n

.meas tran vdout0_163ck1470 FIND v(dout0_163) AT=740.025n

.meas tran vdout0_164ck1470 FIND v(dout0_164) AT=740.025n

.meas tran vdout0_165ck1470 FIND v(dout0_165) AT=740.025n

.meas tran vdout0_166ck1470 FIND v(dout0_166) AT=740.025n

.meas tran vdout0_167ck1470 FIND v(dout0_167) AT=740.025n

.meas tran vdout0_168ck1470 FIND v(dout0_168) AT=740.025n

.meas tran vdout0_169ck1470 FIND v(dout0_169) AT=740.025n

.meas tran vdout0_170ck1470 FIND v(dout0_170) AT=740.025n

.meas tran vdout0_171ck1470 FIND v(dout0_171) AT=740.025n

.meas tran vdout0_172ck1470 FIND v(dout0_172) AT=740.025n

.meas tran vdout0_173ck1470 FIND v(dout0_173) AT=740.025n

.meas tran vdout0_174ck1470 FIND v(dout0_174) AT=740.025n

.meas tran vdout0_175ck1470 FIND v(dout0_175) AT=740.025n

.meas tran vdout0_176ck1470 FIND v(dout0_176) AT=740.025n

.meas tran vdout0_177ck1470 FIND v(dout0_177) AT=740.025n

.meas tran vdout0_178ck1470 FIND v(dout0_178) AT=740.025n

.meas tran vdout0_179ck1470 FIND v(dout0_179) AT=740.025n

.meas tran vdout0_180ck1470 FIND v(dout0_180) AT=740.025n

.meas tran vdout0_181ck1470 FIND v(dout0_181) AT=740.025n

.meas tran vdout0_182ck1470 FIND v(dout0_182) AT=740.025n

.meas tran vdout0_183ck1470 FIND v(dout0_183) AT=740.025n

.meas tran vdout0_184ck1470 FIND v(dout0_184) AT=740.025n

.meas tran vdout0_185ck1470 FIND v(dout0_185) AT=740.025n

.meas tran vdout0_186ck1470 FIND v(dout0_186) AT=740.025n

.meas tran vdout0_187ck1470 FIND v(dout0_187) AT=740.025n

.meas tran vdout0_188ck1470 FIND v(dout0_188) AT=740.025n

.meas tran vdout0_189ck1470 FIND v(dout0_189) AT=740.025n

.meas tran vdout0_190ck1470 FIND v(dout0_190) AT=740.025n

.meas tran vdout0_191ck1470 FIND v(dout0_191) AT=740.025n

.meas tran vdout0_192ck1470 FIND v(dout0_192) AT=740.025n

.meas tran vdout0_193ck1470 FIND v(dout0_193) AT=740.025n

.meas tran vdout0_194ck1470 FIND v(dout0_194) AT=740.025n

.meas tran vdout0_195ck1470 FIND v(dout0_195) AT=740.025n

.meas tran vdout0_196ck1470 FIND v(dout0_196) AT=740.025n

.meas tran vdout0_197ck1470 FIND v(dout0_197) AT=740.025n

.meas tran vdout0_198ck1470 FIND v(dout0_198) AT=740.025n

.meas tran vdout0_199ck1470 FIND v(dout0_199) AT=740.025n

.meas tran vdout0_200ck1470 FIND v(dout0_200) AT=740.025n

.meas tran vdout0_201ck1470 FIND v(dout0_201) AT=740.025n

.meas tran vdout0_202ck1470 FIND v(dout0_202) AT=740.025n

.meas tran vdout0_203ck1470 FIND v(dout0_203) AT=740.025n

.meas tran vdout0_204ck1470 FIND v(dout0_204) AT=740.025n

.meas tran vdout0_205ck1470 FIND v(dout0_205) AT=740.025n

.meas tran vdout0_206ck1470 FIND v(dout0_206) AT=740.025n

.meas tran vdout0_207ck1470 FIND v(dout0_207) AT=740.025n

.meas tran vdout0_208ck1470 FIND v(dout0_208) AT=740.025n

.meas tran vdout0_209ck1470 FIND v(dout0_209) AT=740.025n

.meas tran vdout0_210ck1470 FIND v(dout0_210) AT=740.025n

.meas tran vdout0_211ck1470 FIND v(dout0_211) AT=740.025n

.meas tran vdout0_212ck1470 FIND v(dout0_212) AT=740.025n

.meas tran vdout0_213ck1470 FIND v(dout0_213) AT=740.025n

.meas tran vdout0_214ck1470 FIND v(dout0_214) AT=740.025n

.meas tran vdout0_215ck1470 FIND v(dout0_215) AT=740.025n

.meas tran vdout0_216ck1470 FIND v(dout0_216) AT=740.025n

.meas tran vdout0_217ck1470 FIND v(dout0_217) AT=740.025n

.meas tran vdout0_218ck1470 FIND v(dout0_218) AT=740.025n

.meas tran vdout0_219ck1470 FIND v(dout0_219) AT=740.025n

.meas tran vdout0_220ck1470 FIND v(dout0_220) AT=740.025n

.meas tran vdout0_221ck1470 FIND v(dout0_221) AT=740.025n

.meas tran vdout0_222ck1470 FIND v(dout0_222) AT=740.025n

.meas tran vdout0_223ck1470 FIND v(dout0_223) AT=740.025n

.meas tran vdout0_224ck1470 FIND v(dout0_224) AT=740.025n

.meas tran vdout0_225ck1470 FIND v(dout0_225) AT=740.025n

.meas tran vdout0_226ck1470 FIND v(dout0_226) AT=740.025n

.meas tran vdout0_227ck1470 FIND v(dout0_227) AT=740.025n

.meas tran vdout0_228ck1470 FIND v(dout0_228) AT=740.025n

.meas tran vdout0_229ck1470 FIND v(dout0_229) AT=740.025n

.meas tran vdout0_230ck1470 FIND v(dout0_230) AT=740.025n

.meas tran vdout0_231ck1470 FIND v(dout0_231) AT=740.025n

.meas tran vdout0_232ck1470 FIND v(dout0_232) AT=740.025n

.meas tran vdout0_233ck1470 FIND v(dout0_233) AT=740.025n

.meas tran vdout0_234ck1470 FIND v(dout0_234) AT=740.025n

.meas tran vdout0_235ck1470 FIND v(dout0_235) AT=740.025n

.meas tran vdout0_236ck1470 FIND v(dout0_236) AT=740.025n

.meas tran vdout0_237ck1470 FIND v(dout0_237) AT=740.025n

.meas tran vdout0_238ck1470 FIND v(dout0_238) AT=740.025n

.meas tran vdout0_239ck1470 FIND v(dout0_239) AT=740.025n

.meas tran vdout0_240ck1470 FIND v(dout0_240) AT=740.025n

.meas tran vdout0_241ck1470 FIND v(dout0_241) AT=740.025n

.meas tran vdout0_242ck1470 FIND v(dout0_242) AT=740.025n

.meas tran vdout0_243ck1470 FIND v(dout0_243) AT=740.025n

.meas tran vdout0_244ck1470 FIND v(dout0_244) AT=740.025n

.meas tran vdout0_245ck1470 FIND v(dout0_245) AT=740.025n

.meas tran vdout0_246ck1470 FIND v(dout0_246) AT=740.025n

.meas tran vdout0_247ck1470 FIND v(dout0_247) AT=740.025n

.meas tran vdout0_248ck1470 FIND v(dout0_248) AT=740.025n

.meas tran vdout0_249ck1470 FIND v(dout0_249) AT=740.025n

.meas tran vdout0_250ck1470 FIND v(dout0_250) AT=740.025n

.meas tran vdout0_251ck1470 FIND v(dout0_251) AT=740.025n

.meas tran vdout0_252ck1470 FIND v(dout0_252) AT=740.025n

.meas tran vdout0_253ck1470 FIND v(dout0_253) AT=740.025n

.meas tran vdout0_254ck1470 FIND v(dout0_254) AT=740.025n

.meas tran vdout0_255ck1470 FIND v(dout0_255) AT=740.025n

.meas tran vdout0_0ck1480 FIND v(dout0_0) AT=745.025n

.meas tran vdout0_1ck1480 FIND v(dout0_1) AT=745.025n

.meas tran vdout0_2ck1480 FIND v(dout0_2) AT=745.025n

.meas tran vdout0_3ck1480 FIND v(dout0_3) AT=745.025n

.meas tran vdout0_4ck1480 FIND v(dout0_4) AT=745.025n

.meas tran vdout0_5ck1480 FIND v(dout0_5) AT=745.025n

.meas tran vdout0_6ck1480 FIND v(dout0_6) AT=745.025n

.meas tran vdout0_7ck1480 FIND v(dout0_7) AT=745.025n

.meas tran vdout0_8ck1480 FIND v(dout0_8) AT=745.025n

.meas tran vdout0_9ck1480 FIND v(dout0_9) AT=745.025n

.meas tran vdout0_10ck1480 FIND v(dout0_10) AT=745.025n

.meas tran vdout0_11ck1480 FIND v(dout0_11) AT=745.025n

.meas tran vdout0_12ck1480 FIND v(dout0_12) AT=745.025n

.meas tran vdout0_13ck1480 FIND v(dout0_13) AT=745.025n

.meas tran vdout0_14ck1480 FIND v(dout0_14) AT=745.025n

.meas tran vdout0_15ck1480 FIND v(dout0_15) AT=745.025n

.meas tran vdout0_16ck1480 FIND v(dout0_16) AT=745.025n

.meas tran vdout0_17ck1480 FIND v(dout0_17) AT=745.025n

.meas tran vdout0_18ck1480 FIND v(dout0_18) AT=745.025n

.meas tran vdout0_19ck1480 FIND v(dout0_19) AT=745.025n

.meas tran vdout0_20ck1480 FIND v(dout0_20) AT=745.025n

.meas tran vdout0_21ck1480 FIND v(dout0_21) AT=745.025n

.meas tran vdout0_22ck1480 FIND v(dout0_22) AT=745.025n

.meas tran vdout0_23ck1480 FIND v(dout0_23) AT=745.025n

.meas tran vdout0_24ck1480 FIND v(dout0_24) AT=745.025n

.meas tran vdout0_25ck1480 FIND v(dout0_25) AT=745.025n

.meas tran vdout0_26ck1480 FIND v(dout0_26) AT=745.025n

.meas tran vdout0_27ck1480 FIND v(dout0_27) AT=745.025n

.meas tran vdout0_28ck1480 FIND v(dout0_28) AT=745.025n

.meas tran vdout0_29ck1480 FIND v(dout0_29) AT=745.025n

.meas tran vdout0_30ck1480 FIND v(dout0_30) AT=745.025n

.meas tran vdout0_31ck1480 FIND v(dout0_31) AT=745.025n

.meas tran vdout0_32ck1480 FIND v(dout0_32) AT=745.025n

.meas tran vdout0_33ck1480 FIND v(dout0_33) AT=745.025n

.meas tran vdout0_34ck1480 FIND v(dout0_34) AT=745.025n

.meas tran vdout0_35ck1480 FIND v(dout0_35) AT=745.025n

.meas tran vdout0_36ck1480 FIND v(dout0_36) AT=745.025n

.meas tran vdout0_37ck1480 FIND v(dout0_37) AT=745.025n

.meas tran vdout0_38ck1480 FIND v(dout0_38) AT=745.025n

.meas tran vdout0_39ck1480 FIND v(dout0_39) AT=745.025n

.meas tran vdout0_40ck1480 FIND v(dout0_40) AT=745.025n

.meas tran vdout0_41ck1480 FIND v(dout0_41) AT=745.025n

.meas tran vdout0_42ck1480 FIND v(dout0_42) AT=745.025n

.meas tran vdout0_43ck1480 FIND v(dout0_43) AT=745.025n

.meas tran vdout0_44ck1480 FIND v(dout0_44) AT=745.025n

.meas tran vdout0_45ck1480 FIND v(dout0_45) AT=745.025n

.meas tran vdout0_46ck1480 FIND v(dout0_46) AT=745.025n

.meas tran vdout0_47ck1480 FIND v(dout0_47) AT=745.025n

.meas tran vdout0_48ck1480 FIND v(dout0_48) AT=745.025n

.meas tran vdout0_49ck1480 FIND v(dout0_49) AT=745.025n

.meas tran vdout0_50ck1480 FIND v(dout0_50) AT=745.025n

.meas tran vdout0_51ck1480 FIND v(dout0_51) AT=745.025n

.meas tran vdout0_52ck1480 FIND v(dout0_52) AT=745.025n

.meas tran vdout0_53ck1480 FIND v(dout0_53) AT=745.025n

.meas tran vdout0_54ck1480 FIND v(dout0_54) AT=745.025n

.meas tran vdout0_55ck1480 FIND v(dout0_55) AT=745.025n

.meas tran vdout0_56ck1480 FIND v(dout0_56) AT=745.025n

.meas tran vdout0_57ck1480 FIND v(dout0_57) AT=745.025n

.meas tran vdout0_58ck1480 FIND v(dout0_58) AT=745.025n

.meas tran vdout0_59ck1480 FIND v(dout0_59) AT=745.025n

.meas tran vdout0_60ck1480 FIND v(dout0_60) AT=745.025n

.meas tran vdout0_61ck1480 FIND v(dout0_61) AT=745.025n

.meas tran vdout0_62ck1480 FIND v(dout0_62) AT=745.025n

.meas tran vdout0_63ck1480 FIND v(dout0_63) AT=745.025n

.meas tran vdout0_64ck1480 FIND v(dout0_64) AT=745.025n

.meas tran vdout0_65ck1480 FIND v(dout0_65) AT=745.025n

.meas tran vdout0_66ck1480 FIND v(dout0_66) AT=745.025n

.meas tran vdout0_67ck1480 FIND v(dout0_67) AT=745.025n

.meas tran vdout0_68ck1480 FIND v(dout0_68) AT=745.025n

.meas tran vdout0_69ck1480 FIND v(dout0_69) AT=745.025n

.meas tran vdout0_70ck1480 FIND v(dout0_70) AT=745.025n

.meas tran vdout0_71ck1480 FIND v(dout0_71) AT=745.025n

.meas tran vdout0_72ck1480 FIND v(dout0_72) AT=745.025n

.meas tran vdout0_73ck1480 FIND v(dout0_73) AT=745.025n

.meas tran vdout0_74ck1480 FIND v(dout0_74) AT=745.025n

.meas tran vdout0_75ck1480 FIND v(dout0_75) AT=745.025n

.meas tran vdout0_76ck1480 FIND v(dout0_76) AT=745.025n

.meas tran vdout0_77ck1480 FIND v(dout0_77) AT=745.025n

.meas tran vdout0_78ck1480 FIND v(dout0_78) AT=745.025n

.meas tran vdout0_79ck1480 FIND v(dout0_79) AT=745.025n

.meas tran vdout0_80ck1480 FIND v(dout0_80) AT=745.025n

.meas tran vdout0_81ck1480 FIND v(dout0_81) AT=745.025n

.meas tran vdout0_82ck1480 FIND v(dout0_82) AT=745.025n

.meas tran vdout0_83ck1480 FIND v(dout0_83) AT=745.025n

.meas tran vdout0_84ck1480 FIND v(dout0_84) AT=745.025n

.meas tran vdout0_85ck1480 FIND v(dout0_85) AT=745.025n

.meas tran vdout0_86ck1480 FIND v(dout0_86) AT=745.025n

.meas tran vdout0_87ck1480 FIND v(dout0_87) AT=745.025n

.meas tran vdout0_88ck1480 FIND v(dout0_88) AT=745.025n

.meas tran vdout0_89ck1480 FIND v(dout0_89) AT=745.025n

.meas tran vdout0_90ck1480 FIND v(dout0_90) AT=745.025n

.meas tran vdout0_91ck1480 FIND v(dout0_91) AT=745.025n

.meas tran vdout0_92ck1480 FIND v(dout0_92) AT=745.025n

.meas tran vdout0_93ck1480 FIND v(dout0_93) AT=745.025n

.meas tran vdout0_94ck1480 FIND v(dout0_94) AT=745.025n

.meas tran vdout0_95ck1480 FIND v(dout0_95) AT=745.025n

.meas tran vdout0_96ck1480 FIND v(dout0_96) AT=745.025n

.meas tran vdout0_97ck1480 FIND v(dout0_97) AT=745.025n

.meas tran vdout0_98ck1480 FIND v(dout0_98) AT=745.025n

.meas tran vdout0_99ck1480 FIND v(dout0_99) AT=745.025n

.meas tran vdout0_100ck1480 FIND v(dout0_100) AT=745.025n

.meas tran vdout0_101ck1480 FIND v(dout0_101) AT=745.025n

.meas tran vdout0_102ck1480 FIND v(dout0_102) AT=745.025n

.meas tran vdout0_103ck1480 FIND v(dout0_103) AT=745.025n

.meas tran vdout0_104ck1480 FIND v(dout0_104) AT=745.025n

.meas tran vdout0_105ck1480 FIND v(dout0_105) AT=745.025n

.meas tran vdout0_106ck1480 FIND v(dout0_106) AT=745.025n

.meas tran vdout0_107ck1480 FIND v(dout0_107) AT=745.025n

.meas tran vdout0_108ck1480 FIND v(dout0_108) AT=745.025n

.meas tran vdout0_109ck1480 FIND v(dout0_109) AT=745.025n

.meas tran vdout0_110ck1480 FIND v(dout0_110) AT=745.025n

.meas tran vdout0_111ck1480 FIND v(dout0_111) AT=745.025n

.meas tran vdout0_112ck1480 FIND v(dout0_112) AT=745.025n

.meas tran vdout0_113ck1480 FIND v(dout0_113) AT=745.025n

.meas tran vdout0_114ck1480 FIND v(dout0_114) AT=745.025n

.meas tran vdout0_115ck1480 FIND v(dout0_115) AT=745.025n

.meas tran vdout0_116ck1480 FIND v(dout0_116) AT=745.025n

.meas tran vdout0_117ck1480 FIND v(dout0_117) AT=745.025n

.meas tran vdout0_118ck1480 FIND v(dout0_118) AT=745.025n

.meas tran vdout0_119ck1480 FIND v(dout0_119) AT=745.025n

.meas tran vdout0_120ck1480 FIND v(dout0_120) AT=745.025n

.meas tran vdout0_121ck1480 FIND v(dout0_121) AT=745.025n

.meas tran vdout0_122ck1480 FIND v(dout0_122) AT=745.025n

.meas tran vdout0_123ck1480 FIND v(dout0_123) AT=745.025n

.meas tran vdout0_124ck1480 FIND v(dout0_124) AT=745.025n

.meas tran vdout0_125ck1480 FIND v(dout0_125) AT=745.025n

.meas tran vdout0_126ck1480 FIND v(dout0_126) AT=745.025n

.meas tran vdout0_127ck1480 FIND v(dout0_127) AT=745.025n

.meas tran vdout0_128ck1480 FIND v(dout0_128) AT=745.025n

.meas tran vdout0_129ck1480 FIND v(dout0_129) AT=745.025n

.meas tran vdout0_130ck1480 FIND v(dout0_130) AT=745.025n

.meas tran vdout0_131ck1480 FIND v(dout0_131) AT=745.025n

.meas tran vdout0_132ck1480 FIND v(dout0_132) AT=745.025n

.meas tran vdout0_133ck1480 FIND v(dout0_133) AT=745.025n

.meas tran vdout0_134ck1480 FIND v(dout0_134) AT=745.025n

.meas tran vdout0_135ck1480 FIND v(dout0_135) AT=745.025n

.meas tran vdout0_136ck1480 FIND v(dout0_136) AT=745.025n

.meas tran vdout0_137ck1480 FIND v(dout0_137) AT=745.025n

.meas tran vdout0_138ck1480 FIND v(dout0_138) AT=745.025n

.meas tran vdout0_139ck1480 FIND v(dout0_139) AT=745.025n

.meas tran vdout0_140ck1480 FIND v(dout0_140) AT=745.025n

.meas tran vdout0_141ck1480 FIND v(dout0_141) AT=745.025n

.meas tran vdout0_142ck1480 FIND v(dout0_142) AT=745.025n

.meas tran vdout0_143ck1480 FIND v(dout0_143) AT=745.025n

.meas tran vdout0_144ck1480 FIND v(dout0_144) AT=745.025n

.meas tran vdout0_145ck1480 FIND v(dout0_145) AT=745.025n

.meas tran vdout0_146ck1480 FIND v(dout0_146) AT=745.025n

.meas tran vdout0_147ck1480 FIND v(dout0_147) AT=745.025n

.meas tran vdout0_148ck1480 FIND v(dout0_148) AT=745.025n

.meas tran vdout0_149ck1480 FIND v(dout0_149) AT=745.025n

.meas tran vdout0_150ck1480 FIND v(dout0_150) AT=745.025n

.meas tran vdout0_151ck1480 FIND v(dout0_151) AT=745.025n

.meas tran vdout0_152ck1480 FIND v(dout0_152) AT=745.025n

.meas tran vdout0_153ck1480 FIND v(dout0_153) AT=745.025n

.meas tran vdout0_154ck1480 FIND v(dout0_154) AT=745.025n

.meas tran vdout0_155ck1480 FIND v(dout0_155) AT=745.025n

.meas tran vdout0_156ck1480 FIND v(dout0_156) AT=745.025n

.meas tran vdout0_157ck1480 FIND v(dout0_157) AT=745.025n

.meas tran vdout0_158ck1480 FIND v(dout0_158) AT=745.025n

.meas tran vdout0_159ck1480 FIND v(dout0_159) AT=745.025n

.meas tran vdout0_160ck1480 FIND v(dout0_160) AT=745.025n

.meas tran vdout0_161ck1480 FIND v(dout0_161) AT=745.025n

.meas tran vdout0_162ck1480 FIND v(dout0_162) AT=745.025n

.meas tran vdout0_163ck1480 FIND v(dout0_163) AT=745.025n

.meas tran vdout0_164ck1480 FIND v(dout0_164) AT=745.025n

.meas tran vdout0_165ck1480 FIND v(dout0_165) AT=745.025n

.meas tran vdout0_166ck1480 FIND v(dout0_166) AT=745.025n

.meas tran vdout0_167ck1480 FIND v(dout0_167) AT=745.025n

.meas tran vdout0_168ck1480 FIND v(dout0_168) AT=745.025n

.meas tran vdout0_169ck1480 FIND v(dout0_169) AT=745.025n

.meas tran vdout0_170ck1480 FIND v(dout0_170) AT=745.025n

.meas tran vdout0_171ck1480 FIND v(dout0_171) AT=745.025n

.meas tran vdout0_172ck1480 FIND v(dout0_172) AT=745.025n

.meas tran vdout0_173ck1480 FIND v(dout0_173) AT=745.025n

.meas tran vdout0_174ck1480 FIND v(dout0_174) AT=745.025n

.meas tran vdout0_175ck1480 FIND v(dout0_175) AT=745.025n

.meas tran vdout0_176ck1480 FIND v(dout0_176) AT=745.025n

.meas tran vdout0_177ck1480 FIND v(dout0_177) AT=745.025n

.meas tran vdout0_178ck1480 FIND v(dout0_178) AT=745.025n

.meas tran vdout0_179ck1480 FIND v(dout0_179) AT=745.025n

.meas tran vdout0_180ck1480 FIND v(dout0_180) AT=745.025n

.meas tran vdout0_181ck1480 FIND v(dout0_181) AT=745.025n

.meas tran vdout0_182ck1480 FIND v(dout0_182) AT=745.025n

.meas tran vdout0_183ck1480 FIND v(dout0_183) AT=745.025n

.meas tran vdout0_184ck1480 FIND v(dout0_184) AT=745.025n

.meas tran vdout0_185ck1480 FIND v(dout0_185) AT=745.025n

.meas tran vdout0_186ck1480 FIND v(dout0_186) AT=745.025n

.meas tran vdout0_187ck1480 FIND v(dout0_187) AT=745.025n

.meas tran vdout0_188ck1480 FIND v(dout0_188) AT=745.025n

.meas tran vdout0_189ck1480 FIND v(dout0_189) AT=745.025n

.meas tran vdout0_190ck1480 FIND v(dout0_190) AT=745.025n

.meas tran vdout0_191ck1480 FIND v(dout0_191) AT=745.025n

.meas tran vdout0_192ck1480 FIND v(dout0_192) AT=745.025n

.meas tran vdout0_193ck1480 FIND v(dout0_193) AT=745.025n

.meas tran vdout0_194ck1480 FIND v(dout0_194) AT=745.025n

.meas tran vdout0_195ck1480 FIND v(dout0_195) AT=745.025n

.meas tran vdout0_196ck1480 FIND v(dout0_196) AT=745.025n

.meas tran vdout0_197ck1480 FIND v(dout0_197) AT=745.025n

.meas tran vdout0_198ck1480 FIND v(dout0_198) AT=745.025n

.meas tran vdout0_199ck1480 FIND v(dout0_199) AT=745.025n

.meas tran vdout0_200ck1480 FIND v(dout0_200) AT=745.025n

.meas tran vdout0_201ck1480 FIND v(dout0_201) AT=745.025n

.meas tran vdout0_202ck1480 FIND v(dout0_202) AT=745.025n

.meas tran vdout0_203ck1480 FIND v(dout0_203) AT=745.025n

.meas tran vdout0_204ck1480 FIND v(dout0_204) AT=745.025n

.meas tran vdout0_205ck1480 FIND v(dout0_205) AT=745.025n

.meas tran vdout0_206ck1480 FIND v(dout0_206) AT=745.025n

.meas tran vdout0_207ck1480 FIND v(dout0_207) AT=745.025n

.meas tran vdout0_208ck1480 FIND v(dout0_208) AT=745.025n

.meas tran vdout0_209ck1480 FIND v(dout0_209) AT=745.025n

.meas tran vdout0_210ck1480 FIND v(dout0_210) AT=745.025n

.meas tran vdout0_211ck1480 FIND v(dout0_211) AT=745.025n

.meas tran vdout0_212ck1480 FIND v(dout0_212) AT=745.025n

.meas tran vdout0_213ck1480 FIND v(dout0_213) AT=745.025n

.meas tran vdout0_214ck1480 FIND v(dout0_214) AT=745.025n

.meas tran vdout0_215ck1480 FIND v(dout0_215) AT=745.025n

.meas tran vdout0_216ck1480 FIND v(dout0_216) AT=745.025n

.meas tran vdout0_217ck1480 FIND v(dout0_217) AT=745.025n

.meas tran vdout0_218ck1480 FIND v(dout0_218) AT=745.025n

.meas tran vdout0_219ck1480 FIND v(dout0_219) AT=745.025n

.meas tran vdout0_220ck1480 FIND v(dout0_220) AT=745.025n

.meas tran vdout0_221ck1480 FIND v(dout0_221) AT=745.025n

.meas tran vdout0_222ck1480 FIND v(dout0_222) AT=745.025n

.meas tran vdout0_223ck1480 FIND v(dout0_223) AT=745.025n

.meas tran vdout0_224ck1480 FIND v(dout0_224) AT=745.025n

.meas tran vdout0_225ck1480 FIND v(dout0_225) AT=745.025n

.meas tran vdout0_226ck1480 FIND v(dout0_226) AT=745.025n

.meas tran vdout0_227ck1480 FIND v(dout0_227) AT=745.025n

.meas tran vdout0_228ck1480 FIND v(dout0_228) AT=745.025n

.meas tran vdout0_229ck1480 FIND v(dout0_229) AT=745.025n

.meas tran vdout0_230ck1480 FIND v(dout0_230) AT=745.025n

.meas tran vdout0_231ck1480 FIND v(dout0_231) AT=745.025n

.meas tran vdout0_232ck1480 FIND v(dout0_232) AT=745.025n

.meas tran vdout0_233ck1480 FIND v(dout0_233) AT=745.025n

.meas tran vdout0_234ck1480 FIND v(dout0_234) AT=745.025n

.meas tran vdout0_235ck1480 FIND v(dout0_235) AT=745.025n

.meas tran vdout0_236ck1480 FIND v(dout0_236) AT=745.025n

.meas tran vdout0_237ck1480 FIND v(dout0_237) AT=745.025n

.meas tran vdout0_238ck1480 FIND v(dout0_238) AT=745.025n

.meas tran vdout0_239ck1480 FIND v(dout0_239) AT=745.025n

.meas tran vdout0_240ck1480 FIND v(dout0_240) AT=745.025n

.meas tran vdout0_241ck1480 FIND v(dout0_241) AT=745.025n

.meas tran vdout0_242ck1480 FIND v(dout0_242) AT=745.025n

.meas tran vdout0_243ck1480 FIND v(dout0_243) AT=745.025n

.meas tran vdout0_244ck1480 FIND v(dout0_244) AT=745.025n

.meas tran vdout0_245ck1480 FIND v(dout0_245) AT=745.025n

.meas tran vdout0_246ck1480 FIND v(dout0_246) AT=745.025n

.meas tran vdout0_247ck1480 FIND v(dout0_247) AT=745.025n

.meas tran vdout0_248ck1480 FIND v(dout0_248) AT=745.025n

.meas tran vdout0_249ck1480 FIND v(dout0_249) AT=745.025n

.meas tran vdout0_250ck1480 FIND v(dout0_250) AT=745.025n

.meas tran vdout0_251ck1480 FIND v(dout0_251) AT=745.025n

.meas tran vdout0_252ck1480 FIND v(dout0_252) AT=745.025n

.meas tran vdout0_253ck1480 FIND v(dout0_253) AT=745.025n

.meas tran vdout0_254ck1480 FIND v(dout0_254) AT=745.025n

.meas tran vdout0_255ck1480 FIND v(dout0_255) AT=745.025n

.meas tran vdout0_0ck1540 FIND v(dout0_0) AT=775.025n

.meas tran vdout0_1ck1540 FIND v(dout0_1) AT=775.025n

.meas tran vdout0_2ck1540 FIND v(dout0_2) AT=775.025n

.meas tran vdout0_3ck1540 FIND v(dout0_3) AT=775.025n

.meas tran vdout0_4ck1540 FIND v(dout0_4) AT=775.025n

.meas tran vdout0_5ck1540 FIND v(dout0_5) AT=775.025n

.meas tran vdout0_6ck1540 FIND v(dout0_6) AT=775.025n

.meas tran vdout0_7ck1540 FIND v(dout0_7) AT=775.025n

.meas tran vdout0_8ck1540 FIND v(dout0_8) AT=775.025n

.meas tran vdout0_9ck1540 FIND v(dout0_9) AT=775.025n

.meas tran vdout0_10ck1540 FIND v(dout0_10) AT=775.025n

.meas tran vdout0_11ck1540 FIND v(dout0_11) AT=775.025n

.meas tran vdout0_12ck1540 FIND v(dout0_12) AT=775.025n

.meas tran vdout0_13ck1540 FIND v(dout0_13) AT=775.025n

.meas tran vdout0_14ck1540 FIND v(dout0_14) AT=775.025n

.meas tran vdout0_15ck1540 FIND v(dout0_15) AT=775.025n

.meas tran vdout0_16ck1540 FIND v(dout0_16) AT=775.025n

.meas tran vdout0_17ck1540 FIND v(dout0_17) AT=775.025n

.meas tran vdout0_18ck1540 FIND v(dout0_18) AT=775.025n

.meas tran vdout0_19ck1540 FIND v(dout0_19) AT=775.025n

.meas tran vdout0_20ck1540 FIND v(dout0_20) AT=775.025n

.meas tran vdout0_21ck1540 FIND v(dout0_21) AT=775.025n

.meas tran vdout0_22ck1540 FIND v(dout0_22) AT=775.025n

.meas tran vdout0_23ck1540 FIND v(dout0_23) AT=775.025n

.meas tran vdout0_24ck1540 FIND v(dout0_24) AT=775.025n

.meas tran vdout0_25ck1540 FIND v(dout0_25) AT=775.025n

.meas tran vdout0_26ck1540 FIND v(dout0_26) AT=775.025n

.meas tran vdout0_27ck1540 FIND v(dout0_27) AT=775.025n

.meas tran vdout0_28ck1540 FIND v(dout0_28) AT=775.025n

.meas tran vdout0_29ck1540 FIND v(dout0_29) AT=775.025n

.meas tran vdout0_30ck1540 FIND v(dout0_30) AT=775.025n

.meas tran vdout0_31ck1540 FIND v(dout0_31) AT=775.025n

.meas tran vdout0_32ck1540 FIND v(dout0_32) AT=775.025n

.meas tran vdout0_33ck1540 FIND v(dout0_33) AT=775.025n

.meas tran vdout0_34ck1540 FIND v(dout0_34) AT=775.025n

.meas tran vdout0_35ck1540 FIND v(dout0_35) AT=775.025n

.meas tran vdout0_36ck1540 FIND v(dout0_36) AT=775.025n

.meas tran vdout0_37ck1540 FIND v(dout0_37) AT=775.025n

.meas tran vdout0_38ck1540 FIND v(dout0_38) AT=775.025n

.meas tran vdout0_39ck1540 FIND v(dout0_39) AT=775.025n

.meas tran vdout0_40ck1540 FIND v(dout0_40) AT=775.025n

.meas tran vdout0_41ck1540 FIND v(dout0_41) AT=775.025n

.meas tran vdout0_42ck1540 FIND v(dout0_42) AT=775.025n

.meas tran vdout0_43ck1540 FIND v(dout0_43) AT=775.025n

.meas tran vdout0_44ck1540 FIND v(dout0_44) AT=775.025n

.meas tran vdout0_45ck1540 FIND v(dout0_45) AT=775.025n

.meas tran vdout0_46ck1540 FIND v(dout0_46) AT=775.025n

.meas tran vdout0_47ck1540 FIND v(dout0_47) AT=775.025n

.meas tran vdout0_48ck1540 FIND v(dout0_48) AT=775.025n

.meas tran vdout0_49ck1540 FIND v(dout0_49) AT=775.025n

.meas tran vdout0_50ck1540 FIND v(dout0_50) AT=775.025n

.meas tran vdout0_51ck1540 FIND v(dout0_51) AT=775.025n

.meas tran vdout0_52ck1540 FIND v(dout0_52) AT=775.025n

.meas tran vdout0_53ck1540 FIND v(dout0_53) AT=775.025n

.meas tran vdout0_54ck1540 FIND v(dout0_54) AT=775.025n

.meas tran vdout0_55ck1540 FIND v(dout0_55) AT=775.025n

.meas tran vdout0_56ck1540 FIND v(dout0_56) AT=775.025n

.meas tran vdout0_57ck1540 FIND v(dout0_57) AT=775.025n

.meas tran vdout0_58ck1540 FIND v(dout0_58) AT=775.025n

.meas tran vdout0_59ck1540 FIND v(dout0_59) AT=775.025n

.meas tran vdout0_60ck1540 FIND v(dout0_60) AT=775.025n

.meas tran vdout0_61ck1540 FIND v(dout0_61) AT=775.025n

.meas tran vdout0_62ck1540 FIND v(dout0_62) AT=775.025n

.meas tran vdout0_63ck1540 FIND v(dout0_63) AT=775.025n

.meas tran vdout0_64ck1540 FIND v(dout0_64) AT=775.025n

.meas tran vdout0_65ck1540 FIND v(dout0_65) AT=775.025n

.meas tran vdout0_66ck1540 FIND v(dout0_66) AT=775.025n

.meas tran vdout0_67ck1540 FIND v(dout0_67) AT=775.025n

.meas tran vdout0_68ck1540 FIND v(dout0_68) AT=775.025n

.meas tran vdout0_69ck1540 FIND v(dout0_69) AT=775.025n

.meas tran vdout0_70ck1540 FIND v(dout0_70) AT=775.025n

.meas tran vdout0_71ck1540 FIND v(dout0_71) AT=775.025n

.meas tran vdout0_72ck1540 FIND v(dout0_72) AT=775.025n

.meas tran vdout0_73ck1540 FIND v(dout0_73) AT=775.025n

.meas tran vdout0_74ck1540 FIND v(dout0_74) AT=775.025n

.meas tran vdout0_75ck1540 FIND v(dout0_75) AT=775.025n

.meas tran vdout0_76ck1540 FIND v(dout0_76) AT=775.025n

.meas tran vdout0_77ck1540 FIND v(dout0_77) AT=775.025n

.meas tran vdout0_78ck1540 FIND v(dout0_78) AT=775.025n

.meas tran vdout0_79ck1540 FIND v(dout0_79) AT=775.025n

.meas tran vdout0_80ck1540 FIND v(dout0_80) AT=775.025n

.meas tran vdout0_81ck1540 FIND v(dout0_81) AT=775.025n

.meas tran vdout0_82ck1540 FIND v(dout0_82) AT=775.025n

.meas tran vdout0_83ck1540 FIND v(dout0_83) AT=775.025n

.meas tran vdout0_84ck1540 FIND v(dout0_84) AT=775.025n

.meas tran vdout0_85ck1540 FIND v(dout0_85) AT=775.025n

.meas tran vdout0_86ck1540 FIND v(dout0_86) AT=775.025n

.meas tran vdout0_87ck1540 FIND v(dout0_87) AT=775.025n

.meas tran vdout0_88ck1540 FIND v(dout0_88) AT=775.025n

.meas tran vdout0_89ck1540 FIND v(dout0_89) AT=775.025n

.meas tran vdout0_90ck1540 FIND v(dout0_90) AT=775.025n

.meas tran vdout0_91ck1540 FIND v(dout0_91) AT=775.025n

.meas tran vdout0_92ck1540 FIND v(dout0_92) AT=775.025n

.meas tran vdout0_93ck1540 FIND v(dout0_93) AT=775.025n

.meas tran vdout0_94ck1540 FIND v(dout0_94) AT=775.025n

.meas tran vdout0_95ck1540 FIND v(dout0_95) AT=775.025n

.meas tran vdout0_96ck1540 FIND v(dout0_96) AT=775.025n

.meas tran vdout0_97ck1540 FIND v(dout0_97) AT=775.025n

.meas tran vdout0_98ck1540 FIND v(dout0_98) AT=775.025n

.meas tran vdout0_99ck1540 FIND v(dout0_99) AT=775.025n

.meas tran vdout0_100ck1540 FIND v(dout0_100) AT=775.025n

.meas tran vdout0_101ck1540 FIND v(dout0_101) AT=775.025n

.meas tran vdout0_102ck1540 FIND v(dout0_102) AT=775.025n

.meas tran vdout0_103ck1540 FIND v(dout0_103) AT=775.025n

.meas tran vdout0_104ck1540 FIND v(dout0_104) AT=775.025n

.meas tran vdout0_105ck1540 FIND v(dout0_105) AT=775.025n

.meas tran vdout0_106ck1540 FIND v(dout0_106) AT=775.025n

.meas tran vdout0_107ck1540 FIND v(dout0_107) AT=775.025n

.meas tran vdout0_108ck1540 FIND v(dout0_108) AT=775.025n

.meas tran vdout0_109ck1540 FIND v(dout0_109) AT=775.025n

.meas tran vdout0_110ck1540 FIND v(dout0_110) AT=775.025n

.meas tran vdout0_111ck1540 FIND v(dout0_111) AT=775.025n

.meas tran vdout0_112ck1540 FIND v(dout0_112) AT=775.025n

.meas tran vdout0_113ck1540 FIND v(dout0_113) AT=775.025n

.meas tran vdout0_114ck1540 FIND v(dout0_114) AT=775.025n

.meas tran vdout0_115ck1540 FIND v(dout0_115) AT=775.025n

.meas tran vdout0_116ck1540 FIND v(dout0_116) AT=775.025n

.meas tran vdout0_117ck1540 FIND v(dout0_117) AT=775.025n

.meas tran vdout0_118ck1540 FIND v(dout0_118) AT=775.025n

.meas tran vdout0_119ck1540 FIND v(dout0_119) AT=775.025n

.meas tran vdout0_120ck1540 FIND v(dout0_120) AT=775.025n

.meas tran vdout0_121ck1540 FIND v(dout0_121) AT=775.025n

.meas tran vdout0_122ck1540 FIND v(dout0_122) AT=775.025n

.meas tran vdout0_123ck1540 FIND v(dout0_123) AT=775.025n

.meas tran vdout0_124ck1540 FIND v(dout0_124) AT=775.025n

.meas tran vdout0_125ck1540 FIND v(dout0_125) AT=775.025n

.meas tran vdout0_126ck1540 FIND v(dout0_126) AT=775.025n

.meas tran vdout0_127ck1540 FIND v(dout0_127) AT=775.025n

.meas tran vdout0_128ck1540 FIND v(dout0_128) AT=775.025n

.meas tran vdout0_129ck1540 FIND v(dout0_129) AT=775.025n

.meas tran vdout0_130ck1540 FIND v(dout0_130) AT=775.025n

.meas tran vdout0_131ck1540 FIND v(dout0_131) AT=775.025n

.meas tran vdout0_132ck1540 FIND v(dout0_132) AT=775.025n

.meas tran vdout0_133ck1540 FIND v(dout0_133) AT=775.025n

.meas tran vdout0_134ck1540 FIND v(dout0_134) AT=775.025n

.meas tran vdout0_135ck1540 FIND v(dout0_135) AT=775.025n

.meas tran vdout0_136ck1540 FIND v(dout0_136) AT=775.025n

.meas tran vdout0_137ck1540 FIND v(dout0_137) AT=775.025n

.meas tran vdout0_138ck1540 FIND v(dout0_138) AT=775.025n

.meas tran vdout0_139ck1540 FIND v(dout0_139) AT=775.025n

.meas tran vdout0_140ck1540 FIND v(dout0_140) AT=775.025n

.meas tran vdout0_141ck1540 FIND v(dout0_141) AT=775.025n

.meas tran vdout0_142ck1540 FIND v(dout0_142) AT=775.025n

.meas tran vdout0_143ck1540 FIND v(dout0_143) AT=775.025n

.meas tran vdout0_144ck1540 FIND v(dout0_144) AT=775.025n

.meas tran vdout0_145ck1540 FIND v(dout0_145) AT=775.025n

.meas tran vdout0_146ck1540 FIND v(dout0_146) AT=775.025n

.meas tran vdout0_147ck1540 FIND v(dout0_147) AT=775.025n

.meas tran vdout0_148ck1540 FIND v(dout0_148) AT=775.025n

.meas tran vdout0_149ck1540 FIND v(dout0_149) AT=775.025n

.meas tran vdout0_150ck1540 FIND v(dout0_150) AT=775.025n

.meas tran vdout0_151ck1540 FIND v(dout0_151) AT=775.025n

.meas tran vdout0_152ck1540 FIND v(dout0_152) AT=775.025n

.meas tran vdout0_153ck1540 FIND v(dout0_153) AT=775.025n

.meas tran vdout0_154ck1540 FIND v(dout0_154) AT=775.025n

.meas tran vdout0_155ck1540 FIND v(dout0_155) AT=775.025n

.meas tran vdout0_156ck1540 FIND v(dout0_156) AT=775.025n

.meas tran vdout0_157ck1540 FIND v(dout0_157) AT=775.025n

.meas tran vdout0_158ck1540 FIND v(dout0_158) AT=775.025n

.meas tran vdout0_159ck1540 FIND v(dout0_159) AT=775.025n

.meas tran vdout0_160ck1540 FIND v(dout0_160) AT=775.025n

.meas tran vdout0_161ck1540 FIND v(dout0_161) AT=775.025n

.meas tran vdout0_162ck1540 FIND v(dout0_162) AT=775.025n

.meas tran vdout0_163ck1540 FIND v(dout0_163) AT=775.025n

.meas tran vdout0_164ck1540 FIND v(dout0_164) AT=775.025n

.meas tran vdout0_165ck1540 FIND v(dout0_165) AT=775.025n

.meas tran vdout0_166ck1540 FIND v(dout0_166) AT=775.025n

.meas tran vdout0_167ck1540 FIND v(dout0_167) AT=775.025n

.meas tran vdout0_168ck1540 FIND v(dout0_168) AT=775.025n

.meas tran vdout0_169ck1540 FIND v(dout0_169) AT=775.025n

.meas tran vdout0_170ck1540 FIND v(dout0_170) AT=775.025n

.meas tran vdout0_171ck1540 FIND v(dout0_171) AT=775.025n

.meas tran vdout0_172ck1540 FIND v(dout0_172) AT=775.025n

.meas tran vdout0_173ck1540 FIND v(dout0_173) AT=775.025n

.meas tran vdout0_174ck1540 FIND v(dout0_174) AT=775.025n

.meas tran vdout0_175ck1540 FIND v(dout0_175) AT=775.025n

.meas tran vdout0_176ck1540 FIND v(dout0_176) AT=775.025n

.meas tran vdout0_177ck1540 FIND v(dout0_177) AT=775.025n

.meas tran vdout0_178ck1540 FIND v(dout0_178) AT=775.025n

.meas tran vdout0_179ck1540 FIND v(dout0_179) AT=775.025n

.meas tran vdout0_180ck1540 FIND v(dout0_180) AT=775.025n

.meas tran vdout0_181ck1540 FIND v(dout0_181) AT=775.025n

.meas tran vdout0_182ck1540 FIND v(dout0_182) AT=775.025n

.meas tran vdout0_183ck1540 FIND v(dout0_183) AT=775.025n

.meas tran vdout0_184ck1540 FIND v(dout0_184) AT=775.025n

.meas tran vdout0_185ck1540 FIND v(dout0_185) AT=775.025n

.meas tran vdout0_186ck1540 FIND v(dout0_186) AT=775.025n

.meas tran vdout0_187ck1540 FIND v(dout0_187) AT=775.025n

.meas tran vdout0_188ck1540 FIND v(dout0_188) AT=775.025n

.meas tran vdout0_189ck1540 FIND v(dout0_189) AT=775.025n

.meas tran vdout0_190ck1540 FIND v(dout0_190) AT=775.025n

.meas tran vdout0_191ck1540 FIND v(dout0_191) AT=775.025n

.meas tran vdout0_192ck1540 FIND v(dout0_192) AT=775.025n

.meas tran vdout0_193ck1540 FIND v(dout0_193) AT=775.025n

.meas tran vdout0_194ck1540 FIND v(dout0_194) AT=775.025n

.meas tran vdout0_195ck1540 FIND v(dout0_195) AT=775.025n

.meas tran vdout0_196ck1540 FIND v(dout0_196) AT=775.025n

.meas tran vdout0_197ck1540 FIND v(dout0_197) AT=775.025n

.meas tran vdout0_198ck1540 FIND v(dout0_198) AT=775.025n

.meas tran vdout0_199ck1540 FIND v(dout0_199) AT=775.025n

.meas tran vdout0_200ck1540 FIND v(dout0_200) AT=775.025n

.meas tran vdout0_201ck1540 FIND v(dout0_201) AT=775.025n

.meas tran vdout0_202ck1540 FIND v(dout0_202) AT=775.025n

.meas tran vdout0_203ck1540 FIND v(dout0_203) AT=775.025n

.meas tran vdout0_204ck1540 FIND v(dout0_204) AT=775.025n

.meas tran vdout0_205ck1540 FIND v(dout0_205) AT=775.025n

.meas tran vdout0_206ck1540 FIND v(dout0_206) AT=775.025n

.meas tran vdout0_207ck1540 FIND v(dout0_207) AT=775.025n

.meas tran vdout0_208ck1540 FIND v(dout0_208) AT=775.025n

.meas tran vdout0_209ck1540 FIND v(dout0_209) AT=775.025n

.meas tran vdout0_210ck1540 FIND v(dout0_210) AT=775.025n

.meas tran vdout0_211ck1540 FIND v(dout0_211) AT=775.025n

.meas tran vdout0_212ck1540 FIND v(dout0_212) AT=775.025n

.meas tran vdout0_213ck1540 FIND v(dout0_213) AT=775.025n

.meas tran vdout0_214ck1540 FIND v(dout0_214) AT=775.025n

.meas tran vdout0_215ck1540 FIND v(dout0_215) AT=775.025n

.meas tran vdout0_216ck1540 FIND v(dout0_216) AT=775.025n

.meas tran vdout0_217ck1540 FIND v(dout0_217) AT=775.025n

.meas tran vdout0_218ck1540 FIND v(dout0_218) AT=775.025n

.meas tran vdout0_219ck1540 FIND v(dout0_219) AT=775.025n

.meas tran vdout0_220ck1540 FIND v(dout0_220) AT=775.025n

.meas tran vdout0_221ck1540 FIND v(dout0_221) AT=775.025n

.meas tran vdout0_222ck1540 FIND v(dout0_222) AT=775.025n

.meas tran vdout0_223ck1540 FIND v(dout0_223) AT=775.025n

.meas tran vdout0_224ck1540 FIND v(dout0_224) AT=775.025n

.meas tran vdout0_225ck1540 FIND v(dout0_225) AT=775.025n

.meas tran vdout0_226ck1540 FIND v(dout0_226) AT=775.025n

.meas tran vdout0_227ck1540 FIND v(dout0_227) AT=775.025n

.meas tran vdout0_228ck1540 FIND v(dout0_228) AT=775.025n

.meas tran vdout0_229ck1540 FIND v(dout0_229) AT=775.025n

.meas tran vdout0_230ck1540 FIND v(dout0_230) AT=775.025n

.meas tran vdout0_231ck1540 FIND v(dout0_231) AT=775.025n

.meas tran vdout0_232ck1540 FIND v(dout0_232) AT=775.025n

.meas tran vdout0_233ck1540 FIND v(dout0_233) AT=775.025n

.meas tran vdout0_234ck1540 FIND v(dout0_234) AT=775.025n

.meas tran vdout0_235ck1540 FIND v(dout0_235) AT=775.025n

.meas tran vdout0_236ck1540 FIND v(dout0_236) AT=775.025n

.meas tran vdout0_237ck1540 FIND v(dout0_237) AT=775.025n

.meas tran vdout0_238ck1540 FIND v(dout0_238) AT=775.025n

.meas tran vdout0_239ck1540 FIND v(dout0_239) AT=775.025n

.meas tran vdout0_240ck1540 FIND v(dout0_240) AT=775.025n

.meas tran vdout0_241ck1540 FIND v(dout0_241) AT=775.025n

.meas tran vdout0_242ck1540 FIND v(dout0_242) AT=775.025n

.meas tran vdout0_243ck1540 FIND v(dout0_243) AT=775.025n

.meas tran vdout0_244ck1540 FIND v(dout0_244) AT=775.025n

.meas tran vdout0_245ck1540 FIND v(dout0_245) AT=775.025n

.meas tran vdout0_246ck1540 FIND v(dout0_246) AT=775.025n

.meas tran vdout0_247ck1540 FIND v(dout0_247) AT=775.025n

.meas tran vdout0_248ck1540 FIND v(dout0_248) AT=775.025n

.meas tran vdout0_249ck1540 FIND v(dout0_249) AT=775.025n

.meas tran vdout0_250ck1540 FIND v(dout0_250) AT=775.025n

.meas tran vdout0_251ck1540 FIND v(dout0_251) AT=775.025n

.meas tran vdout0_252ck1540 FIND v(dout0_252) AT=775.025n

.meas tran vdout0_253ck1540 FIND v(dout0_253) AT=775.025n

.meas tran vdout0_254ck1540 FIND v(dout0_254) AT=775.025n

.meas tran vdout0_255ck1540 FIND v(dout0_255) AT=775.025n

.meas tran vdout0_0ck1570 FIND v(dout0_0) AT=790.025n

.meas tran vdout0_1ck1570 FIND v(dout0_1) AT=790.025n

.meas tran vdout0_2ck1570 FIND v(dout0_2) AT=790.025n

.meas tran vdout0_3ck1570 FIND v(dout0_3) AT=790.025n

.meas tran vdout0_4ck1570 FIND v(dout0_4) AT=790.025n

.meas tran vdout0_5ck1570 FIND v(dout0_5) AT=790.025n

.meas tran vdout0_6ck1570 FIND v(dout0_6) AT=790.025n

.meas tran vdout0_7ck1570 FIND v(dout0_7) AT=790.025n

.meas tran vdout0_8ck1570 FIND v(dout0_8) AT=790.025n

.meas tran vdout0_9ck1570 FIND v(dout0_9) AT=790.025n

.meas tran vdout0_10ck1570 FIND v(dout0_10) AT=790.025n

.meas tran vdout0_11ck1570 FIND v(dout0_11) AT=790.025n

.meas tran vdout0_12ck1570 FIND v(dout0_12) AT=790.025n

.meas tran vdout0_13ck1570 FIND v(dout0_13) AT=790.025n

.meas tran vdout0_14ck1570 FIND v(dout0_14) AT=790.025n

.meas tran vdout0_15ck1570 FIND v(dout0_15) AT=790.025n

.meas tran vdout0_16ck1570 FIND v(dout0_16) AT=790.025n

.meas tran vdout0_17ck1570 FIND v(dout0_17) AT=790.025n

.meas tran vdout0_18ck1570 FIND v(dout0_18) AT=790.025n

.meas tran vdout0_19ck1570 FIND v(dout0_19) AT=790.025n

.meas tran vdout0_20ck1570 FIND v(dout0_20) AT=790.025n

.meas tran vdout0_21ck1570 FIND v(dout0_21) AT=790.025n

.meas tran vdout0_22ck1570 FIND v(dout0_22) AT=790.025n

.meas tran vdout0_23ck1570 FIND v(dout0_23) AT=790.025n

.meas tran vdout0_24ck1570 FIND v(dout0_24) AT=790.025n

.meas tran vdout0_25ck1570 FIND v(dout0_25) AT=790.025n

.meas tran vdout0_26ck1570 FIND v(dout0_26) AT=790.025n

.meas tran vdout0_27ck1570 FIND v(dout0_27) AT=790.025n

.meas tran vdout0_28ck1570 FIND v(dout0_28) AT=790.025n

.meas tran vdout0_29ck1570 FIND v(dout0_29) AT=790.025n

.meas tran vdout0_30ck1570 FIND v(dout0_30) AT=790.025n

.meas tran vdout0_31ck1570 FIND v(dout0_31) AT=790.025n

.meas tran vdout0_32ck1570 FIND v(dout0_32) AT=790.025n

.meas tran vdout0_33ck1570 FIND v(dout0_33) AT=790.025n

.meas tran vdout0_34ck1570 FIND v(dout0_34) AT=790.025n

.meas tran vdout0_35ck1570 FIND v(dout0_35) AT=790.025n

.meas tran vdout0_36ck1570 FIND v(dout0_36) AT=790.025n

.meas tran vdout0_37ck1570 FIND v(dout0_37) AT=790.025n

.meas tran vdout0_38ck1570 FIND v(dout0_38) AT=790.025n

.meas tran vdout0_39ck1570 FIND v(dout0_39) AT=790.025n

.meas tran vdout0_40ck1570 FIND v(dout0_40) AT=790.025n

.meas tran vdout0_41ck1570 FIND v(dout0_41) AT=790.025n

.meas tran vdout0_42ck1570 FIND v(dout0_42) AT=790.025n

.meas tran vdout0_43ck1570 FIND v(dout0_43) AT=790.025n

.meas tran vdout0_44ck1570 FIND v(dout0_44) AT=790.025n

.meas tran vdout0_45ck1570 FIND v(dout0_45) AT=790.025n

.meas tran vdout0_46ck1570 FIND v(dout0_46) AT=790.025n

.meas tran vdout0_47ck1570 FIND v(dout0_47) AT=790.025n

.meas tran vdout0_48ck1570 FIND v(dout0_48) AT=790.025n

.meas tran vdout0_49ck1570 FIND v(dout0_49) AT=790.025n

.meas tran vdout0_50ck1570 FIND v(dout0_50) AT=790.025n

.meas tran vdout0_51ck1570 FIND v(dout0_51) AT=790.025n

.meas tran vdout0_52ck1570 FIND v(dout0_52) AT=790.025n

.meas tran vdout0_53ck1570 FIND v(dout0_53) AT=790.025n

.meas tran vdout0_54ck1570 FIND v(dout0_54) AT=790.025n

.meas tran vdout0_55ck1570 FIND v(dout0_55) AT=790.025n

.meas tran vdout0_56ck1570 FIND v(dout0_56) AT=790.025n

.meas tran vdout0_57ck1570 FIND v(dout0_57) AT=790.025n

.meas tran vdout0_58ck1570 FIND v(dout0_58) AT=790.025n

.meas tran vdout0_59ck1570 FIND v(dout0_59) AT=790.025n

.meas tran vdout0_60ck1570 FIND v(dout0_60) AT=790.025n

.meas tran vdout0_61ck1570 FIND v(dout0_61) AT=790.025n

.meas tran vdout0_62ck1570 FIND v(dout0_62) AT=790.025n

.meas tran vdout0_63ck1570 FIND v(dout0_63) AT=790.025n

.meas tran vdout0_64ck1570 FIND v(dout0_64) AT=790.025n

.meas tran vdout0_65ck1570 FIND v(dout0_65) AT=790.025n

.meas tran vdout0_66ck1570 FIND v(dout0_66) AT=790.025n

.meas tran vdout0_67ck1570 FIND v(dout0_67) AT=790.025n

.meas tran vdout0_68ck1570 FIND v(dout0_68) AT=790.025n

.meas tran vdout0_69ck1570 FIND v(dout0_69) AT=790.025n

.meas tran vdout0_70ck1570 FIND v(dout0_70) AT=790.025n

.meas tran vdout0_71ck1570 FIND v(dout0_71) AT=790.025n

.meas tran vdout0_72ck1570 FIND v(dout0_72) AT=790.025n

.meas tran vdout0_73ck1570 FIND v(dout0_73) AT=790.025n

.meas tran vdout0_74ck1570 FIND v(dout0_74) AT=790.025n

.meas tran vdout0_75ck1570 FIND v(dout0_75) AT=790.025n

.meas tran vdout0_76ck1570 FIND v(dout0_76) AT=790.025n

.meas tran vdout0_77ck1570 FIND v(dout0_77) AT=790.025n

.meas tran vdout0_78ck1570 FIND v(dout0_78) AT=790.025n

.meas tran vdout0_79ck1570 FIND v(dout0_79) AT=790.025n

.meas tran vdout0_80ck1570 FIND v(dout0_80) AT=790.025n

.meas tran vdout0_81ck1570 FIND v(dout0_81) AT=790.025n

.meas tran vdout0_82ck1570 FIND v(dout0_82) AT=790.025n

.meas tran vdout0_83ck1570 FIND v(dout0_83) AT=790.025n

.meas tran vdout0_84ck1570 FIND v(dout0_84) AT=790.025n

.meas tran vdout0_85ck1570 FIND v(dout0_85) AT=790.025n

.meas tran vdout0_86ck1570 FIND v(dout0_86) AT=790.025n

.meas tran vdout0_87ck1570 FIND v(dout0_87) AT=790.025n

.meas tran vdout0_88ck1570 FIND v(dout0_88) AT=790.025n

.meas tran vdout0_89ck1570 FIND v(dout0_89) AT=790.025n

.meas tran vdout0_90ck1570 FIND v(dout0_90) AT=790.025n

.meas tran vdout0_91ck1570 FIND v(dout0_91) AT=790.025n

.meas tran vdout0_92ck1570 FIND v(dout0_92) AT=790.025n

.meas tran vdout0_93ck1570 FIND v(dout0_93) AT=790.025n

.meas tran vdout0_94ck1570 FIND v(dout0_94) AT=790.025n

.meas tran vdout0_95ck1570 FIND v(dout0_95) AT=790.025n

.meas tran vdout0_96ck1570 FIND v(dout0_96) AT=790.025n

.meas tran vdout0_97ck1570 FIND v(dout0_97) AT=790.025n

.meas tran vdout0_98ck1570 FIND v(dout0_98) AT=790.025n

.meas tran vdout0_99ck1570 FIND v(dout0_99) AT=790.025n

.meas tran vdout0_100ck1570 FIND v(dout0_100) AT=790.025n

.meas tran vdout0_101ck1570 FIND v(dout0_101) AT=790.025n

.meas tran vdout0_102ck1570 FIND v(dout0_102) AT=790.025n

.meas tran vdout0_103ck1570 FIND v(dout0_103) AT=790.025n

.meas tran vdout0_104ck1570 FIND v(dout0_104) AT=790.025n

.meas tran vdout0_105ck1570 FIND v(dout0_105) AT=790.025n

.meas tran vdout0_106ck1570 FIND v(dout0_106) AT=790.025n

.meas tran vdout0_107ck1570 FIND v(dout0_107) AT=790.025n

.meas tran vdout0_108ck1570 FIND v(dout0_108) AT=790.025n

.meas tran vdout0_109ck1570 FIND v(dout0_109) AT=790.025n

.meas tran vdout0_110ck1570 FIND v(dout0_110) AT=790.025n

.meas tran vdout0_111ck1570 FIND v(dout0_111) AT=790.025n

.meas tran vdout0_112ck1570 FIND v(dout0_112) AT=790.025n

.meas tran vdout0_113ck1570 FIND v(dout0_113) AT=790.025n

.meas tran vdout0_114ck1570 FIND v(dout0_114) AT=790.025n

.meas tran vdout0_115ck1570 FIND v(dout0_115) AT=790.025n

.meas tran vdout0_116ck1570 FIND v(dout0_116) AT=790.025n

.meas tran vdout0_117ck1570 FIND v(dout0_117) AT=790.025n

.meas tran vdout0_118ck1570 FIND v(dout0_118) AT=790.025n

.meas tran vdout0_119ck1570 FIND v(dout0_119) AT=790.025n

.meas tran vdout0_120ck1570 FIND v(dout0_120) AT=790.025n

.meas tran vdout0_121ck1570 FIND v(dout0_121) AT=790.025n

.meas tran vdout0_122ck1570 FIND v(dout0_122) AT=790.025n

.meas tran vdout0_123ck1570 FIND v(dout0_123) AT=790.025n

.meas tran vdout0_124ck1570 FIND v(dout0_124) AT=790.025n

.meas tran vdout0_125ck1570 FIND v(dout0_125) AT=790.025n

.meas tran vdout0_126ck1570 FIND v(dout0_126) AT=790.025n

.meas tran vdout0_127ck1570 FIND v(dout0_127) AT=790.025n

.meas tran vdout0_128ck1570 FIND v(dout0_128) AT=790.025n

.meas tran vdout0_129ck1570 FIND v(dout0_129) AT=790.025n

.meas tran vdout0_130ck1570 FIND v(dout0_130) AT=790.025n

.meas tran vdout0_131ck1570 FIND v(dout0_131) AT=790.025n

.meas tran vdout0_132ck1570 FIND v(dout0_132) AT=790.025n

.meas tran vdout0_133ck1570 FIND v(dout0_133) AT=790.025n

.meas tran vdout0_134ck1570 FIND v(dout0_134) AT=790.025n

.meas tran vdout0_135ck1570 FIND v(dout0_135) AT=790.025n

.meas tran vdout0_136ck1570 FIND v(dout0_136) AT=790.025n

.meas tran vdout0_137ck1570 FIND v(dout0_137) AT=790.025n

.meas tran vdout0_138ck1570 FIND v(dout0_138) AT=790.025n

.meas tran vdout0_139ck1570 FIND v(dout0_139) AT=790.025n

.meas tran vdout0_140ck1570 FIND v(dout0_140) AT=790.025n

.meas tran vdout0_141ck1570 FIND v(dout0_141) AT=790.025n

.meas tran vdout0_142ck1570 FIND v(dout0_142) AT=790.025n

.meas tran vdout0_143ck1570 FIND v(dout0_143) AT=790.025n

.meas tran vdout0_144ck1570 FIND v(dout0_144) AT=790.025n

.meas tran vdout0_145ck1570 FIND v(dout0_145) AT=790.025n

.meas tran vdout0_146ck1570 FIND v(dout0_146) AT=790.025n

.meas tran vdout0_147ck1570 FIND v(dout0_147) AT=790.025n

.meas tran vdout0_148ck1570 FIND v(dout0_148) AT=790.025n

.meas tran vdout0_149ck1570 FIND v(dout0_149) AT=790.025n

.meas tran vdout0_150ck1570 FIND v(dout0_150) AT=790.025n

.meas tran vdout0_151ck1570 FIND v(dout0_151) AT=790.025n

.meas tran vdout0_152ck1570 FIND v(dout0_152) AT=790.025n

.meas tran vdout0_153ck1570 FIND v(dout0_153) AT=790.025n

.meas tran vdout0_154ck1570 FIND v(dout0_154) AT=790.025n

.meas tran vdout0_155ck1570 FIND v(dout0_155) AT=790.025n

.meas tran vdout0_156ck1570 FIND v(dout0_156) AT=790.025n

.meas tran vdout0_157ck1570 FIND v(dout0_157) AT=790.025n

.meas tran vdout0_158ck1570 FIND v(dout0_158) AT=790.025n

.meas tran vdout0_159ck1570 FIND v(dout0_159) AT=790.025n

.meas tran vdout0_160ck1570 FIND v(dout0_160) AT=790.025n

.meas tran vdout0_161ck1570 FIND v(dout0_161) AT=790.025n

.meas tran vdout0_162ck1570 FIND v(dout0_162) AT=790.025n

.meas tran vdout0_163ck1570 FIND v(dout0_163) AT=790.025n

.meas tran vdout0_164ck1570 FIND v(dout0_164) AT=790.025n

.meas tran vdout0_165ck1570 FIND v(dout0_165) AT=790.025n

.meas tran vdout0_166ck1570 FIND v(dout0_166) AT=790.025n

.meas tran vdout0_167ck1570 FIND v(dout0_167) AT=790.025n

.meas tran vdout0_168ck1570 FIND v(dout0_168) AT=790.025n

.meas tran vdout0_169ck1570 FIND v(dout0_169) AT=790.025n

.meas tran vdout0_170ck1570 FIND v(dout0_170) AT=790.025n

.meas tran vdout0_171ck1570 FIND v(dout0_171) AT=790.025n

.meas tran vdout0_172ck1570 FIND v(dout0_172) AT=790.025n

.meas tran vdout0_173ck1570 FIND v(dout0_173) AT=790.025n

.meas tran vdout0_174ck1570 FIND v(dout0_174) AT=790.025n

.meas tran vdout0_175ck1570 FIND v(dout0_175) AT=790.025n

.meas tran vdout0_176ck1570 FIND v(dout0_176) AT=790.025n

.meas tran vdout0_177ck1570 FIND v(dout0_177) AT=790.025n

.meas tran vdout0_178ck1570 FIND v(dout0_178) AT=790.025n

.meas tran vdout0_179ck1570 FIND v(dout0_179) AT=790.025n

.meas tran vdout0_180ck1570 FIND v(dout0_180) AT=790.025n

.meas tran vdout0_181ck1570 FIND v(dout0_181) AT=790.025n

.meas tran vdout0_182ck1570 FIND v(dout0_182) AT=790.025n

.meas tran vdout0_183ck1570 FIND v(dout0_183) AT=790.025n

.meas tran vdout0_184ck1570 FIND v(dout0_184) AT=790.025n

.meas tran vdout0_185ck1570 FIND v(dout0_185) AT=790.025n

.meas tran vdout0_186ck1570 FIND v(dout0_186) AT=790.025n

.meas tran vdout0_187ck1570 FIND v(dout0_187) AT=790.025n

.meas tran vdout0_188ck1570 FIND v(dout0_188) AT=790.025n

.meas tran vdout0_189ck1570 FIND v(dout0_189) AT=790.025n

.meas tran vdout0_190ck1570 FIND v(dout0_190) AT=790.025n

.meas tran vdout0_191ck1570 FIND v(dout0_191) AT=790.025n

.meas tran vdout0_192ck1570 FIND v(dout0_192) AT=790.025n

.meas tran vdout0_193ck1570 FIND v(dout0_193) AT=790.025n

.meas tran vdout0_194ck1570 FIND v(dout0_194) AT=790.025n

.meas tran vdout0_195ck1570 FIND v(dout0_195) AT=790.025n

.meas tran vdout0_196ck1570 FIND v(dout0_196) AT=790.025n

.meas tran vdout0_197ck1570 FIND v(dout0_197) AT=790.025n

.meas tran vdout0_198ck1570 FIND v(dout0_198) AT=790.025n

.meas tran vdout0_199ck1570 FIND v(dout0_199) AT=790.025n

.meas tran vdout0_200ck1570 FIND v(dout0_200) AT=790.025n

.meas tran vdout0_201ck1570 FIND v(dout0_201) AT=790.025n

.meas tran vdout0_202ck1570 FIND v(dout0_202) AT=790.025n

.meas tran vdout0_203ck1570 FIND v(dout0_203) AT=790.025n

.meas tran vdout0_204ck1570 FIND v(dout0_204) AT=790.025n

.meas tran vdout0_205ck1570 FIND v(dout0_205) AT=790.025n

.meas tran vdout0_206ck1570 FIND v(dout0_206) AT=790.025n

.meas tran vdout0_207ck1570 FIND v(dout0_207) AT=790.025n

.meas tran vdout0_208ck1570 FIND v(dout0_208) AT=790.025n

.meas tran vdout0_209ck1570 FIND v(dout0_209) AT=790.025n

.meas tran vdout0_210ck1570 FIND v(dout0_210) AT=790.025n

.meas tran vdout0_211ck1570 FIND v(dout0_211) AT=790.025n

.meas tran vdout0_212ck1570 FIND v(dout0_212) AT=790.025n

.meas tran vdout0_213ck1570 FIND v(dout0_213) AT=790.025n

.meas tran vdout0_214ck1570 FIND v(dout0_214) AT=790.025n

.meas tran vdout0_215ck1570 FIND v(dout0_215) AT=790.025n

.meas tran vdout0_216ck1570 FIND v(dout0_216) AT=790.025n

.meas tran vdout0_217ck1570 FIND v(dout0_217) AT=790.025n

.meas tran vdout0_218ck1570 FIND v(dout0_218) AT=790.025n

.meas tran vdout0_219ck1570 FIND v(dout0_219) AT=790.025n

.meas tran vdout0_220ck1570 FIND v(dout0_220) AT=790.025n

.meas tran vdout0_221ck1570 FIND v(dout0_221) AT=790.025n

.meas tran vdout0_222ck1570 FIND v(dout0_222) AT=790.025n

.meas tran vdout0_223ck1570 FIND v(dout0_223) AT=790.025n

.meas tran vdout0_224ck1570 FIND v(dout0_224) AT=790.025n

.meas tran vdout0_225ck1570 FIND v(dout0_225) AT=790.025n

.meas tran vdout0_226ck1570 FIND v(dout0_226) AT=790.025n

.meas tran vdout0_227ck1570 FIND v(dout0_227) AT=790.025n

.meas tran vdout0_228ck1570 FIND v(dout0_228) AT=790.025n

.meas tran vdout0_229ck1570 FIND v(dout0_229) AT=790.025n

.meas tran vdout0_230ck1570 FIND v(dout0_230) AT=790.025n

.meas tran vdout0_231ck1570 FIND v(dout0_231) AT=790.025n

.meas tran vdout0_232ck1570 FIND v(dout0_232) AT=790.025n

.meas tran vdout0_233ck1570 FIND v(dout0_233) AT=790.025n

.meas tran vdout0_234ck1570 FIND v(dout0_234) AT=790.025n

.meas tran vdout0_235ck1570 FIND v(dout0_235) AT=790.025n

.meas tran vdout0_236ck1570 FIND v(dout0_236) AT=790.025n

.meas tran vdout0_237ck1570 FIND v(dout0_237) AT=790.025n

.meas tran vdout0_238ck1570 FIND v(dout0_238) AT=790.025n

.meas tran vdout0_239ck1570 FIND v(dout0_239) AT=790.025n

.meas tran vdout0_240ck1570 FIND v(dout0_240) AT=790.025n

.meas tran vdout0_241ck1570 FIND v(dout0_241) AT=790.025n

.meas tran vdout0_242ck1570 FIND v(dout0_242) AT=790.025n

.meas tran vdout0_243ck1570 FIND v(dout0_243) AT=790.025n

.meas tran vdout0_244ck1570 FIND v(dout0_244) AT=790.025n

.meas tran vdout0_245ck1570 FIND v(dout0_245) AT=790.025n

.meas tran vdout0_246ck1570 FIND v(dout0_246) AT=790.025n

.meas tran vdout0_247ck1570 FIND v(dout0_247) AT=790.025n

.meas tran vdout0_248ck1570 FIND v(dout0_248) AT=790.025n

.meas tran vdout0_249ck1570 FIND v(dout0_249) AT=790.025n

.meas tran vdout0_250ck1570 FIND v(dout0_250) AT=790.025n

.meas tran vdout0_251ck1570 FIND v(dout0_251) AT=790.025n

.meas tran vdout0_252ck1570 FIND v(dout0_252) AT=790.025n

.meas tran vdout0_253ck1570 FIND v(dout0_253) AT=790.025n

.meas tran vdout0_254ck1570 FIND v(dout0_254) AT=790.025n

.meas tran vdout0_255ck1570 FIND v(dout0_255) AT=790.025n

.meas tran vdout0_0ck1590 FIND v(dout0_0) AT=800.025n

.meas tran vdout0_1ck1590 FIND v(dout0_1) AT=800.025n

.meas tran vdout0_2ck1590 FIND v(dout0_2) AT=800.025n

.meas tran vdout0_3ck1590 FIND v(dout0_3) AT=800.025n

.meas tran vdout0_4ck1590 FIND v(dout0_4) AT=800.025n

.meas tran vdout0_5ck1590 FIND v(dout0_5) AT=800.025n

.meas tran vdout0_6ck1590 FIND v(dout0_6) AT=800.025n

.meas tran vdout0_7ck1590 FIND v(dout0_7) AT=800.025n

.meas tran vdout0_8ck1590 FIND v(dout0_8) AT=800.025n

.meas tran vdout0_9ck1590 FIND v(dout0_9) AT=800.025n

.meas tran vdout0_10ck1590 FIND v(dout0_10) AT=800.025n

.meas tran vdout0_11ck1590 FIND v(dout0_11) AT=800.025n

.meas tran vdout0_12ck1590 FIND v(dout0_12) AT=800.025n

.meas tran vdout0_13ck1590 FIND v(dout0_13) AT=800.025n

.meas tran vdout0_14ck1590 FIND v(dout0_14) AT=800.025n

.meas tran vdout0_15ck1590 FIND v(dout0_15) AT=800.025n

.meas tran vdout0_16ck1590 FIND v(dout0_16) AT=800.025n

.meas tran vdout0_17ck1590 FIND v(dout0_17) AT=800.025n

.meas tran vdout0_18ck1590 FIND v(dout0_18) AT=800.025n

.meas tran vdout0_19ck1590 FIND v(dout0_19) AT=800.025n

.meas tran vdout0_20ck1590 FIND v(dout0_20) AT=800.025n

.meas tran vdout0_21ck1590 FIND v(dout0_21) AT=800.025n

.meas tran vdout0_22ck1590 FIND v(dout0_22) AT=800.025n

.meas tran vdout0_23ck1590 FIND v(dout0_23) AT=800.025n

.meas tran vdout0_24ck1590 FIND v(dout0_24) AT=800.025n

.meas tran vdout0_25ck1590 FIND v(dout0_25) AT=800.025n

.meas tran vdout0_26ck1590 FIND v(dout0_26) AT=800.025n

.meas tran vdout0_27ck1590 FIND v(dout0_27) AT=800.025n

.meas tran vdout0_28ck1590 FIND v(dout0_28) AT=800.025n

.meas tran vdout0_29ck1590 FIND v(dout0_29) AT=800.025n

.meas tran vdout0_30ck1590 FIND v(dout0_30) AT=800.025n

.meas tran vdout0_31ck1590 FIND v(dout0_31) AT=800.025n

.meas tran vdout0_32ck1590 FIND v(dout0_32) AT=800.025n

.meas tran vdout0_33ck1590 FIND v(dout0_33) AT=800.025n

.meas tran vdout0_34ck1590 FIND v(dout0_34) AT=800.025n

.meas tran vdout0_35ck1590 FIND v(dout0_35) AT=800.025n

.meas tran vdout0_36ck1590 FIND v(dout0_36) AT=800.025n

.meas tran vdout0_37ck1590 FIND v(dout0_37) AT=800.025n

.meas tran vdout0_38ck1590 FIND v(dout0_38) AT=800.025n

.meas tran vdout0_39ck1590 FIND v(dout0_39) AT=800.025n

.meas tran vdout0_40ck1590 FIND v(dout0_40) AT=800.025n

.meas tran vdout0_41ck1590 FIND v(dout0_41) AT=800.025n

.meas tran vdout0_42ck1590 FIND v(dout0_42) AT=800.025n

.meas tran vdout0_43ck1590 FIND v(dout0_43) AT=800.025n

.meas tran vdout0_44ck1590 FIND v(dout0_44) AT=800.025n

.meas tran vdout0_45ck1590 FIND v(dout0_45) AT=800.025n

.meas tran vdout0_46ck1590 FIND v(dout0_46) AT=800.025n

.meas tran vdout0_47ck1590 FIND v(dout0_47) AT=800.025n

.meas tran vdout0_48ck1590 FIND v(dout0_48) AT=800.025n

.meas tran vdout0_49ck1590 FIND v(dout0_49) AT=800.025n

.meas tran vdout0_50ck1590 FIND v(dout0_50) AT=800.025n

.meas tran vdout0_51ck1590 FIND v(dout0_51) AT=800.025n

.meas tran vdout0_52ck1590 FIND v(dout0_52) AT=800.025n

.meas tran vdout0_53ck1590 FIND v(dout0_53) AT=800.025n

.meas tran vdout0_54ck1590 FIND v(dout0_54) AT=800.025n

.meas tran vdout0_55ck1590 FIND v(dout0_55) AT=800.025n

.meas tran vdout0_56ck1590 FIND v(dout0_56) AT=800.025n

.meas tran vdout0_57ck1590 FIND v(dout0_57) AT=800.025n

.meas tran vdout0_58ck1590 FIND v(dout0_58) AT=800.025n

.meas tran vdout0_59ck1590 FIND v(dout0_59) AT=800.025n

.meas tran vdout0_60ck1590 FIND v(dout0_60) AT=800.025n

.meas tran vdout0_61ck1590 FIND v(dout0_61) AT=800.025n

.meas tran vdout0_62ck1590 FIND v(dout0_62) AT=800.025n

.meas tran vdout0_63ck1590 FIND v(dout0_63) AT=800.025n

.meas tran vdout0_64ck1590 FIND v(dout0_64) AT=800.025n

.meas tran vdout0_65ck1590 FIND v(dout0_65) AT=800.025n

.meas tran vdout0_66ck1590 FIND v(dout0_66) AT=800.025n

.meas tran vdout0_67ck1590 FIND v(dout0_67) AT=800.025n

.meas tran vdout0_68ck1590 FIND v(dout0_68) AT=800.025n

.meas tran vdout0_69ck1590 FIND v(dout0_69) AT=800.025n

.meas tran vdout0_70ck1590 FIND v(dout0_70) AT=800.025n

.meas tran vdout0_71ck1590 FIND v(dout0_71) AT=800.025n

.meas tran vdout0_72ck1590 FIND v(dout0_72) AT=800.025n

.meas tran vdout0_73ck1590 FIND v(dout0_73) AT=800.025n

.meas tran vdout0_74ck1590 FIND v(dout0_74) AT=800.025n

.meas tran vdout0_75ck1590 FIND v(dout0_75) AT=800.025n

.meas tran vdout0_76ck1590 FIND v(dout0_76) AT=800.025n

.meas tran vdout0_77ck1590 FIND v(dout0_77) AT=800.025n

.meas tran vdout0_78ck1590 FIND v(dout0_78) AT=800.025n

.meas tran vdout0_79ck1590 FIND v(dout0_79) AT=800.025n

.meas tran vdout0_80ck1590 FIND v(dout0_80) AT=800.025n

.meas tran vdout0_81ck1590 FIND v(dout0_81) AT=800.025n

.meas tran vdout0_82ck1590 FIND v(dout0_82) AT=800.025n

.meas tran vdout0_83ck1590 FIND v(dout0_83) AT=800.025n

.meas tran vdout0_84ck1590 FIND v(dout0_84) AT=800.025n

.meas tran vdout0_85ck1590 FIND v(dout0_85) AT=800.025n

.meas tran vdout0_86ck1590 FIND v(dout0_86) AT=800.025n

.meas tran vdout0_87ck1590 FIND v(dout0_87) AT=800.025n

.meas tran vdout0_88ck1590 FIND v(dout0_88) AT=800.025n

.meas tran vdout0_89ck1590 FIND v(dout0_89) AT=800.025n

.meas tran vdout0_90ck1590 FIND v(dout0_90) AT=800.025n

.meas tran vdout0_91ck1590 FIND v(dout0_91) AT=800.025n

.meas tran vdout0_92ck1590 FIND v(dout0_92) AT=800.025n

.meas tran vdout0_93ck1590 FIND v(dout0_93) AT=800.025n

.meas tran vdout0_94ck1590 FIND v(dout0_94) AT=800.025n

.meas tran vdout0_95ck1590 FIND v(dout0_95) AT=800.025n

.meas tran vdout0_96ck1590 FIND v(dout0_96) AT=800.025n

.meas tran vdout0_97ck1590 FIND v(dout0_97) AT=800.025n

.meas tran vdout0_98ck1590 FIND v(dout0_98) AT=800.025n

.meas tran vdout0_99ck1590 FIND v(dout0_99) AT=800.025n

.meas tran vdout0_100ck1590 FIND v(dout0_100) AT=800.025n

.meas tran vdout0_101ck1590 FIND v(dout0_101) AT=800.025n

.meas tran vdout0_102ck1590 FIND v(dout0_102) AT=800.025n

.meas tran vdout0_103ck1590 FIND v(dout0_103) AT=800.025n

.meas tran vdout0_104ck1590 FIND v(dout0_104) AT=800.025n

.meas tran vdout0_105ck1590 FIND v(dout0_105) AT=800.025n

.meas tran vdout0_106ck1590 FIND v(dout0_106) AT=800.025n

.meas tran vdout0_107ck1590 FIND v(dout0_107) AT=800.025n

.meas tran vdout0_108ck1590 FIND v(dout0_108) AT=800.025n

.meas tran vdout0_109ck1590 FIND v(dout0_109) AT=800.025n

.meas tran vdout0_110ck1590 FIND v(dout0_110) AT=800.025n

.meas tran vdout0_111ck1590 FIND v(dout0_111) AT=800.025n

.meas tran vdout0_112ck1590 FIND v(dout0_112) AT=800.025n

.meas tran vdout0_113ck1590 FIND v(dout0_113) AT=800.025n

.meas tran vdout0_114ck1590 FIND v(dout0_114) AT=800.025n

.meas tran vdout0_115ck1590 FIND v(dout0_115) AT=800.025n

.meas tran vdout0_116ck1590 FIND v(dout0_116) AT=800.025n

.meas tran vdout0_117ck1590 FIND v(dout0_117) AT=800.025n

.meas tran vdout0_118ck1590 FIND v(dout0_118) AT=800.025n

.meas tran vdout0_119ck1590 FIND v(dout0_119) AT=800.025n

.meas tran vdout0_120ck1590 FIND v(dout0_120) AT=800.025n

.meas tran vdout0_121ck1590 FIND v(dout0_121) AT=800.025n

.meas tran vdout0_122ck1590 FIND v(dout0_122) AT=800.025n

.meas tran vdout0_123ck1590 FIND v(dout0_123) AT=800.025n

.meas tran vdout0_124ck1590 FIND v(dout0_124) AT=800.025n

.meas tran vdout0_125ck1590 FIND v(dout0_125) AT=800.025n

.meas tran vdout0_126ck1590 FIND v(dout0_126) AT=800.025n

.meas tran vdout0_127ck1590 FIND v(dout0_127) AT=800.025n

.meas tran vdout0_128ck1590 FIND v(dout0_128) AT=800.025n

.meas tran vdout0_129ck1590 FIND v(dout0_129) AT=800.025n

.meas tran vdout0_130ck1590 FIND v(dout0_130) AT=800.025n

.meas tran vdout0_131ck1590 FIND v(dout0_131) AT=800.025n

.meas tran vdout0_132ck1590 FIND v(dout0_132) AT=800.025n

.meas tran vdout0_133ck1590 FIND v(dout0_133) AT=800.025n

.meas tran vdout0_134ck1590 FIND v(dout0_134) AT=800.025n

.meas tran vdout0_135ck1590 FIND v(dout0_135) AT=800.025n

.meas tran vdout0_136ck1590 FIND v(dout0_136) AT=800.025n

.meas tran vdout0_137ck1590 FIND v(dout0_137) AT=800.025n

.meas tran vdout0_138ck1590 FIND v(dout0_138) AT=800.025n

.meas tran vdout0_139ck1590 FIND v(dout0_139) AT=800.025n

.meas tran vdout0_140ck1590 FIND v(dout0_140) AT=800.025n

.meas tran vdout0_141ck1590 FIND v(dout0_141) AT=800.025n

.meas tran vdout0_142ck1590 FIND v(dout0_142) AT=800.025n

.meas tran vdout0_143ck1590 FIND v(dout0_143) AT=800.025n

.meas tran vdout0_144ck1590 FIND v(dout0_144) AT=800.025n

.meas tran vdout0_145ck1590 FIND v(dout0_145) AT=800.025n

.meas tran vdout0_146ck1590 FIND v(dout0_146) AT=800.025n

.meas tran vdout0_147ck1590 FIND v(dout0_147) AT=800.025n

.meas tran vdout0_148ck1590 FIND v(dout0_148) AT=800.025n

.meas tran vdout0_149ck1590 FIND v(dout0_149) AT=800.025n

.meas tran vdout0_150ck1590 FIND v(dout0_150) AT=800.025n

.meas tran vdout0_151ck1590 FIND v(dout0_151) AT=800.025n

.meas tran vdout0_152ck1590 FIND v(dout0_152) AT=800.025n

.meas tran vdout0_153ck1590 FIND v(dout0_153) AT=800.025n

.meas tran vdout0_154ck1590 FIND v(dout0_154) AT=800.025n

.meas tran vdout0_155ck1590 FIND v(dout0_155) AT=800.025n

.meas tran vdout0_156ck1590 FIND v(dout0_156) AT=800.025n

.meas tran vdout0_157ck1590 FIND v(dout0_157) AT=800.025n

.meas tran vdout0_158ck1590 FIND v(dout0_158) AT=800.025n

.meas tran vdout0_159ck1590 FIND v(dout0_159) AT=800.025n

.meas tran vdout0_160ck1590 FIND v(dout0_160) AT=800.025n

.meas tran vdout0_161ck1590 FIND v(dout0_161) AT=800.025n

.meas tran vdout0_162ck1590 FIND v(dout0_162) AT=800.025n

.meas tran vdout0_163ck1590 FIND v(dout0_163) AT=800.025n

.meas tran vdout0_164ck1590 FIND v(dout0_164) AT=800.025n

.meas tran vdout0_165ck1590 FIND v(dout0_165) AT=800.025n

.meas tran vdout0_166ck1590 FIND v(dout0_166) AT=800.025n

.meas tran vdout0_167ck1590 FIND v(dout0_167) AT=800.025n

.meas tran vdout0_168ck1590 FIND v(dout0_168) AT=800.025n

.meas tran vdout0_169ck1590 FIND v(dout0_169) AT=800.025n

.meas tran vdout0_170ck1590 FIND v(dout0_170) AT=800.025n

.meas tran vdout0_171ck1590 FIND v(dout0_171) AT=800.025n

.meas tran vdout0_172ck1590 FIND v(dout0_172) AT=800.025n

.meas tran vdout0_173ck1590 FIND v(dout0_173) AT=800.025n

.meas tran vdout0_174ck1590 FIND v(dout0_174) AT=800.025n

.meas tran vdout0_175ck1590 FIND v(dout0_175) AT=800.025n

.meas tran vdout0_176ck1590 FIND v(dout0_176) AT=800.025n

.meas tran vdout0_177ck1590 FIND v(dout0_177) AT=800.025n

.meas tran vdout0_178ck1590 FIND v(dout0_178) AT=800.025n

.meas tran vdout0_179ck1590 FIND v(dout0_179) AT=800.025n

.meas tran vdout0_180ck1590 FIND v(dout0_180) AT=800.025n

.meas tran vdout0_181ck1590 FIND v(dout0_181) AT=800.025n

.meas tran vdout0_182ck1590 FIND v(dout0_182) AT=800.025n

.meas tran vdout0_183ck1590 FIND v(dout0_183) AT=800.025n

.meas tran vdout0_184ck1590 FIND v(dout0_184) AT=800.025n

.meas tran vdout0_185ck1590 FIND v(dout0_185) AT=800.025n

.meas tran vdout0_186ck1590 FIND v(dout0_186) AT=800.025n

.meas tran vdout0_187ck1590 FIND v(dout0_187) AT=800.025n

.meas tran vdout0_188ck1590 FIND v(dout0_188) AT=800.025n

.meas tran vdout0_189ck1590 FIND v(dout0_189) AT=800.025n

.meas tran vdout0_190ck1590 FIND v(dout0_190) AT=800.025n

.meas tran vdout0_191ck1590 FIND v(dout0_191) AT=800.025n

.meas tran vdout0_192ck1590 FIND v(dout0_192) AT=800.025n

.meas tran vdout0_193ck1590 FIND v(dout0_193) AT=800.025n

.meas tran vdout0_194ck1590 FIND v(dout0_194) AT=800.025n

.meas tran vdout0_195ck1590 FIND v(dout0_195) AT=800.025n

.meas tran vdout0_196ck1590 FIND v(dout0_196) AT=800.025n

.meas tran vdout0_197ck1590 FIND v(dout0_197) AT=800.025n

.meas tran vdout0_198ck1590 FIND v(dout0_198) AT=800.025n

.meas tran vdout0_199ck1590 FIND v(dout0_199) AT=800.025n

.meas tran vdout0_200ck1590 FIND v(dout0_200) AT=800.025n

.meas tran vdout0_201ck1590 FIND v(dout0_201) AT=800.025n

.meas tran vdout0_202ck1590 FIND v(dout0_202) AT=800.025n

.meas tran vdout0_203ck1590 FIND v(dout0_203) AT=800.025n

.meas tran vdout0_204ck1590 FIND v(dout0_204) AT=800.025n

.meas tran vdout0_205ck1590 FIND v(dout0_205) AT=800.025n

.meas tran vdout0_206ck1590 FIND v(dout0_206) AT=800.025n

.meas tran vdout0_207ck1590 FIND v(dout0_207) AT=800.025n

.meas tran vdout0_208ck1590 FIND v(dout0_208) AT=800.025n

.meas tran vdout0_209ck1590 FIND v(dout0_209) AT=800.025n

.meas tran vdout0_210ck1590 FIND v(dout0_210) AT=800.025n

.meas tran vdout0_211ck1590 FIND v(dout0_211) AT=800.025n

.meas tran vdout0_212ck1590 FIND v(dout0_212) AT=800.025n

.meas tran vdout0_213ck1590 FIND v(dout0_213) AT=800.025n

.meas tran vdout0_214ck1590 FIND v(dout0_214) AT=800.025n

.meas tran vdout0_215ck1590 FIND v(dout0_215) AT=800.025n

.meas tran vdout0_216ck1590 FIND v(dout0_216) AT=800.025n

.meas tran vdout0_217ck1590 FIND v(dout0_217) AT=800.025n

.meas tran vdout0_218ck1590 FIND v(dout0_218) AT=800.025n

.meas tran vdout0_219ck1590 FIND v(dout0_219) AT=800.025n

.meas tran vdout0_220ck1590 FIND v(dout0_220) AT=800.025n

.meas tran vdout0_221ck1590 FIND v(dout0_221) AT=800.025n

.meas tran vdout0_222ck1590 FIND v(dout0_222) AT=800.025n

.meas tran vdout0_223ck1590 FIND v(dout0_223) AT=800.025n

.meas tran vdout0_224ck1590 FIND v(dout0_224) AT=800.025n

.meas tran vdout0_225ck1590 FIND v(dout0_225) AT=800.025n

.meas tran vdout0_226ck1590 FIND v(dout0_226) AT=800.025n

.meas tran vdout0_227ck1590 FIND v(dout0_227) AT=800.025n

.meas tran vdout0_228ck1590 FIND v(dout0_228) AT=800.025n

.meas tran vdout0_229ck1590 FIND v(dout0_229) AT=800.025n

.meas tran vdout0_230ck1590 FIND v(dout0_230) AT=800.025n

.meas tran vdout0_231ck1590 FIND v(dout0_231) AT=800.025n

.meas tran vdout0_232ck1590 FIND v(dout0_232) AT=800.025n

.meas tran vdout0_233ck1590 FIND v(dout0_233) AT=800.025n

.meas tran vdout0_234ck1590 FIND v(dout0_234) AT=800.025n

.meas tran vdout0_235ck1590 FIND v(dout0_235) AT=800.025n

.meas tran vdout0_236ck1590 FIND v(dout0_236) AT=800.025n

.meas tran vdout0_237ck1590 FIND v(dout0_237) AT=800.025n

.meas tran vdout0_238ck1590 FIND v(dout0_238) AT=800.025n

.meas tran vdout0_239ck1590 FIND v(dout0_239) AT=800.025n

.meas tran vdout0_240ck1590 FIND v(dout0_240) AT=800.025n

.meas tran vdout0_241ck1590 FIND v(dout0_241) AT=800.025n

.meas tran vdout0_242ck1590 FIND v(dout0_242) AT=800.025n

.meas tran vdout0_243ck1590 FIND v(dout0_243) AT=800.025n

.meas tran vdout0_244ck1590 FIND v(dout0_244) AT=800.025n

.meas tran vdout0_245ck1590 FIND v(dout0_245) AT=800.025n

.meas tran vdout0_246ck1590 FIND v(dout0_246) AT=800.025n

.meas tran vdout0_247ck1590 FIND v(dout0_247) AT=800.025n

.meas tran vdout0_248ck1590 FIND v(dout0_248) AT=800.025n

.meas tran vdout0_249ck1590 FIND v(dout0_249) AT=800.025n

.meas tran vdout0_250ck1590 FIND v(dout0_250) AT=800.025n

.meas tran vdout0_251ck1590 FIND v(dout0_251) AT=800.025n

.meas tran vdout0_252ck1590 FIND v(dout0_252) AT=800.025n

.meas tran vdout0_253ck1590 FIND v(dout0_253) AT=800.025n

.meas tran vdout0_254ck1590 FIND v(dout0_254) AT=800.025n

.meas tran vdout0_255ck1590 FIND v(dout0_255) AT=800.025n

.meas tran vdout0_0ck1720 FIND v(dout0_0) AT=865.025n

.meas tran vdout0_1ck1720 FIND v(dout0_1) AT=865.025n

.meas tran vdout0_2ck1720 FIND v(dout0_2) AT=865.025n

.meas tran vdout0_3ck1720 FIND v(dout0_3) AT=865.025n

.meas tran vdout0_4ck1720 FIND v(dout0_4) AT=865.025n

.meas tran vdout0_5ck1720 FIND v(dout0_5) AT=865.025n

.meas tran vdout0_6ck1720 FIND v(dout0_6) AT=865.025n

.meas tran vdout0_7ck1720 FIND v(dout0_7) AT=865.025n

.meas tran vdout0_8ck1720 FIND v(dout0_8) AT=865.025n

.meas tran vdout0_9ck1720 FIND v(dout0_9) AT=865.025n

.meas tran vdout0_10ck1720 FIND v(dout0_10) AT=865.025n

.meas tran vdout0_11ck1720 FIND v(dout0_11) AT=865.025n

.meas tran vdout0_12ck1720 FIND v(dout0_12) AT=865.025n

.meas tran vdout0_13ck1720 FIND v(dout0_13) AT=865.025n

.meas tran vdout0_14ck1720 FIND v(dout0_14) AT=865.025n

.meas tran vdout0_15ck1720 FIND v(dout0_15) AT=865.025n

.meas tran vdout0_16ck1720 FIND v(dout0_16) AT=865.025n

.meas tran vdout0_17ck1720 FIND v(dout0_17) AT=865.025n

.meas tran vdout0_18ck1720 FIND v(dout0_18) AT=865.025n

.meas tran vdout0_19ck1720 FIND v(dout0_19) AT=865.025n

.meas tran vdout0_20ck1720 FIND v(dout0_20) AT=865.025n

.meas tran vdout0_21ck1720 FIND v(dout0_21) AT=865.025n

.meas tran vdout0_22ck1720 FIND v(dout0_22) AT=865.025n

.meas tran vdout0_23ck1720 FIND v(dout0_23) AT=865.025n

.meas tran vdout0_24ck1720 FIND v(dout0_24) AT=865.025n

.meas tran vdout0_25ck1720 FIND v(dout0_25) AT=865.025n

.meas tran vdout0_26ck1720 FIND v(dout0_26) AT=865.025n

.meas tran vdout0_27ck1720 FIND v(dout0_27) AT=865.025n

.meas tran vdout0_28ck1720 FIND v(dout0_28) AT=865.025n

.meas tran vdout0_29ck1720 FIND v(dout0_29) AT=865.025n

.meas tran vdout0_30ck1720 FIND v(dout0_30) AT=865.025n

.meas tran vdout0_31ck1720 FIND v(dout0_31) AT=865.025n

.meas tran vdout0_32ck1720 FIND v(dout0_32) AT=865.025n

.meas tran vdout0_33ck1720 FIND v(dout0_33) AT=865.025n

.meas tran vdout0_34ck1720 FIND v(dout0_34) AT=865.025n

.meas tran vdout0_35ck1720 FIND v(dout0_35) AT=865.025n

.meas tran vdout0_36ck1720 FIND v(dout0_36) AT=865.025n

.meas tran vdout0_37ck1720 FIND v(dout0_37) AT=865.025n

.meas tran vdout0_38ck1720 FIND v(dout0_38) AT=865.025n

.meas tran vdout0_39ck1720 FIND v(dout0_39) AT=865.025n

.meas tran vdout0_40ck1720 FIND v(dout0_40) AT=865.025n

.meas tran vdout0_41ck1720 FIND v(dout0_41) AT=865.025n

.meas tran vdout0_42ck1720 FIND v(dout0_42) AT=865.025n

.meas tran vdout0_43ck1720 FIND v(dout0_43) AT=865.025n

.meas tran vdout0_44ck1720 FIND v(dout0_44) AT=865.025n

.meas tran vdout0_45ck1720 FIND v(dout0_45) AT=865.025n

.meas tran vdout0_46ck1720 FIND v(dout0_46) AT=865.025n

.meas tran vdout0_47ck1720 FIND v(dout0_47) AT=865.025n

.meas tran vdout0_48ck1720 FIND v(dout0_48) AT=865.025n

.meas tran vdout0_49ck1720 FIND v(dout0_49) AT=865.025n

.meas tran vdout0_50ck1720 FIND v(dout0_50) AT=865.025n

.meas tran vdout0_51ck1720 FIND v(dout0_51) AT=865.025n

.meas tran vdout0_52ck1720 FIND v(dout0_52) AT=865.025n

.meas tran vdout0_53ck1720 FIND v(dout0_53) AT=865.025n

.meas tran vdout0_54ck1720 FIND v(dout0_54) AT=865.025n

.meas tran vdout0_55ck1720 FIND v(dout0_55) AT=865.025n

.meas tran vdout0_56ck1720 FIND v(dout0_56) AT=865.025n

.meas tran vdout0_57ck1720 FIND v(dout0_57) AT=865.025n

.meas tran vdout0_58ck1720 FIND v(dout0_58) AT=865.025n

.meas tran vdout0_59ck1720 FIND v(dout0_59) AT=865.025n

.meas tran vdout0_60ck1720 FIND v(dout0_60) AT=865.025n

.meas tran vdout0_61ck1720 FIND v(dout0_61) AT=865.025n

.meas tran vdout0_62ck1720 FIND v(dout0_62) AT=865.025n

.meas tran vdout0_63ck1720 FIND v(dout0_63) AT=865.025n

.meas tran vdout0_64ck1720 FIND v(dout0_64) AT=865.025n

.meas tran vdout0_65ck1720 FIND v(dout0_65) AT=865.025n

.meas tran vdout0_66ck1720 FIND v(dout0_66) AT=865.025n

.meas tran vdout0_67ck1720 FIND v(dout0_67) AT=865.025n

.meas tran vdout0_68ck1720 FIND v(dout0_68) AT=865.025n

.meas tran vdout0_69ck1720 FIND v(dout0_69) AT=865.025n

.meas tran vdout0_70ck1720 FIND v(dout0_70) AT=865.025n

.meas tran vdout0_71ck1720 FIND v(dout0_71) AT=865.025n

.meas tran vdout0_72ck1720 FIND v(dout0_72) AT=865.025n

.meas tran vdout0_73ck1720 FIND v(dout0_73) AT=865.025n

.meas tran vdout0_74ck1720 FIND v(dout0_74) AT=865.025n

.meas tran vdout0_75ck1720 FIND v(dout0_75) AT=865.025n

.meas tran vdout0_76ck1720 FIND v(dout0_76) AT=865.025n

.meas tran vdout0_77ck1720 FIND v(dout0_77) AT=865.025n

.meas tran vdout0_78ck1720 FIND v(dout0_78) AT=865.025n

.meas tran vdout0_79ck1720 FIND v(dout0_79) AT=865.025n

.meas tran vdout0_80ck1720 FIND v(dout0_80) AT=865.025n

.meas tran vdout0_81ck1720 FIND v(dout0_81) AT=865.025n

.meas tran vdout0_82ck1720 FIND v(dout0_82) AT=865.025n

.meas tran vdout0_83ck1720 FIND v(dout0_83) AT=865.025n

.meas tran vdout0_84ck1720 FIND v(dout0_84) AT=865.025n

.meas tran vdout0_85ck1720 FIND v(dout0_85) AT=865.025n

.meas tran vdout0_86ck1720 FIND v(dout0_86) AT=865.025n

.meas tran vdout0_87ck1720 FIND v(dout0_87) AT=865.025n

.meas tran vdout0_88ck1720 FIND v(dout0_88) AT=865.025n

.meas tran vdout0_89ck1720 FIND v(dout0_89) AT=865.025n

.meas tran vdout0_90ck1720 FIND v(dout0_90) AT=865.025n

.meas tran vdout0_91ck1720 FIND v(dout0_91) AT=865.025n

.meas tran vdout0_92ck1720 FIND v(dout0_92) AT=865.025n

.meas tran vdout0_93ck1720 FIND v(dout0_93) AT=865.025n

.meas tran vdout0_94ck1720 FIND v(dout0_94) AT=865.025n

.meas tran vdout0_95ck1720 FIND v(dout0_95) AT=865.025n

.meas tran vdout0_96ck1720 FIND v(dout0_96) AT=865.025n

.meas tran vdout0_97ck1720 FIND v(dout0_97) AT=865.025n

.meas tran vdout0_98ck1720 FIND v(dout0_98) AT=865.025n

.meas tran vdout0_99ck1720 FIND v(dout0_99) AT=865.025n

.meas tran vdout0_100ck1720 FIND v(dout0_100) AT=865.025n

.meas tran vdout0_101ck1720 FIND v(dout0_101) AT=865.025n

.meas tran vdout0_102ck1720 FIND v(dout0_102) AT=865.025n

.meas tran vdout0_103ck1720 FIND v(dout0_103) AT=865.025n

.meas tran vdout0_104ck1720 FIND v(dout0_104) AT=865.025n

.meas tran vdout0_105ck1720 FIND v(dout0_105) AT=865.025n

.meas tran vdout0_106ck1720 FIND v(dout0_106) AT=865.025n

.meas tran vdout0_107ck1720 FIND v(dout0_107) AT=865.025n

.meas tran vdout0_108ck1720 FIND v(dout0_108) AT=865.025n

.meas tran vdout0_109ck1720 FIND v(dout0_109) AT=865.025n

.meas tran vdout0_110ck1720 FIND v(dout0_110) AT=865.025n

.meas tran vdout0_111ck1720 FIND v(dout0_111) AT=865.025n

.meas tran vdout0_112ck1720 FIND v(dout0_112) AT=865.025n

.meas tran vdout0_113ck1720 FIND v(dout0_113) AT=865.025n

.meas tran vdout0_114ck1720 FIND v(dout0_114) AT=865.025n

.meas tran vdout0_115ck1720 FIND v(dout0_115) AT=865.025n

.meas tran vdout0_116ck1720 FIND v(dout0_116) AT=865.025n

.meas tran vdout0_117ck1720 FIND v(dout0_117) AT=865.025n

.meas tran vdout0_118ck1720 FIND v(dout0_118) AT=865.025n

.meas tran vdout0_119ck1720 FIND v(dout0_119) AT=865.025n

.meas tran vdout0_120ck1720 FIND v(dout0_120) AT=865.025n

.meas tran vdout0_121ck1720 FIND v(dout0_121) AT=865.025n

.meas tran vdout0_122ck1720 FIND v(dout0_122) AT=865.025n

.meas tran vdout0_123ck1720 FIND v(dout0_123) AT=865.025n

.meas tran vdout0_124ck1720 FIND v(dout0_124) AT=865.025n

.meas tran vdout0_125ck1720 FIND v(dout0_125) AT=865.025n

.meas tran vdout0_126ck1720 FIND v(dout0_126) AT=865.025n

.meas tran vdout0_127ck1720 FIND v(dout0_127) AT=865.025n

.meas tran vdout0_128ck1720 FIND v(dout0_128) AT=865.025n

.meas tran vdout0_129ck1720 FIND v(dout0_129) AT=865.025n

.meas tran vdout0_130ck1720 FIND v(dout0_130) AT=865.025n

.meas tran vdout0_131ck1720 FIND v(dout0_131) AT=865.025n

.meas tran vdout0_132ck1720 FIND v(dout0_132) AT=865.025n

.meas tran vdout0_133ck1720 FIND v(dout0_133) AT=865.025n

.meas tran vdout0_134ck1720 FIND v(dout0_134) AT=865.025n

.meas tran vdout0_135ck1720 FIND v(dout0_135) AT=865.025n

.meas tran vdout0_136ck1720 FIND v(dout0_136) AT=865.025n

.meas tran vdout0_137ck1720 FIND v(dout0_137) AT=865.025n

.meas tran vdout0_138ck1720 FIND v(dout0_138) AT=865.025n

.meas tran vdout0_139ck1720 FIND v(dout0_139) AT=865.025n

.meas tran vdout0_140ck1720 FIND v(dout0_140) AT=865.025n

.meas tran vdout0_141ck1720 FIND v(dout0_141) AT=865.025n

.meas tran vdout0_142ck1720 FIND v(dout0_142) AT=865.025n

.meas tran vdout0_143ck1720 FIND v(dout0_143) AT=865.025n

.meas tran vdout0_144ck1720 FIND v(dout0_144) AT=865.025n

.meas tran vdout0_145ck1720 FIND v(dout0_145) AT=865.025n

.meas tran vdout0_146ck1720 FIND v(dout0_146) AT=865.025n

.meas tran vdout0_147ck1720 FIND v(dout0_147) AT=865.025n

.meas tran vdout0_148ck1720 FIND v(dout0_148) AT=865.025n

.meas tran vdout0_149ck1720 FIND v(dout0_149) AT=865.025n

.meas tran vdout0_150ck1720 FIND v(dout0_150) AT=865.025n

.meas tran vdout0_151ck1720 FIND v(dout0_151) AT=865.025n

.meas tran vdout0_152ck1720 FIND v(dout0_152) AT=865.025n

.meas tran vdout0_153ck1720 FIND v(dout0_153) AT=865.025n

.meas tran vdout0_154ck1720 FIND v(dout0_154) AT=865.025n

.meas tran vdout0_155ck1720 FIND v(dout0_155) AT=865.025n

.meas tran vdout0_156ck1720 FIND v(dout0_156) AT=865.025n

.meas tran vdout0_157ck1720 FIND v(dout0_157) AT=865.025n

.meas tran vdout0_158ck1720 FIND v(dout0_158) AT=865.025n

.meas tran vdout0_159ck1720 FIND v(dout0_159) AT=865.025n

.meas tran vdout0_160ck1720 FIND v(dout0_160) AT=865.025n

.meas tran vdout0_161ck1720 FIND v(dout0_161) AT=865.025n

.meas tran vdout0_162ck1720 FIND v(dout0_162) AT=865.025n

.meas tran vdout0_163ck1720 FIND v(dout0_163) AT=865.025n

.meas tran vdout0_164ck1720 FIND v(dout0_164) AT=865.025n

.meas tran vdout0_165ck1720 FIND v(dout0_165) AT=865.025n

.meas tran vdout0_166ck1720 FIND v(dout0_166) AT=865.025n

.meas tran vdout0_167ck1720 FIND v(dout0_167) AT=865.025n

.meas tran vdout0_168ck1720 FIND v(dout0_168) AT=865.025n

.meas tran vdout0_169ck1720 FIND v(dout0_169) AT=865.025n

.meas tran vdout0_170ck1720 FIND v(dout0_170) AT=865.025n

.meas tran vdout0_171ck1720 FIND v(dout0_171) AT=865.025n

.meas tran vdout0_172ck1720 FIND v(dout0_172) AT=865.025n

.meas tran vdout0_173ck1720 FIND v(dout0_173) AT=865.025n

.meas tran vdout0_174ck1720 FIND v(dout0_174) AT=865.025n

.meas tran vdout0_175ck1720 FIND v(dout0_175) AT=865.025n

.meas tran vdout0_176ck1720 FIND v(dout0_176) AT=865.025n

.meas tran vdout0_177ck1720 FIND v(dout0_177) AT=865.025n

.meas tran vdout0_178ck1720 FIND v(dout0_178) AT=865.025n

.meas tran vdout0_179ck1720 FIND v(dout0_179) AT=865.025n

.meas tran vdout0_180ck1720 FIND v(dout0_180) AT=865.025n

.meas tran vdout0_181ck1720 FIND v(dout0_181) AT=865.025n

.meas tran vdout0_182ck1720 FIND v(dout0_182) AT=865.025n

.meas tran vdout0_183ck1720 FIND v(dout0_183) AT=865.025n

.meas tran vdout0_184ck1720 FIND v(dout0_184) AT=865.025n

.meas tran vdout0_185ck1720 FIND v(dout0_185) AT=865.025n

.meas tran vdout0_186ck1720 FIND v(dout0_186) AT=865.025n

.meas tran vdout0_187ck1720 FIND v(dout0_187) AT=865.025n

.meas tran vdout0_188ck1720 FIND v(dout0_188) AT=865.025n

.meas tran vdout0_189ck1720 FIND v(dout0_189) AT=865.025n

.meas tran vdout0_190ck1720 FIND v(dout0_190) AT=865.025n

.meas tran vdout0_191ck1720 FIND v(dout0_191) AT=865.025n

.meas tran vdout0_192ck1720 FIND v(dout0_192) AT=865.025n

.meas tran vdout0_193ck1720 FIND v(dout0_193) AT=865.025n

.meas tran vdout0_194ck1720 FIND v(dout0_194) AT=865.025n

.meas tran vdout0_195ck1720 FIND v(dout0_195) AT=865.025n

.meas tran vdout0_196ck1720 FIND v(dout0_196) AT=865.025n

.meas tran vdout0_197ck1720 FIND v(dout0_197) AT=865.025n

.meas tran vdout0_198ck1720 FIND v(dout0_198) AT=865.025n

.meas tran vdout0_199ck1720 FIND v(dout0_199) AT=865.025n

.meas tran vdout0_200ck1720 FIND v(dout0_200) AT=865.025n

.meas tran vdout0_201ck1720 FIND v(dout0_201) AT=865.025n

.meas tran vdout0_202ck1720 FIND v(dout0_202) AT=865.025n

.meas tran vdout0_203ck1720 FIND v(dout0_203) AT=865.025n

.meas tran vdout0_204ck1720 FIND v(dout0_204) AT=865.025n

.meas tran vdout0_205ck1720 FIND v(dout0_205) AT=865.025n

.meas tran vdout0_206ck1720 FIND v(dout0_206) AT=865.025n

.meas tran vdout0_207ck1720 FIND v(dout0_207) AT=865.025n

.meas tran vdout0_208ck1720 FIND v(dout0_208) AT=865.025n

.meas tran vdout0_209ck1720 FIND v(dout0_209) AT=865.025n

.meas tran vdout0_210ck1720 FIND v(dout0_210) AT=865.025n

.meas tran vdout0_211ck1720 FIND v(dout0_211) AT=865.025n

.meas tran vdout0_212ck1720 FIND v(dout0_212) AT=865.025n

.meas tran vdout0_213ck1720 FIND v(dout0_213) AT=865.025n

.meas tran vdout0_214ck1720 FIND v(dout0_214) AT=865.025n

.meas tran vdout0_215ck1720 FIND v(dout0_215) AT=865.025n

.meas tran vdout0_216ck1720 FIND v(dout0_216) AT=865.025n

.meas tran vdout0_217ck1720 FIND v(dout0_217) AT=865.025n

.meas tran vdout0_218ck1720 FIND v(dout0_218) AT=865.025n

.meas tran vdout0_219ck1720 FIND v(dout0_219) AT=865.025n

.meas tran vdout0_220ck1720 FIND v(dout0_220) AT=865.025n

.meas tran vdout0_221ck1720 FIND v(dout0_221) AT=865.025n

.meas tran vdout0_222ck1720 FIND v(dout0_222) AT=865.025n

.meas tran vdout0_223ck1720 FIND v(dout0_223) AT=865.025n

.meas tran vdout0_224ck1720 FIND v(dout0_224) AT=865.025n

.meas tran vdout0_225ck1720 FIND v(dout0_225) AT=865.025n

.meas tran vdout0_226ck1720 FIND v(dout0_226) AT=865.025n

.meas tran vdout0_227ck1720 FIND v(dout0_227) AT=865.025n

.meas tran vdout0_228ck1720 FIND v(dout0_228) AT=865.025n

.meas tran vdout0_229ck1720 FIND v(dout0_229) AT=865.025n

.meas tran vdout0_230ck1720 FIND v(dout0_230) AT=865.025n

.meas tran vdout0_231ck1720 FIND v(dout0_231) AT=865.025n

.meas tran vdout0_232ck1720 FIND v(dout0_232) AT=865.025n

.meas tran vdout0_233ck1720 FIND v(dout0_233) AT=865.025n

.meas tran vdout0_234ck1720 FIND v(dout0_234) AT=865.025n

.meas tran vdout0_235ck1720 FIND v(dout0_235) AT=865.025n

.meas tran vdout0_236ck1720 FIND v(dout0_236) AT=865.025n

.meas tran vdout0_237ck1720 FIND v(dout0_237) AT=865.025n

.meas tran vdout0_238ck1720 FIND v(dout0_238) AT=865.025n

.meas tran vdout0_239ck1720 FIND v(dout0_239) AT=865.025n

.meas tran vdout0_240ck1720 FIND v(dout0_240) AT=865.025n

.meas tran vdout0_241ck1720 FIND v(dout0_241) AT=865.025n

.meas tran vdout0_242ck1720 FIND v(dout0_242) AT=865.025n

.meas tran vdout0_243ck1720 FIND v(dout0_243) AT=865.025n

.meas tran vdout0_244ck1720 FIND v(dout0_244) AT=865.025n

.meas tran vdout0_245ck1720 FIND v(dout0_245) AT=865.025n

.meas tran vdout0_246ck1720 FIND v(dout0_246) AT=865.025n

.meas tran vdout0_247ck1720 FIND v(dout0_247) AT=865.025n

.meas tran vdout0_248ck1720 FIND v(dout0_248) AT=865.025n

.meas tran vdout0_249ck1720 FIND v(dout0_249) AT=865.025n

.meas tran vdout0_250ck1720 FIND v(dout0_250) AT=865.025n

.meas tran vdout0_251ck1720 FIND v(dout0_251) AT=865.025n

.meas tran vdout0_252ck1720 FIND v(dout0_252) AT=865.025n

.meas tran vdout0_253ck1720 FIND v(dout0_253) AT=865.025n

.meas tran vdout0_254ck1720 FIND v(dout0_254) AT=865.025n

.meas tran vdout0_255ck1720 FIND v(dout0_255) AT=865.025n

.meas tran vdout0_0ck1730 FIND v(dout0_0) AT=870.025n

.meas tran vdout0_1ck1730 FIND v(dout0_1) AT=870.025n

.meas tran vdout0_2ck1730 FIND v(dout0_2) AT=870.025n

.meas tran vdout0_3ck1730 FIND v(dout0_3) AT=870.025n

.meas tran vdout0_4ck1730 FIND v(dout0_4) AT=870.025n

.meas tran vdout0_5ck1730 FIND v(dout0_5) AT=870.025n

.meas tran vdout0_6ck1730 FIND v(dout0_6) AT=870.025n

.meas tran vdout0_7ck1730 FIND v(dout0_7) AT=870.025n

.meas tran vdout0_8ck1730 FIND v(dout0_8) AT=870.025n

.meas tran vdout0_9ck1730 FIND v(dout0_9) AT=870.025n

.meas tran vdout0_10ck1730 FIND v(dout0_10) AT=870.025n

.meas tran vdout0_11ck1730 FIND v(dout0_11) AT=870.025n

.meas tran vdout0_12ck1730 FIND v(dout0_12) AT=870.025n

.meas tran vdout0_13ck1730 FIND v(dout0_13) AT=870.025n

.meas tran vdout0_14ck1730 FIND v(dout0_14) AT=870.025n

.meas tran vdout0_15ck1730 FIND v(dout0_15) AT=870.025n

.meas tran vdout0_16ck1730 FIND v(dout0_16) AT=870.025n

.meas tran vdout0_17ck1730 FIND v(dout0_17) AT=870.025n

.meas tran vdout0_18ck1730 FIND v(dout0_18) AT=870.025n

.meas tran vdout0_19ck1730 FIND v(dout0_19) AT=870.025n

.meas tran vdout0_20ck1730 FIND v(dout0_20) AT=870.025n

.meas tran vdout0_21ck1730 FIND v(dout0_21) AT=870.025n

.meas tran vdout0_22ck1730 FIND v(dout0_22) AT=870.025n

.meas tran vdout0_23ck1730 FIND v(dout0_23) AT=870.025n

.meas tran vdout0_24ck1730 FIND v(dout0_24) AT=870.025n

.meas tran vdout0_25ck1730 FIND v(dout0_25) AT=870.025n

.meas tran vdout0_26ck1730 FIND v(dout0_26) AT=870.025n

.meas tran vdout0_27ck1730 FIND v(dout0_27) AT=870.025n

.meas tran vdout0_28ck1730 FIND v(dout0_28) AT=870.025n

.meas tran vdout0_29ck1730 FIND v(dout0_29) AT=870.025n

.meas tran vdout0_30ck1730 FIND v(dout0_30) AT=870.025n

.meas tran vdout0_31ck1730 FIND v(dout0_31) AT=870.025n

.meas tran vdout0_32ck1730 FIND v(dout0_32) AT=870.025n

.meas tran vdout0_33ck1730 FIND v(dout0_33) AT=870.025n

.meas tran vdout0_34ck1730 FIND v(dout0_34) AT=870.025n

.meas tran vdout0_35ck1730 FIND v(dout0_35) AT=870.025n

.meas tran vdout0_36ck1730 FIND v(dout0_36) AT=870.025n

.meas tran vdout0_37ck1730 FIND v(dout0_37) AT=870.025n

.meas tran vdout0_38ck1730 FIND v(dout0_38) AT=870.025n

.meas tran vdout0_39ck1730 FIND v(dout0_39) AT=870.025n

.meas tran vdout0_40ck1730 FIND v(dout0_40) AT=870.025n

.meas tran vdout0_41ck1730 FIND v(dout0_41) AT=870.025n

.meas tran vdout0_42ck1730 FIND v(dout0_42) AT=870.025n

.meas tran vdout0_43ck1730 FIND v(dout0_43) AT=870.025n

.meas tran vdout0_44ck1730 FIND v(dout0_44) AT=870.025n

.meas tran vdout0_45ck1730 FIND v(dout0_45) AT=870.025n

.meas tran vdout0_46ck1730 FIND v(dout0_46) AT=870.025n

.meas tran vdout0_47ck1730 FIND v(dout0_47) AT=870.025n

.meas tran vdout0_48ck1730 FIND v(dout0_48) AT=870.025n

.meas tran vdout0_49ck1730 FIND v(dout0_49) AT=870.025n

.meas tran vdout0_50ck1730 FIND v(dout0_50) AT=870.025n

.meas tran vdout0_51ck1730 FIND v(dout0_51) AT=870.025n

.meas tran vdout0_52ck1730 FIND v(dout0_52) AT=870.025n

.meas tran vdout0_53ck1730 FIND v(dout0_53) AT=870.025n

.meas tran vdout0_54ck1730 FIND v(dout0_54) AT=870.025n

.meas tran vdout0_55ck1730 FIND v(dout0_55) AT=870.025n

.meas tran vdout0_56ck1730 FIND v(dout0_56) AT=870.025n

.meas tran vdout0_57ck1730 FIND v(dout0_57) AT=870.025n

.meas tran vdout0_58ck1730 FIND v(dout0_58) AT=870.025n

.meas tran vdout0_59ck1730 FIND v(dout0_59) AT=870.025n

.meas tran vdout0_60ck1730 FIND v(dout0_60) AT=870.025n

.meas tran vdout0_61ck1730 FIND v(dout0_61) AT=870.025n

.meas tran vdout0_62ck1730 FIND v(dout0_62) AT=870.025n

.meas tran vdout0_63ck1730 FIND v(dout0_63) AT=870.025n

.meas tran vdout0_64ck1730 FIND v(dout0_64) AT=870.025n

.meas tran vdout0_65ck1730 FIND v(dout0_65) AT=870.025n

.meas tran vdout0_66ck1730 FIND v(dout0_66) AT=870.025n

.meas tran vdout0_67ck1730 FIND v(dout0_67) AT=870.025n

.meas tran vdout0_68ck1730 FIND v(dout0_68) AT=870.025n

.meas tran vdout0_69ck1730 FIND v(dout0_69) AT=870.025n

.meas tran vdout0_70ck1730 FIND v(dout0_70) AT=870.025n

.meas tran vdout0_71ck1730 FIND v(dout0_71) AT=870.025n

.meas tran vdout0_72ck1730 FIND v(dout0_72) AT=870.025n

.meas tran vdout0_73ck1730 FIND v(dout0_73) AT=870.025n

.meas tran vdout0_74ck1730 FIND v(dout0_74) AT=870.025n

.meas tran vdout0_75ck1730 FIND v(dout0_75) AT=870.025n

.meas tran vdout0_76ck1730 FIND v(dout0_76) AT=870.025n

.meas tran vdout0_77ck1730 FIND v(dout0_77) AT=870.025n

.meas tran vdout0_78ck1730 FIND v(dout0_78) AT=870.025n

.meas tran vdout0_79ck1730 FIND v(dout0_79) AT=870.025n

.meas tran vdout0_80ck1730 FIND v(dout0_80) AT=870.025n

.meas tran vdout0_81ck1730 FIND v(dout0_81) AT=870.025n

.meas tran vdout0_82ck1730 FIND v(dout0_82) AT=870.025n

.meas tran vdout0_83ck1730 FIND v(dout0_83) AT=870.025n

.meas tran vdout0_84ck1730 FIND v(dout0_84) AT=870.025n

.meas tran vdout0_85ck1730 FIND v(dout0_85) AT=870.025n

.meas tran vdout0_86ck1730 FIND v(dout0_86) AT=870.025n

.meas tran vdout0_87ck1730 FIND v(dout0_87) AT=870.025n

.meas tran vdout0_88ck1730 FIND v(dout0_88) AT=870.025n

.meas tran vdout0_89ck1730 FIND v(dout0_89) AT=870.025n

.meas tran vdout0_90ck1730 FIND v(dout0_90) AT=870.025n

.meas tran vdout0_91ck1730 FIND v(dout0_91) AT=870.025n

.meas tran vdout0_92ck1730 FIND v(dout0_92) AT=870.025n

.meas tran vdout0_93ck1730 FIND v(dout0_93) AT=870.025n

.meas tran vdout0_94ck1730 FIND v(dout0_94) AT=870.025n

.meas tran vdout0_95ck1730 FIND v(dout0_95) AT=870.025n

.meas tran vdout0_96ck1730 FIND v(dout0_96) AT=870.025n

.meas tran vdout0_97ck1730 FIND v(dout0_97) AT=870.025n

.meas tran vdout0_98ck1730 FIND v(dout0_98) AT=870.025n

.meas tran vdout0_99ck1730 FIND v(dout0_99) AT=870.025n

.meas tran vdout0_100ck1730 FIND v(dout0_100) AT=870.025n

.meas tran vdout0_101ck1730 FIND v(dout0_101) AT=870.025n

.meas tran vdout0_102ck1730 FIND v(dout0_102) AT=870.025n

.meas tran vdout0_103ck1730 FIND v(dout0_103) AT=870.025n

.meas tran vdout0_104ck1730 FIND v(dout0_104) AT=870.025n

.meas tran vdout0_105ck1730 FIND v(dout0_105) AT=870.025n

.meas tran vdout0_106ck1730 FIND v(dout0_106) AT=870.025n

.meas tran vdout0_107ck1730 FIND v(dout0_107) AT=870.025n

.meas tran vdout0_108ck1730 FIND v(dout0_108) AT=870.025n

.meas tran vdout0_109ck1730 FIND v(dout0_109) AT=870.025n

.meas tran vdout0_110ck1730 FIND v(dout0_110) AT=870.025n

.meas tran vdout0_111ck1730 FIND v(dout0_111) AT=870.025n

.meas tran vdout0_112ck1730 FIND v(dout0_112) AT=870.025n

.meas tran vdout0_113ck1730 FIND v(dout0_113) AT=870.025n

.meas tran vdout0_114ck1730 FIND v(dout0_114) AT=870.025n

.meas tran vdout0_115ck1730 FIND v(dout0_115) AT=870.025n

.meas tran vdout0_116ck1730 FIND v(dout0_116) AT=870.025n

.meas tran vdout0_117ck1730 FIND v(dout0_117) AT=870.025n

.meas tran vdout0_118ck1730 FIND v(dout0_118) AT=870.025n

.meas tran vdout0_119ck1730 FIND v(dout0_119) AT=870.025n

.meas tran vdout0_120ck1730 FIND v(dout0_120) AT=870.025n

.meas tran vdout0_121ck1730 FIND v(dout0_121) AT=870.025n

.meas tran vdout0_122ck1730 FIND v(dout0_122) AT=870.025n

.meas tran vdout0_123ck1730 FIND v(dout0_123) AT=870.025n

.meas tran vdout0_124ck1730 FIND v(dout0_124) AT=870.025n

.meas tran vdout0_125ck1730 FIND v(dout0_125) AT=870.025n

.meas tran vdout0_126ck1730 FIND v(dout0_126) AT=870.025n

.meas tran vdout0_127ck1730 FIND v(dout0_127) AT=870.025n

.meas tran vdout0_128ck1730 FIND v(dout0_128) AT=870.025n

.meas tran vdout0_129ck1730 FIND v(dout0_129) AT=870.025n

.meas tran vdout0_130ck1730 FIND v(dout0_130) AT=870.025n

.meas tran vdout0_131ck1730 FIND v(dout0_131) AT=870.025n

.meas tran vdout0_132ck1730 FIND v(dout0_132) AT=870.025n

.meas tran vdout0_133ck1730 FIND v(dout0_133) AT=870.025n

.meas tran vdout0_134ck1730 FIND v(dout0_134) AT=870.025n

.meas tran vdout0_135ck1730 FIND v(dout0_135) AT=870.025n

.meas tran vdout0_136ck1730 FIND v(dout0_136) AT=870.025n

.meas tran vdout0_137ck1730 FIND v(dout0_137) AT=870.025n

.meas tran vdout0_138ck1730 FIND v(dout0_138) AT=870.025n

.meas tran vdout0_139ck1730 FIND v(dout0_139) AT=870.025n

.meas tran vdout0_140ck1730 FIND v(dout0_140) AT=870.025n

.meas tran vdout0_141ck1730 FIND v(dout0_141) AT=870.025n

.meas tran vdout0_142ck1730 FIND v(dout0_142) AT=870.025n

.meas tran vdout0_143ck1730 FIND v(dout0_143) AT=870.025n

.meas tran vdout0_144ck1730 FIND v(dout0_144) AT=870.025n

.meas tran vdout0_145ck1730 FIND v(dout0_145) AT=870.025n

.meas tran vdout0_146ck1730 FIND v(dout0_146) AT=870.025n

.meas tran vdout0_147ck1730 FIND v(dout0_147) AT=870.025n

.meas tran vdout0_148ck1730 FIND v(dout0_148) AT=870.025n

.meas tran vdout0_149ck1730 FIND v(dout0_149) AT=870.025n

.meas tran vdout0_150ck1730 FIND v(dout0_150) AT=870.025n

.meas tran vdout0_151ck1730 FIND v(dout0_151) AT=870.025n

.meas tran vdout0_152ck1730 FIND v(dout0_152) AT=870.025n

.meas tran vdout0_153ck1730 FIND v(dout0_153) AT=870.025n

.meas tran vdout0_154ck1730 FIND v(dout0_154) AT=870.025n

.meas tran vdout0_155ck1730 FIND v(dout0_155) AT=870.025n

.meas tran vdout0_156ck1730 FIND v(dout0_156) AT=870.025n

.meas tran vdout0_157ck1730 FIND v(dout0_157) AT=870.025n

.meas tran vdout0_158ck1730 FIND v(dout0_158) AT=870.025n

.meas tran vdout0_159ck1730 FIND v(dout0_159) AT=870.025n

.meas tran vdout0_160ck1730 FIND v(dout0_160) AT=870.025n

.meas tran vdout0_161ck1730 FIND v(dout0_161) AT=870.025n

.meas tran vdout0_162ck1730 FIND v(dout0_162) AT=870.025n

.meas tran vdout0_163ck1730 FIND v(dout0_163) AT=870.025n

.meas tran vdout0_164ck1730 FIND v(dout0_164) AT=870.025n

.meas tran vdout0_165ck1730 FIND v(dout0_165) AT=870.025n

.meas tran vdout0_166ck1730 FIND v(dout0_166) AT=870.025n

.meas tran vdout0_167ck1730 FIND v(dout0_167) AT=870.025n

.meas tran vdout0_168ck1730 FIND v(dout0_168) AT=870.025n

.meas tran vdout0_169ck1730 FIND v(dout0_169) AT=870.025n

.meas tran vdout0_170ck1730 FIND v(dout0_170) AT=870.025n

.meas tran vdout0_171ck1730 FIND v(dout0_171) AT=870.025n

.meas tran vdout0_172ck1730 FIND v(dout0_172) AT=870.025n

.meas tran vdout0_173ck1730 FIND v(dout0_173) AT=870.025n

.meas tran vdout0_174ck1730 FIND v(dout0_174) AT=870.025n

.meas tran vdout0_175ck1730 FIND v(dout0_175) AT=870.025n

.meas tran vdout0_176ck1730 FIND v(dout0_176) AT=870.025n

.meas tran vdout0_177ck1730 FIND v(dout0_177) AT=870.025n

.meas tran vdout0_178ck1730 FIND v(dout0_178) AT=870.025n

.meas tran vdout0_179ck1730 FIND v(dout0_179) AT=870.025n

.meas tran vdout0_180ck1730 FIND v(dout0_180) AT=870.025n

.meas tran vdout0_181ck1730 FIND v(dout0_181) AT=870.025n

.meas tran vdout0_182ck1730 FIND v(dout0_182) AT=870.025n

.meas tran vdout0_183ck1730 FIND v(dout0_183) AT=870.025n

.meas tran vdout0_184ck1730 FIND v(dout0_184) AT=870.025n

.meas tran vdout0_185ck1730 FIND v(dout0_185) AT=870.025n

.meas tran vdout0_186ck1730 FIND v(dout0_186) AT=870.025n

.meas tran vdout0_187ck1730 FIND v(dout0_187) AT=870.025n

.meas tran vdout0_188ck1730 FIND v(dout0_188) AT=870.025n

.meas tran vdout0_189ck1730 FIND v(dout0_189) AT=870.025n

.meas tran vdout0_190ck1730 FIND v(dout0_190) AT=870.025n

.meas tran vdout0_191ck1730 FIND v(dout0_191) AT=870.025n

.meas tran vdout0_192ck1730 FIND v(dout0_192) AT=870.025n

.meas tran vdout0_193ck1730 FIND v(dout0_193) AT=870.025n

.meas tran vdout0_194ck1730 FIND v(dout0_194) AT=870.025n

.meas tran vdout0_195ck1730 FIND v(dout0_195) AT=870.025n

.meas tran vdout0_196ck1730 FIND v(dout0_196) AT=870.025n

.meas tran vdout0_197ck1730 FIND v(dout0_197) AT=870.025n

.meas tran vdout0_198ck1730 FIND v(dout0_198) AT=870.025n

.meas tran vdout0_199ck1730 FIND v(dout0_199) AT=870.025n

.meas tran vdout0_200ck1730 FIND v(dout0_200) AT=870.025n

.meas tran vdout0_201ck1730 FIND v(dout0_201) AT=870.025n

.meas tran vdout0_202ck1730 FIND v(dout0_202) AT=870.025n

.meas tran vdout0_203ck1730 FIND v(dout0_203) AT=870.025n

.meas tran vdout0_204ck1730 FIND v(dout0_204) AT=870.025n

.meas tran vdout0_205ck1730 FIND v(dout0_205) AT=870.025n

.meas tran vdout0_206ck1730 FIND v(dout0_206) AT=870.025n

.meas tran vdout0_207ck1730 FIND v(dout0_207) AT=870.025n

.meas tran vdout0_208ck1730 FIND v(dout0_208) AT=870.025n

.meas tran vdout0_209ck1730 FIND v(dout0_209) AT=870.025n

.meas tran vdout0_210ck1730 FIND v(dout0_210) AT=870.025n

.meas tran vdout0_211ck1730 FIND v(dout0_211) AT=870.025n

.meas tran vdout0_212ck1730 FIND v(dout0_212) AT=870.025n

.meas tran vdout0_213ck1730 FIND v(dout0_213) AT=870.025n

.meas tran vdout0_214ck1730 FIND v(dout0_214) AT=870.025n

.meas tran vdout0_215ck1730 FIND v(dout0_215) AT=870.025n

.meas tran vdout0_216ck1730 FIND v(dout0_216) AT=870.025n

.meas tran vdout0_217ck1730 FIND v(dout0_217) AT=870.025n

.meas tran vdout0_218ck1730 FIND v(dout0_218) AT=870.025n

.meas tran vdout0_219ck1730 FIND v(dout0_219) AT=870.025n

.meas tran vdout0_220ck1730 FIND v(dout0_220) AT=870.025n

.meas tran vdout0_221ck1730 FIND v(dout0_221) AT=870.025n

.meas tran vdout0_222ck1730 FIND v(dout0_222) AT=870.025n

.meas tran vdout0_223ck1730 FIND v(dout0_223) AT=870.025n

.meas tran vdout0_224ck1730 FIND v(dout0_224) AT=870.025n

.meas tran vdout0_225ck1730 FIND v(dout0_225) AT=870.025n

.meas tran vdout0_226ck1730 FIND v(dout0_226) AT=870.025n

.meas tran vdout0_227ck1730 FIND v(dout0_227) AT=870.025n

.meas tran vdout0_228ck1730 FIND v(dout0_228) AT=870.025n

.meas tran vdout0_229ck1730 FIND v(dout0_229) AT=870.025n

.meas tran vdout0_230ck1730 FIND v(dout0_230) AT=870.025n

.meas tran vdout0_231ck1730 FIND v(dout0_231) AT=870.025n

.meas tran vdout0_232ck1730 FIND v(dout0_232) AT=870.025n

.meas tran vdout0_233ck1730 FIND v(dout0_233) AT=870.025n

.meas tran vdout0_234ck1730 FIND v(dout0_234) AT=870.025n

.meas tran vdout0_235ck1730 FIND v(dout0_235) AT=870.025n

.meas tran vdout0_236ck1730 FIND v(dout0_236) AT=870.025n

.meas tran vdout0_237ck1730 FIND v(dout0_237) AT=870.025n

.meas tran vdout0_238ck1730 FIND v(dout0_238) AT=870.025n

.meas tran vdout0_239ck1730 FIND v(dout0_239) AT=870.025n

.meas tran vdout0_240ck1730 FIND v(dout0_240) AT=870.025n

.meas tran vdout0_241ck1730 FIND v(dout0_241) AT=870.025n

.meas tran vdout0_242ck1730 FIND v(dout0_242) AT=870.025n

.meas tran vdout0_243ck1730 FIND v(dout0_243) AT=870.025n

.meas tran vdout0_244ck1730 FIND v(dout0_244) AT=870.025n

.meas tran vdout0_245ck1730 FIND v(dout0_245) AT=870.025n

.meas tran vdout0_246ck1730 FIND v(dout0_246) AT=870.025n

.meas tran vdout0_247ck1730 FIND v(dout0_247) AT=870.025n

.meas tran vdout0_248ck1730 FIND v(dout0_248) AT=870.025n

.meas tran vdout0_249ck1730 FIND v(dout0_249) AT=870.025n

.meas tran vdout0_250ck1730 FIND v(dout0_250) AT=870.025n

.meas tran vdout0_251ck1730 FIND v(dout0_251) AT=870.025n

.meas tran vdout0_252ck1730 FIND v(dout0_252) AT=870.025n

.meas tran vdout0_253ck1730 FIND v(dout0_253) AT=870.025n

.meas tran vdout0_254ck1730 FIND v(dout0_254) AT=870.025n

.meas tran vdout0_255ck1730 FIND v(dout0_255) AT=870.025n

.meas tran vdout0_0ck1740 FIND v(dout0_0) AT=875.025n

.meas tran vdout0_1ck1740 FIND v(dout0_1) AT=875.025n

.meas tran vdout0_2ck1740 FIND v(dout0_2) AT=875.025n

.meas tran vdout0_3ck1740 FIND v(dout0_3) AT=875.025n

.meas tran vdout0_4ck1740 FIND v(dout0_4) AT=875.025n

.meas tran vdout0_5ck1740 FIND v(dout0_5) AT=875.025n

.meas tran vdout0_6ck1740 FIND v(dout0_6) AT=875.025n

.meas tran vdout0_7ck1740 FIND v(dout0_7) AT=875.025n

.meas tran vdout0_8ck1740 FIND v(dout0_8) AT=875.025n

.meas tran vdout0_9ck1740 FIND v(dout0_9) AT=875.025n

.meas tran vdout0_10ck1740 FIND v(dout0_10) AT=875.025n

.meas tran vdout0_11ck1740 FIND v(dout0_11) AT=875.025n

.meas tran vdout0_12ck1740 FIND v(dout0_12) AT=875.025n

.meas tran vdout0_13ck1740 FIND v(dout0_13) AT=875.025n

.meas tran vdout0_14ck1740 FIND v(dout0_14) AT=875.025n

.meas tran vdout0_15ck1740 FIND v(dout0_15) AT=875.025n

.meas tran vdout0_16ck1740 FIND v(dout0_16) AT=875.025n

.meas tran vdout0_17ck1740 FIND v(dout0_17) AT=875.025n

.meas tran vdout0_18ck1740 FIND v(dout0_18) AT=875.025n

.meas tran vdout0_19ck1740 FIND v(dout0_19) AT=875.025n

.meas tran vdout0_20ck1740 FIND v(dout0_20) AT=875.025n

.meas tran vdout0_21ck1740 FIND v(dout0_21) AT=875.025n

.meas tran vdout0_22ck1740 FIND v(dout0_22) AT=875.025n

.meas tran vdout0_23ck1740 FIND v(dout0_23) AT=875.025n

.meas tran vdout0_24ck1740 FIND v(dout0_24) AT=875.025n

.meas tran vdout0_25ck1740 FIND v(dout0_25) AT=875.025n

.meas tran vdout0_26ck1740 FIND v(dout0_26) AT=875.025n

.meas tran vdout0_27ck1740 FIND v(dout0_27) AT=875.025n

.meas tran vdout0_28ck1740 FIND v(dout0_28) AT=875.025n

.meas tran vdout0_29ck1740 FIND v(dout0_29) AT=875.025n

.meas tran vdout0_30ck1740 FIND v(dout0_30) AT=875.025n

.meas tran vdout0_31ck1740 FIND v(dout0_31) AT=875.025n

.meas tran vdout0_32ck1740 FIND v(dout0_32) AT=875.025n

.meas tran vdout0_33ck1740 FIND v(dout0_33) AT=875.025n

.meas tran vdout0_34ck1740 FIND v(dout0_34) AT=875.025n

.meas tran vdout0_35ck1740 FIND v(dout0_35) AT=875.025n

.meas tran vdout0_36ck1740 FIND v(dout0_36) AT=875.025n

.meas tran vdout0_37ck1740 FIND v(dout0_37) AT=875.025n

.meas tran vdout0_38ck1740 FIND v(dout0_38) AT=875.025n

.meas tran vdout0_39ck1740 FIND v(dout0_39) AT=875.025n

.meas tran vdout0_40ck1740 FIND v(dout0_40) AT=875.025n

.meas tran vdout0_41ck1740 FIND v(dout0_41) AT=875.025n

.meas tran vdout0_42ck1740 FIND v(dout0_42) AT=875.025n

.meas tran vdout0_43ck1740 FIND v(dout0_43) AT=875.025n

.meas tran vdout0_44ck1740 FIND v(dout0_44) AT=875.025n

.meas tran vdout0_45ck1740 FIND v(dout0_45) AT=875.025n

.meas tran vdout0_46ck1740 FIND v(dout0_46) AT=875.025n

.meas tran vdout0_47ck1740 FIND v(dout0_47) AT=875.025n

.meas tran vdout0_48ck1740 FIND v(dout0_48) AT=875.025n

.meas tran vdout0_49ck1740 FIND v(dout0_49) AT=875.025n

.meas tran vdout0_50ck1740 FIND v(dout0_50) AT=875.025n

.meas tran vdout0_51ck1740 FIND v(dout0_51) AT=875.025n

.meas tran vdout0_52ck1740 FIND v(dout0_52) AT=875.025n

.meas tran vdout0_53ck1740 FIND v(dout0_53) AT=875.025n

.meas tran vdout0_54ck1740 FIND v(dout0_54) AT=875.025n

.meas tran vdout0_55ck1740 FIND v(dout0_55) AT=875.025n

.meas tran vdout0_56ck1740 FIND v(dout0_56) AT=875.025n

.meas tran vdout0_57ck1740 FIND v(dout0_57) AT=875.025n

.meas tran vdout0_58ck1740 FIND v(dout0_58) AT=875.025n

.meas tran vdout0_59ck1740 FIND v(dout0_59) AT=875.025n

.meas tran vdout0_60ck1740 FIND v(dout0_60) AT=875.025n

.meas tran vdout0_61ck1740 FIND v(dout0_61) AT=875.025n

.meas tran vdout0_62ck1740 FIND v(dout0_62) AT=875.025n

.meas tran vdout0_63ck1740 FIND v(dout0_63) AT=875.025n

.meas tran vdout0_64ck1740 FIND v(dout0_64) AT=875.025n

.meas tran vdout0_65ck1740 FIND v(dout0_65) AT=875.025n

.meas tran vdout0_66ck1740 FIND v(dout0_66) AT=875.025n

.meas tran vdout0_67ck1740 FIND v(dout0_67) AT=875.025n

.meas tran vdout0_68ck1740 FIND v(dout0_68) AT=875.025n

.meas tran vdout0_69ck1740 FIND v(dout0_69) AT=875.025n

.meas tran vdout0_70ck1740 FIND v(dout0_70) AT=875.025n

.meas tran vdout0_71ck1740 FIND v(dout0_71) AT=875.025n

.meas tran vdout0_72ck1740 FIND v(dout0_72) AT=875.025n

.meas tran vdout0_73ck1740 FIND v(dout0_73) AT=875.025n

.meas tran vdout0_74ck1740 FIND v(dout0_74) AT=875.025n

.meas tran vdout0_75ck1740 FIND v(dout0_75) AT=875.025n

.meas tran vdout0_76ck1740 FIND v(dout0_76) AT=875.025n

.meas tran vdout0_77ck1740 FIND v(dout0_77) AT=875.025n

.meas tran vdout0_78ck1740 FIND v(dout0_78) AT=875.025n

.meas tran vdout0_79ck1740 FIND v(dout0_79) AT=875.025n

.meas tran vdout0_80ck1740 FIND v(dout0_80) AT=875.025n

.meas tran vdout0_81ck1740 FIND v(dout0_81) AT=875.025n

.meas tran vdout0_82ck1740 FIND v(dout0_82) AT=875.025n

.meas tran vdout0_83ck1740 FIND v(dout0_83) AT=875.025n

.meas tran vdout0_84ck1740 FIND v(dout0_84) AT=875.025n

.meas tran vdout0_85ck1740 FIND v(dout0_85) AT=875.025n

.meas tran vdout0_86ck1740 FIND v(dout0_86) AT=875.025n

.meas tran vdout0_87ck1740 FIND v(dout0_87) AT=875.025n

.meas tran vdout0_88ck1740 FIND v(dout0_88) AT=875.025n

.meas tran vdout0_89ck1740 FIND v(dout0_89) AT=875.025n

.meas tran vdout0_90ck1740 FIND v(dout0_90) AT=875.025n

.meas tran vdout0_91ck1740 FIND v(dout0_91) AT=875.025n

.meas tran vdout0_92ck1740 FIND v(dout0_92) AT=875.025n

.meas tran vdout0_93ck1740 FIND v(dout0_93) AT=875.025n

.meas tran vdout0_94ck1740 FIND v(dout0_94) AT=875.025n

.meas tran vdout0_95ck1740 FIND v(dout0_95) AT=875.025n

.meas tran vdout0_96ck1740 FIND v(dout0_96) AT=875.025n

.meas tran vdout0_97ck1740 FIND v(dout0_97) AT=875.025n

.meas tran vdout0_98ck1740 FIND v(dout0_98) AT=875.025n

.meas tran vdout0_99ck1740 FIND v(dout0_99) AT=875.025n

.meas tran vdout0_100ck1740 FIND v(dout0_100) AT=875.025n

.meas tran vdout0_101ck1740 FIND v(dout0_101) AT=875.025n

.meas tran vdout0_102ck1740 FIND v(dout0_102) AT=875.025n

.meas tran vdout0_103ck1740 FIND v(dout0_103) AT=875.025n

.meas tran vdout0_104ck1740 FIND v(dout0_104) AT=875.025n

.meas tran vdout0_105ck1740 FIND v(dout0_105) AT=875.025n

.meas tran vdout0_106ck1740 FIND v(dout0_106) AT=875.025n

.meas tran vdout0_107ck1740 FIND v(dout0_107) AT=875.025n

.meas tran vdout0_108ck1740 FIND v(dout0_108) AT=875.025n

.meas tran vdout0_109ck1740 FIND v(dout0_109) AT=875.025n

.meas tran vdout0_110ck1740 FIND v(dout0_110) AT=875.025n

.meas tran vdout0_111ck1740 FIND v(dout0_111) AT=875.025n

.meas tran vdout0_112ck1740 FIND v(dout0_112) AT=875.025n

.meas tran vdout0_113ck1740 FIND v(dout0_113) AT=875.025n

.meas tran vdout0_114ck1740 FIND v(dout0_114) AT=875.025n

.meas tran vdout0_115ck1740 FIND v(dout0_115) AT=875.025n

.meas tran vdout0_116ck1740 FIND v(dout0_116) AT=875.025n

.meas tran vdout0_117ck1740 FIND v(dout0_117) AT=875.025n

.meas tran vdout0_118ck1740 FIND v(dout0_118) AT=875.025n

.meas tran vdout0_119ck1740 FIND v(dout0_119) AT=875.025n

.meas tran vdout0_120ck1740 FIND v(dout0_120) AT=875.025n

.meas tran vdout0_121ck1740 FIND v(dout0_121) AT=875.025n

.meas tran vdout0_122ck1740 FIND v(dout0_122) AT=875.025n

.meas tran vdout0_123ck1740 FIND v(dout0_123) AT=875.025n

.meas tran vdout0_124ck1740 FIND v(dout0_124) AT=875.025n

.meas tran vdout0_125ck1740 FIND v(dout0_125) AT=875.025n

.meas tran vdout0_126ck1740 FIND v(dout0_126) AT=875.025n

.meas tran vdout0_127ck1740 FIND v(dout0_127) AT=875.025n

.meas tran vdout0_128ck1740 FIND v(dout0_128) AT=875.025n

.meas tran vdout0_129ck1740 FIND v(dout0_129) AT=875.025n

.meas tran vdout0_130ck1740 FIND v(dout0_130) AT=875.025n

.meas tran vdout0_131ck1740 FIND v(dout0_131) AT=875.025n

.meas tran vdout0_132ck1740 FIND v(dout0_132) AT=875.025n

.meas tran vdout0_133ck1740 FIND v(dout0_133) AT=875.025n

.meas tran vdout0_134ck1740 FIND v(dout0_134) AT=875.025n

.meas tran vdout0_135ck1740 FIND v(dout0_135) AT=875.025n

.meas tran vdout0_136ck1740 FIND v(dout0_136) AT=875.025n

.meas tran vdout0_137ck1740 FIND v(dout0_137) AT=875.025n

.meas tran vdout0_138ck1740 FIND v(dout0_138) AT=875.025n

.meas tran vdout0_139ck1740 FIND v(dout0_139) AT=875.025n

.meas tran vdout0_140ck1740 FIND v(dout0_140) AT=875.025n

.meas tran vdout0_141ck1740 FIND v(dout0_141) AT=875.025n

.meas tran vdout0_142ck1740 FIND v(dout0_142) AT=875.025n

.meas tran vdout0_143ck1740 FIND v(dout0_143) AT=875.025n

.meas tran vdout0_144ck1740 FIND v(dout0_144) AT=875.025n

.meas tran vdout0_145ck1740 FIND v(dout0_145) AT=875.025n

.meas tran vdout0_146ck1740 FIND v(dout0_146) AT=875.025n

.meas tran vdout0_147ck1740 FIND v(dout0_147) AT=875.025n

.meas tran vdout0_148ck1740 FIND v(dout0_148) AT=875.025n

.meas tran vdout0_149ck1740 FIND v(dout0_149) AT=875.025n

.meas tran vdout0_150ck1740 FIND v(dout0_150) AT=875.025n

.meas tran vdout0_151ck1740 FIND v(dout0_151) AT=875.025n

.meas tran vdout0_152ck1740 FIND v(dout0_152) AT=875.025n

.meas tran vdout0_153ck1740 FIND v(dout0_153) AT=875.025n

.meas tran vdout0_154ck1740 FIND v(dout0_154) AT=875.025n

.meas tran vdout0_155ck1740 FIND v(dout0_155) AT=875.025n

.meas tran vdout0_156ck1740 FIND v(dout0_156) AT=875.025n

.meas tran vdout0_157ck1740 FIND v(dout0_157) AT=875.025n

.meas tran vdout0_158ck1740 FIND v(dout0_158) AT=875.025n

.meas tran vdout0_159ck1740 FIND v(dout0_159) AT=875.025n

.meas tran vdout0_160ck1740 FIND v(dout0_160) AT=875.025n

.meas tran vdout0_161ck1740 FIND v(dout0_161) AT=875.025n

.meas tran vdout0_162ck1740 FIND v(dout0_162) AT=875.025n

.meas tran vdout0_163ck1740 FIND v(dout0_163) AT=875.025n

.meas tran vdout0_164ck1740 FIND v(dout0_164) AT=875.025n

.meas tran vdout0_165ck1740 FIND v(dout0_165) AT=875.025n

.meas tran vdout0_166ck1740 FIND v(dout0_166) AT=875.025n

.meas tran vdout0_167ck1740 FIND v(dout0_167) AT=875.025n

.meas tran vdout0_168ck1740 FIND v(dout0_168) AT=875.025n

.meas tran vdout0_169ck1740 FIND v(dout0_169) AT=875.025n

.meas tran vdout0_170ck1740 FIND v(dout0_170) AT=875.025n

.meas tran vdout0_171ck1740 FIND v(dout0_171) AT=875.025n

.meas tran vdout0_172ck1740 FIND v(dout0_172) AT=875.025n

.meas tran vdout0_173ck1740 FIND v(dout0_173) AT=875.025n

.meas tran vdout0_174ck1740 FIND v(dout0_174) AT=875.025n

.meas tran vdout0_175ck1740 FIND v(dout0_175) AT=875.025n

.meas tran vdout0_176ck1740 FIND v(dout0_176) AT=875.025n

.meas tran vdout0_177ck1740 FIND v(dout0_177) AT=875.025n

.meas tran vdout0_178ck1740 FIND v(dout0_178) AT=875.025n

.meas tran vdout0_179ck1740 FIND v(dout0_179) AT=875.025n

.meas tran vdout0_180ck1740 FIND v(dout0_180) AT=875.025n

.meas tran vdout0_181ck1740 FIND v(dout0_181) AT=875.025n

.meas tran vdout0_182ck1740 FIND v(dout0_182) AT=875.025n

.meas tran vdout0_183ck1740 FIND v(dout0_183) AT=875.025n

.meas tran vdout0_184ck1740 FIND v(dout0_184) AT=875.025n

.meas tran vdout0_185ck1740 FIND v(dout0_185) AT=875.025n

.meas tran vdout0_186ck1740 FIND v(dout0_186) AT=875.025n

.meas tran vdout0_187ck1740 FIND v(dout0_187) AT=875.025n

.meas tran vdout0_188ck1740 FIND v(dout0_188) AT=875.025n

.meas tran vdout0_189ck1740 FIND v(dout0_189) AT=875.025n

.meas tran vdout0_190ck1740 FIND v(dout0_190) AT=875.025n

.meas tran vdout0_191ck1740 FIND v(dout0_191) AT=875.025n

.meas tran vdout0_192ck1740 FIND v(dout0_192) AT=875.025n

.meas tran vdout0_193ck1740 FIND v(dout0_193) AT=875.025n

.meas tran vdout0_194ck1740 FIND v(dout0_194) AT=875.025n

.meas tran vdout0_195ck1740 FIND v(dout0_195) AT=875.025n

.meas tran vdout0_196ck1740 FIND v(dout0_196) AT=875.025n

.meas tran vdout0_197ck1740 FIND v(dout0_197) AT=875.025n

.meas tran vdout0_198ck1740 FIND v(dout0_198) AT=875.025n

.meas tran vdout0_199ck1740 FIND v(dout0_199) AT=875.025n

.meas tran vdout0_200ck1740 FIND v(dout0_200) AT=875.025n

.meas tran vdout0_201ck1740 FIND v(dout0_201) AT=875.025n

.meas tran vdout0_202ck1740 FIND v(dout0_202) AT=875.025n

.meas tran vdout0_203ck1740 FIND v(dout0_203) AT=875.025n

.meas tran vdout0_204ck1740 FIND v(dout0_204) AT=875.025n

.meas tran vdout0_205ck1740 FIND v(dout0_205) AT=875.025n

.meas tran vdout0_206ck1740 FIND v(dout0_206) AT=875.025n

.meas tran vdout0_207ck1740 FIND v(dout0_207) AT=875.025n

.meas tran vdout0_208ck1740 FIND v(dout0_208) AT=875.025n

.meas tran vdout0_209ck1740 FIND v(dout0_209) AT=875.025n

.meas tran vdout0_210ck1740 FIND v(dout0_210) AT=875.025n

.meas tran vdout0_211ck1740 FIND v(dout0_211) AT=875.025n

.meas tran vdout0_212ck1740 FIND v(dout0_212) AT=875.025n

.meas tran vdout0_213ck1740 FIND v(dout0_213) AT=875.025n

.meas tran vdout0_214ck1740 FIND v(dout0_214) AT=875.025n

.meas tran vdout0_215ck1740 FIND v(dout0_215) AT=875.025n

.meas tran vdout0_216ck1740 FIND v(dout0_216) AT=875.025n

.meas tran vdout0_217ck1740 FIND v(dout0_217) AT=875.025n

.meas tran vdout0_218ck1740 FIND v(dout0_218) AT=875.025n

.meas tran vdout0_219ck1740 FIND v(dout0_219) AT=875.025n

.meas tran vdout0_220ck1740 FIND v(dout0_220) AT=875.025n

.meas tran vdout0_221ck1740 FIND v(dout0_221) AT=875.025n

.meas tran vdout0_222ck1740 FIND v(dout0_222) AT=875.025n

.meas tran vdout0_223ck1740 FIND v(dout0_223) AT=875.025n

.meas tran vdout0_224ck1740 FIND v(dout0_224) AT=875.025n

.meas tran vdout0_225ck1740 FIND v(dout0_225) AT=875.025n

.meas tran vdout0_226ck1740 FIND v(dout0_226) AT=875.025n

.meas tran vdout0_227ck1740 FIND v(dout0_227) AT=875.025n

.meas tran vdout0_228ck1740 FIND v(dout0_228) AT=875.025n

.meas tran vdout0_229ck1740 FIND v(dout0_229) AT=875.025n

.meas tran vdout0_230ck1740 FIND v(dout0_230) AT=875.025n

.meas tran vdout0_231ck1740 FIND v(dout0_231) AT=875.025n

.meas tran vdout0_232ck1740 FIND v(dout0_232) AT=875.025n

.meas tran vdout0_233ck1740 FIND v(dout0_233) AT=875.025n

.meas tran vdout0_234ck1740 FIND v(dout0_234) AT=875.025n

.meas tran vdout0_235ck1740 FIND v(dout0_235) AT=875.025n

.meas tran vdout0_236ck1740 FIND v(dout0_236) AT=875.025n

.meas tran vdout0_237ck1740 FIND v(dout0_237) AT=875.025n

.meas tran vdout0_238ck1740 FIND v(dout0_238) AT=875.025n

.meas tran vdout0_239ck1740 FIND v(dout0_239) AT=875.025n

.meas tran vdout0_240ck1740 FIND v(dout0_240) AT=875.025n

.meas tran vdout0_241ck1740 FIND v(dout0_241) AT=875.025n

.meas tran vdout0_242ck1740 FIND v(dout0_242) AT=875.025n

.meas tran vdout0_243ck1740 FIND v(dout0_243) AT=875.025n

.meas tran vdout0_244ck1740 FIND v(dout0_244) AT=875.025n

.meas tran vdout0_245ck1740 FIND v(dout0_245) AT=875.025n

.meas tran vdout0_246ck1740 FIND v(dout0_246) AT=875.025n

.meas tran vdout0_247ck1740 FIND v(dout0_247) AT=875.025n

.meas tran vdout0_248ck1740 FIND v(dout0_248) AT=875.025n

.meas tran vdout0_249ck1740 FIND v(dout0_249) AT=875.025n

.meas tran vdout0_250ck1740 FIND v(dout0_250) AT=875.025n

.meas tran vdout0_251ck1740 FIND v(dout0_251) AT=875.025n

.meas tran vdout0_252ck1740 FIND v(dout0_252) AT=875.025n

.meas tran vdout0_253ck1740 FIND v(dout0_253) AT=875.025n

.meas tran vdout0_254ck1740 FIND v(dout0_254) AT=875.025n

.meas tran vdout0_255ck1740 FIND v(dout0_255) AT=875.025n

.meas tran vdout0_0ck1760 FIND v(dout0_0) AT=885.025n

.meas tran vdout0_1ck1760 FIND v(dout0_1) AT=885.025n

.meas tran vdout0_2ck1760 FIND v(dout0_2) AT=885.025n

.meas tran vdout0_3ck1760 FIND v(dout0_3) AT=885.025n

.meas tran vdout0_4ck1760 FIND v(dout0_4) AT=885.025n

.meas tran vdout0_5ck1760 FIND v(dout0_5) AT=885.025n

.meas tran vdout0_6ck1760 FIND v(dout0_6) AT=885.025n

.meas tran vdout0_7ck1760 FIND v(dout0_7) AT=885.025n

.meas tran vdout0_8ck1760 FIND v(dout0_8) AT=885.025n

.meas tran vdout0_9ck1760 FIND v(dout0_9) AT=885.025n

.meas tran vdout0_10ck1760 FIND v(dout0_10) AT=885.025n

.meas tran vdout0_11ck1760 FIND v(dout0_11) AT=885.025n

.meas tran vdout0_12ck1760 FIND v(dout0_12) AT=885.025n

.meas tran vdout0_13ck1760 FIND v(dout0_13) AT=885.025n

.meas tran vdout0_14ck1760 FIND v(dout0_14) AT=885.025n

.meas tran vdout0_15ck1760 FIND v(dout0_15) AT=885.025n

.meas tran vdout0_16ck1760 FIND v(dout0_16) AT=885.025n

.meas tran vdout0_17ck1760 FIND v(dout0_17) AT=885.025n

.meas tran vdout0_18ck1760 FIND v(dout0_18) AT=885.025n

.meas tran vdout0_19ck1760 FIND v(dout0_19) AT=885.025n

.meas tran vdout0_20ck1760 FIND v(dout0_20) AT=885.025n

.meas tran vdout0_21ck1760 FIND v(dout0_21) AT=885.025n

.meas tran vdout0_22ck1760 FIND v(dout0_22) AT=885.025n

.meas tran vdout0_23ck1760 FIND v(dout0_23) AT=885.025n

.meas tran vdout0_24ck1760 FIND v(dout0_24) AT=885.025n

.meas tran vdout0_25ck1760 FIND v(dout0_25) AT=885.025n

.meas tran vdout0_26ck1760 FIND v(dout0_26) AT=885.025n

.meas tran vdout0_27ck1760 FIND v(dout0_27) AT=885.025n

.meas tran vdout0_28ck1760 FIND v(dout0_28) AT=885.025n

.meas tran vdout0_29ck1760 FIND v(dout0_29) AT=885.025n

.meas tran vdout0_30ck1760 FIND v(dout0_30) AT=885.025n

.meas tran vdout0_31ck1760 FIND v(dout0_31) AT=885.025n

.meas tran vdout0_32ck1760 FIND v(dout0_32) AT=885.025n

.meas tran vdout0_33ck1760 FIND v(dout0_33) AT=885.025n

.meas tran vdout0_34ck1760 FIND v(dout0_34) AT=885.025n

.meas tran vdout0_35ck1760 FIND v(dout0_35) AT=885.025n

.meas tran vdout0_36ck1760 FIND v(dout0_36) AT=885.025n

.meas tran vdout0_37ck1760 FIND v(dout0_37) AT=885.025n

.meas tran vdout0_38ck1760 FIND v(dout0_38) AT=885.025n

.meas tran vdout0_39ck1760 FIND v(dout0_39) AT=885.025n

.meas tran vdout0_40ck1760 FIND v(dout0_40) AT=885.025n

.meas tran vdout0_41ck1760 FIND v(dout0_41) AT=885.025n

.meas tran vdout0_42ck1760 FIND v(dout0_42) AT=885.025n

.meas tran vdout0_43ck1760 FIND v(dout0_43) AT=885.025n

.meas tran vdout0_44ck1760 FIND v(dout0_44) AT=885.025n

.meas tran vdout0_45ck1760 FIND v(dout0_45) AT=885.025n

.meas tran vdout0_46ck1760 FIND v(dout0_46) AT=885.025n

.meas tran vdout0_47ck1760 FIND v(dout0_47) AT=885.025n

.meas tran vdout0_48ck1760 FIND v(dout0_48) AT=885.025n

.meas tran vdout0_49ck1760 FIND v(dout0_49) AT=885.025n

.meas tran vdout0_50ck1760 FIND v(dout0_50) AT=885.025n

.meas tran vdout0_51ck1760 FIND v(dout0_51) AT=885.025n

.meas tran vdout0_52ck1760 FIND v(dout0_52) AT=885.025n

.meas tran vdout0_53ck1760 FIND v(dout0_53) AT=885.025n

.meas tran vdout0_54ck1760 FIND v(dout0_54) AT=885.025n

.meas tran vdout0_55ck1760 FIND v(dout0_55) AT=885.025n

.meas tran vdout0_56ck1760 FIND v(dout0_56) AT=885.025n

.meas tran vdout0_57ck1760 FIND v(dout0_57) AT=885.025n

.meas tran vdout0_58ck1760 FIND v(dout0_58) AT=885.025n

.meas tran vdout0_59ck1760 FIND v(dout0_59) AT=885.025n

.meas tran vdout0_60ck1760 FIND v(dout0_60) AT=885.025n

.meas tran vdout0_61ck1760 FIND v(dout0_61) AT=885.025n

.meas tran vdout0_62ck1760 FIND v(dout0_62) AT=885.025n

.meas tran vdout0_63ck1760 FIND v(dout0_63) AT=885.025n

.meas tran vdout0_64ck1760 FIND v(dout0_64) AT=885.025n

.meas tran vdout0_65ck1760 FIND v(dout0_65) AT=885.025n

.meas tran vdout0_66ck1760 FIND v(dout0_66) AT=885.025n

.meas tran vdout0_67ck1760 FIND v(dout0_67) AT=885.025n

.meas tran vdout0_68ck1760 FIND v(dout0_68) AT=885.025n

.meas tran vdout0_69ck1760 FIND v(dout0_69) AT=885.025n

.meas tran vdout0_70ck1760 FIND v(dout0_70) AT=885.025n

.meas tran vdout0_71ck1760 FIND v(dout0_71) AT=885.025n

.meas tran vdout0_72ck1760 FIND v(dout0_72) AT=885.025n

.meas tran vdout0_73ck1760 FIND v(dout0_73) AT=885.025n

.meas tran vdout0_74ck1760 FIND v(dout0_74) AT=885.025n

.meas tran vdout0_75ck1760 FIND v(dout0_75) AT=885.025n

.meas tran vdout0_76ck1760 FIND v(dout0_76) AT=885.025n

.meas tran vdout0_77ck1760 FIND v(dout0_77) AT=885.025n

.meas tran vdout0_78ck1760 FIND v(dout0_78) AT=885.025n

.meas tran vdout0_79ck1760 FIND v(dout0_79) AT=885.025n

.meas tran vdout0_80ck1760 FIND v(dout0_80) AT=885.025n

.meas tran vdout0_81ck1760 FIND v(dout0_81) AT=885.025n

.meas tran vdout0_82ck1760 FIND v(dout0_82) AT=885.025n

.meas tran vdout0_83ck1760 FIND v(dout0_83) AT=885.025n

.meas tran vdout0_84ck1760 FIND v(dout0_84) AT=885.025n

.meas tran vdout0_85ck1760 FIND v(dout0_85) AT=885.025n

.meas tran vdout0_86ck1760 FIND v(dout0_86) AT=885.025n

.meas tran vdout0_87ck1760 FIND v(dout0_87) AT=885.025n

.meas tran vdout0_88ck1760 FIND v(dout0_88) AT=885.025n

.meas tran vdout0_89ck1760 FIND v(dout0_89) AT=885.025n

.meas tran vdout0_90ck1760 FIND v(dout0_90) AT=885.025n

.meas tran vdout0_91ck1760 FIND v(dout0_91) AT=885.025n

.meas tran vdout0_92ck1760 FIND v(dout0_92) AT=885.025n

.meas tran vdout0_93ck1760 FIND v(dout0_93) AT=885.025n

.meas tran vdout0_94ck1760 FIND v(dout0_94) AT=885.025n

.meas tran vdout0_95ck1760 FIND v(dout0_95) AT=885.025n

.meas tran vdout0_96ck1760 FIND v(dout0_96) AT=885.025n

.meas tran vdout0_97ck1760 FIND v(dout0_97) AT=885.025n

.meas tran vdout0_98ck1760 FIND v(dout0_98) AT=885.025n

.meas tran vdout0_99ck1760 FIND v(dout0_99) AT=885.025n

.meas tran vdout0_100ck1760 FIND v(dout0_100) AT=885.025n

.meas tran vdout0_101ck1760 FIND v(dout0_101) AT=885.025n

.meas tran vdout0_102ck1760 FIND v(dout0_102) AT=885.025n

.meas tran vdout0_103ck1760 FIND v(dout0_103) AT=885.025n

.meas tran vdout0_104ck1760 FIND v(dout0_104) AT=885.025n

.meas tran vdout0_105ck1760 FIND v(dout0_105) AT=885.025n

.meas tran vdout0_106ck1760 FIND v(dout0_106) AT=885.025n

.meas tran vdout0_107ck1760 FIND v(dout0_107) AT=885.025n

.meas tran vdout0_108ck1760 FIND v(dout0_108) AT=885.025n

.meas tran vdout0_109ck1760 FIND v(dout0_109) AT=885.025n

.meas tran vdout0_110ck1760 FIND v(dout0_110) AT=885.025n

.meas tran vdout0_111ck1760 FIND v(dout0_111) AT=885.025n

.meas tran vdout0_112ck1760 FIND v(dout0_112) AT=885.025n

.meas tran vdout0_113ck1760 FIND v(dout0_113) AT=885.025n

.meas tran vdout0_114ck1760 FIND v(dout0_114) AT=885.025n

.meas tran vdout0_115ck1760 FIND v(dout0_115) AT=885.025n

.meas tran vdout0_116ck1760 FIND v(dout0_116) AT=885.025n

.meas tran vdout0_117ck1760 FIND v(dout0_117) AT=885.025n

.meas tran vdout0_118ck1760 FIND v(dout0_118) AT=885.025n

.meas tran vdout0_119ck1760 FIND v(dout0_119) AT=885.025n

.meas tran vdout0_120ck1760 FIND v(dout0_120) AT=885.025n

.meas tran vdout0_121ck1760 FIND v(dout0_121) AT=885.025n

.meas tran vdout0_122ck1760 FIND v(dout0_122) AT=885.025n

.meas tran vdout0_123ck1760 FIND v(dout0_123) AT=885.025n

.meas tran vdout0_124ck1760 FIND v(dout0_124) AT=885.025n

.meas tran vdout0_125ck1760 FIND v(dout0_125) AT=885.025n

.meas tran vdout0_126ck1760 FIND v(dout0_126) AT=885.025n

.meas tran vdout0_127ck1760 FIND v(dout0_127) AT=885.025n

.meas tran vdout0_128ck1760 FIND v(dout0_128) AT=885.025n

.meas tran vdout0_129ck1760 FIND v(dout0_129) AT=885.025n

.meas tran vdout0_130ck1760 FIND v(dout0_130) AT=885.025n

.meas tran vdout0_131ck1760 FIND v(dout0_131) AT=885.025n

.meas tran vdout0_132ck1760 FIND v(dout0_132) AT=885.025n

.meas tran vdout0_133ck1760 FIND v(dout0_133) AT=885.025n

.meas tran vdout0_134ck1760 FIND v(dout0_134) AT=885.025n

.meas tran vdout0_135ck1760 FIND v(dout0_135) AT=885.025n

.meas tran vdout0_136ck1760 FIND v(dout0_136) AT=885.025n

.meas tran vdout0_137ck1760 FIND v(dout0_137) AT=885.025n

.meas tran vdout0_138ck1760 FIND v(dout0_138) AT=885.025n

.meas tran vdout0_139ck1760 FIND v(dout0_139) AT=885.025n

.meas tran vdout0_140ck1760 FIND v(dout0_140) AT=885.025n

.meas tran vdout0_141ck1760 FIND v(dout0_141) AT=885.025n

.meas tran vdout0_142ck1760 FIND v(dout0_142) AT=885.025n

.meas tran vdout0_143ck1760 FIND v(dout0_143) AT=885.025n

.meas tran vdout0_144ck1760 FIND v(dout0_144) AT=885.025n

.meas tran vdout0_145ck1760 FIND v(dout0_145) AT=885.025n

.meas tran vdout0_146ck1760 FIND v(dout0_146) AT=885.025n

.meas tran vdout0_147ck1760 FIND v(dout0_147) AT=885.025n

.meas tran vdout0_148ck1760 FIND v(dout0_148) AT=885.025n

.meas tran vdout0_149ck1760 FIND v(dout0_149) AT=885.025n

.meas tran vdout0_150ck1760 FIND v(dout0_150) AT=885.025n

.meas tran vdout0_151ck1760 FIND v(dout0_151) AT=885.025n

.meas tran vdout0_152ck1760 FIND v(dout0_152) AT=885.025n

.meas tran vdout0_153ck1760 FIND v(dout0_153) AT=885.025n

.meas tran vdout0_154ck1760 FIND v(dout0_154) AT=885.025n

.meas tran vdout0_155ck1760 FIND v(dout0_155) AT=885.025n

.meas tran vdout0_156ck1760 FIND v(dout0_156) AT=885.025n

.meas tran vdout0_157ck1760 FIND v(dout0_157) AT=885.025n

.meas tran vdout0_158ck1760 FIND v(dout0_158) AT=885.025n

.meas tran vdout0_159ck1760 FIND v(dout0_159) AT=885.025n

.meas tran vdout0_160ck1760 FIND v(dout0_160) AT=885.025n

.meas tran vdout0_161ck1760 FIND v(dout0_161) AT=885.025n

.meas tran vdout0_162ck1760 FIND v(dout0_162) AT=885.025n

.meas tran vdout0_163ck1760 FIND v(dout0_163) AT=885.025n

.meas tran vdout0_164ck1760 FIND v(dout0_164) AT=885.025n

.meas tran vdout0_165ck1760 FIND v(dout0_165) AT=885.025n

.meas tran vdout0_166ck1760 FIND v(dout0_166) AT=885.025n

.meas tran vdout0_167ck1760 FIND v(dout0_167) AT=885.025n

.meas tran vdout0_168ck1760 FIND v(dout0_168) AT=885.025n

.meas tran vdout0_169ck1760 FIND v(dout0_169) AT=885.025n

.meas tran vdout0_170ck1760 FIND v(dout0_170) AT=885.025n

.meas tran vdout0_171ck1760 FIND v(dout0_171) AT=885.025n

.meas tran vdout0_172ck1760 FIND v(dout0_172) AT=885.025n

.meas tran vdout0_173ck1760 FIND v(dout0_173) AT=885.025n

.meas tran vdout0_174ck1760 FIND v(dout0_174) AT=885.025n

.meas tran vdout0_175ck1760 FIND v(dout0_175) AT=885.025n

.meas tran vdout0_176ck1760 FIND v(dout0_176) AT=885.025n

.meas tran vdout0_177ck1760 FIND v(dout0_177) AT=885.025n

.meas tran vdout0_178ck1760 FIND v(dout0_178) AT=885.025n

.meas tran vdout0_179ck1760 FIND v(dout0_179) AT=885.025n

.meas tran vdout0_180ck1760 FIND v(dout0_180) AT=885.025n

.meas tran vdout0_181ck1760 FIND v(dout0_181) AT=885.025n

.meas tran vdout0_182ck1760 FIND v(dout0_182) AT=885.025n

.meas tran vdout0_183ck1760 FIND v(dout0_183) AT=885.025n

.meas tran vdout0_184ck1760 FIND v(dout0_184) AT=885.025n

.meas tran vdout0_185ck1760 FIND v(dout0_185) AT=885.025n

.meas tran vdout0_186ck1760 FIND v(dout0_186) AT=885.025n

.meas tran vdout0_187ck1760 FIND v(dout0_187) AT=885.025n

.meas tran vdout0_188ck1760 FIND v(dout0_188) AT=885.025n

.meas tran vdout0_189ck1760 FIND v(dout0_189) AT=885.025n

.meas tran vdout0_190ck1760 FIND v(dout0_190) AT=885.025n

.meas tran vdout0_191ck1760 FIND v(dout0_191) AT=885.025n

.meas tran vdout0_192ck1760 FIND v(dout0_192) AT=885.025n

.meas tran vdout0_193ck1760 FIND v(dout0_193) AT=885.025n

.meas tran vdout0_194ck1760 FIND v(dout0_194) AT=885.025n

.meas tran vdout0_195ck1760 FIND v(dout0_195) AT=885.025n

.meas tran vdout0_196ck1760 FIND v(dout0_196) AT=885.025n

.meas tran vdout0_197ck1760 FIND v(dout0_197) AT=885.025n

.meas tran vdout0_198ck1760 FIND v(dout0_198) AT=885.025n

.meas tran vdout0_199ck1760 FIND v(dout0_199) AT=885.025n

.meas tran vdout0_200ck1760 FIND v(dout0_200) AT=885.025n

.meas tran vdout0_201ck1760 FIND v(dout0_201) AT=885.025n

.meas tran vdout0_202ck1760 FIND v(dout0_202) AT=885.025n

.meas tran vdout0_203ck1760 FIND v(dout0_203) AT=885.025n

.meas tran vdout0_204ck1760 FIND v(dout0_204) AT=885.025n

.meas tran vdout0_205ck1760 FIND v(dout0_205) AT=885.025n

.meas tran vdout0_206ck1760 FIND v(dout0_206) AT=885.025n

.meas tran vdout0_207ck1760 FIND v(dout0_207) AT=885.025n

.meas tran vdout0_208ck1760 FIND v(dout0_208) AT=885.025n

.meas tran vdout0_209ck1760 FIND v(dout0_209) AT=885.025n

.meas tran vdout0_210ck1760 FIND v(dout0_210) AT=885.025n

.meas tran vdout0_211ck1760 FIND v(dout0_211) AT=885.025n

.meas tran vdout0_212ck1760 FIND v(dout0_212) AT=885.025n

.meas tran vdout0_213ck1760 FIND v(dout0_213) AT=885.025n

.meas tran vdout0_214ck1760 FIND v(dout0_214) AT=885.025n

.meas tran vdout0_215ck1760 FIND v(dout0_215) AT=885.025n

.meas tran vdout0_216ck1760 FIND v(dout0_216) AT=885.025n

.meas tran vdout0_217ck1760 FIND v(dout0_217) AT=885.025n

.meas tran vdout0_218ck1760 FIND v(dout0_218) AT=885.025n

.meas tran vdout0_219ck1760 FIND v(dout0_219) AT=885.025n

.meas tran vdout0_220ck1760 FIND v(dout0_220) AT=885.025n

.meas tran vdout0_221ck1760 FIND v(dout0_221) AT=885.025n

.meas tran vdout0_222ck1760 FIND v(dout0_222) AT=885.025n

.meas tran vdout0_223ck1760 FIND v(dout0_223) AT=885.025n

.meas tran vdout0_224ck1760 FIND v(dout0_224) AT=885.025n

.meas tran vdout0_225ck1760 FIND v(dout0_225) AT=885.025n

.meas tran vdout0_226ck1760 FIND v(dout0_226) AT=885.025n

.meas tran vdout0_227ck1760 FIND v(dout0_227) AT=885.025n

.meas tran vdout0_228ck1760 FIND v(dout0_228) AT=885.025n

.meas tran vdout0_229ck1760 FIND v(dout0_229) AT=885.025n

.meas tran vdout0_230ck1760 FIND v(dout0_230) AT=885.025n

.meas tran vdout0_231ck1760 FIND v(dout0_231) AT=885.025n

.meas tran vdout0_232ck1760 FIND v(dout0_232) AT=885.025n

.meas tran vdout0_233ck1760 FIND v(dout0_233) AT=885.025n

.meas tran vdout0_234ck1760 FIND v(dout0_234) AT=885.025n

.meas tran vdout0_235ck1760 FIND v(dout0_235) AT=885.025n

.meas tran vdout0_236ck1760 FIND v(dout0_236) AT=885.025n

.meas tran vdout0_237ck1760 FIND v(dout0_237) AT=885.025n

.meas tran vdout0_238ck1760 FIND v(dout0_238) AT=885.025n

.meas tran vdout0_239ck1760 FIND v(dout0_239) AT=885.025n

.meas tran vdout0_240ck1760 FIND v(dout0_240) AT=885.025n

.meas tran vdout0_241ck1760 FIND v(dout0_241) AT=885.025n

.meas tran vdout0_242ck1760 FIND v(dout0_242) AT=885.025n

.meas tran vdout0_243ck1760 FIND v(dout0_243) AT=885.025n

.meas tran vdout0_244ck1760 FIND v(dout0_244) AT=885.025n

.meas tran vdout0_245ck1760 FIND v(dout0_245) AT=885.025n

.meas tran vdout0_246ck1760 FIND v(dout0_246) AT=885.025n

.meas tran vdout0_247ck1760 FIND v(dout0_247) AT=885.025n

.meas tran vdout0_248ck1760 FIND v(dout0_248) AT=885.025n

.meas tran vdout0_249ck1760 FIND v(dout0_249) AT=885.025n

.meas tran vdout0_250ck1760 FIND v(dout0_250) AT=885.025n

.meas tran vdout0_251ck1760 FIND v(dout0_251) AT=885.025n

.meas tran vdout0_252ck1760 FIND v(dout0_252) AT=885.025n

.meas tran vdout0_253ck1760 FIND v(dout0_253) AT=885.025n

.meas tran vdout0_254ck1760 FIND v(dout0_254) AT=885.025n

.meas tran vdout0_255ck1760 FIND v(dout0_255) AT=885.025n

.meas tran vdout0_0ck1800 FIND v(dout0_0) AT=905.025n

.meas tran vdout0_1ck1800 FIND v(dout0_1) AT=905.025n

.meas tran vdout0_2ck1800 FIND v(dout0_2) AT=905.025n

.meas tran vdout0_3ck1800 FIND v(dout0_3) AT=905.025n

.meas tran vdout0_4ck1800 FIND v(dout0_4) AT=905.025n

.meas tran vdout0_5ck1800 FIND v(dout0_5) AT=905.025n

.meas tran vdout0_6ck1800 FIND v(dout0_6) AT=905.025n

.meas tran vdout0_7ck1800 FIND v(dout0_7) AT=905.025n

.meas tran vdout0_8ck1800 FIND v(dout0_8) AT=905.025n

.meas tran vdout0_9ck1800 FIND v(dout0_9) AT=905.025n

.meas tran vdout0_10ck1800 FIND v(dout0_10) AT=905.025n

.meas tran vdout0_11ck1800 FIND v(dout0_11) AT=905.025n

.meas tran vdout0_12ck1800 FIND v(dout0_12) AT=905.025n

.meas tran vdout0_13ck1800 FIND v(dout0_13) AT=905.025n

.meas tran vdout0_14ck1800 FIND v(dout0_14) AT=905.025n

.meas tran vdout0_15ck1800 FIND v(dout0_15) AT=905.025n

.meas tran vdout0_16ck1800 FIND v(dout0_16) AT=905.025n

.meas tran vdout0_17ck1800 FIND v(dout0_17) AT=905.025n

.meas tran vdout0_18ck1800 FIND v(dout0_18) AT=905.025n

.meas tran vdout0_19ck1800 FIND v(dout0_19) AT=905.025n

.meas tran vdout0_20ck1800 FIND v(dout0_20) AT=905.025n

.meas tran vdout0_21ck1800 FIND v(dout0_21) AT=905.025n

.meas tran vdout0_22ck1800 FIND v(dout0_22) AT=905.025n

.meas tran vdout0_23ck1800 FIND v(dout0_23) AT=905.025n

.meas tran vdout0_24ck1800 FIND v(dout0_24) AT=905.025n

.meas tran vdout0_25ck1800 FIND v(dout0_25) AT=905.025n

.meas tran vdout0_26ck1800 FIND v(dout0_26) AT=905.025n

.meas tran vdout0_27ck1800 FIND v(dout0_27) AT=905.025n

.meas tran vdout0_28ck1800 FIND v(dout0_28) AT=905.025n

.meas tran vdout0_29ck1800 FIND v(dout0_29) AT=905.025n

.meas tran vdout0_30ck1800 FIND v(dout0_30) AT=905.025n

.meas tran vdout0_31ck1800 FIND v(dout0_31) AT=905.025n

.meas tran vdout0_32ck1800 FIND v(dout0_32) AT=905.025n

.meas tran vdout0_33ck1800 FIND v(dout0_33) AT=905.025n

.meas tran vdout0_34ck1800 FIND v(dout0_34) AT=905.025n

.meas tran vdout0_35ck1800 FIND v(dout0_35) AT=905.025n

.meas tran vdout0_36ck1800 FIND v(dout0_36) AT=905.025n

.meas tran vdout0_37ck1800 FIND v(dout0_37) AT=905.025n

.meas tran vdout0_38ck1800 FIND v(dout0_38) AT=905.025n

.meas tran vdout0_39ck1800 FIND v(dout0_39) AT=905.025n

.meas tran vdout0_40ck1800 FIND v(dout0_40) AT=905.025n

.meas tran vdout0_41ck1800 FIND v(dout0_41) AT=905.025n

.meas tran vdout0_42ck1800 FIND v(dout0_42) AT=905.025n

.meas tran vdout0_43ck1800 FIND v(dout0_43) AT=905.025n

.meas tran vdout0_44ck1800 FIND v(dout0_44) AT=905.025n

.meas tran vdout0_45ck1800 FIND v(dout0_45) AT=905.025n

.meas tran vdout0_46ck1800 FIND v(dout0_46) AT=905.025n

.meas tran vdout0_47ck1800 FIND v(dout0_47) AT=905.025n

.meas tran vdout0_48ck1800 FIND v(dout0_48) AT=905.025n

.meas tran vdout0_49ck1800 FIND v(dout0_49) AT=905.025n

.meas tran vdout0_50ck1800 FIND v(dout0_50) AT=905.025n

.meas tran vdout0_51ck1800 FIND v(dout0_51) AT=905.025n

.meas tran vdout0_52ck1800 FIND v(dout0_52) AT=905.025n

.meas tran vdout0_53ck1800 FIND v(dout0_53) AT=905.025n

.meas tran vdout0_54ck1800 FIND v(dout0_54) AT=905.025n

.meas tran vdout0_55ck1800 FIND v(dout0_55) AT=905.025n

.meas tran vdout0_56ck1800 FIND v(dout0_56) AT=905.025n

.meas tran vdout0_57ck1800 FIND v(dout0_57) AT=905.025n

.meas tran vdout0_58ck1800 FIND v(dout0_58) AT=905.025n

.meas tran vdout0_59ck1800 FIND v(dout0_59) AT=905.025n

.meas tran vdout0_60ck1800 FIND v(dout0_60) AT=905.025n

.meas tran vdout0_61ck1800 FIND v(dout0_61) AT=905.025n

.meas tran vdout0_62ck1800 FIND v(dout0_62) AT=905.025n

.meas tran vdout0_63ck1800 FIND v(dout0_63) AT=905.025n

.meas tran vdout0_64ck1800 FIND v(dout0_64) AT=905.025n

.meas tran vdout0_65ck1800 FIND v(dout0_65) AT=905.025n

.meas tran vdout0_66ck1800 FIND v(dout0_66) AT=905.025n

.meas tran vdout0_67ck1800 FIND v(dout0_67) AT=905.025n

.meas tran vdout0_68ck1800 FIND v(dout0_68) AT=905.025n

.meas tran vdout0_69ck1800 FIND v(dout0_69) AT=905.025n

.meas tran vdout0_70ck1800 FIND v(dout0_70) AT=905.025n

.meas tran vdout0_71ck1800 FIND v(dout0_71) AT=905.025n

.meas tran vdout0_72ck1800 FIND v(dout0_72) AT=905.025n

.meas tran vdout0_73ck1800 FIND v(dout0_73) AT=905.025n

.meas tran vdout0_74ck1800 FIND v(dout0_74) AT=905.025n

.meas tran vdout0_75ck1800 FIND v(dout0_75) AT=905.025n

.meas tran vdout0_76ck1800 FIND v(dout0_76) AT=905.025n

.meas tran vdout0_77ck1800 FIND v(dout0_77) AT=905.025n

.meas tran vdout0_78ck1800 FIND v(dout0_78) AT=905.025n

.meas tran vdout0_79ck1800 FIND v(dout0_79) AT=905.025n

.meas tran vdout0_80ck1800 FIND v(dout0_80) AT=905.025n

.meas tran vdout0_81ck1800 FIND v(dout0_81) AT=905.025n

.meas tran vdout0_82ck1800 FIND v(dout0_82) AT=905.025n

.meas tran vdout0_83ck1800 FIND v(dout0_83) AT=905.025n

.meas tran vdout0_84ck1800 FIND v(dout0_84) AT=905.025n

.meas tran vdout0_85ck1800 FIND v(dout0_85) AT=905.025n

.meas tran vdout0_86ck1800 FIND v(dout0_86) AT=905.025n

.meas tran vdout0_87ck1800 FIND v(dout0_87) AT=905.025n

.meas tran vdout0_88ck1800 FIND v(dout0_88) AT=905.025n

.meas tran vdout0_89ck1800 FIND v(dout0_89) AT=905.025n

.meas tran vdout0_90ck1800 FIND v(dout0_90) AT=905.025n

.meas tran vdout0_91ck1800 FIND v(dout0_91) AT=905.025n

.meas tran vdout0_92ck1800 FIND v(dout0_92) AT=905.025n

.meas tran vdout0_93ck1800 FIND v(dout0_93) AT=905.025n

.meas tran vdout0_94ck1800 FIND v(dout0_94) AT=905.025n

.meas tran vdout0_95ck1800 FIND v(dout0_95) AT=905.025n

.meas tran vdout0_96ck1800 FIND v(dout0_96) AT=905.025n

.meas tran vdout0_97ck1800 FIND v(dout0_97) AT=905.025n

.meas tran vdout0_98ck1800 FIND v(dout0_98) AT=905.025n

.meas tran vdout0_99ck1800 FIND v(dout0_99) AT=905.025n

.meas tran vdout0_100ck1800 FIND v(dout0_100) AT=905.025n

.meas tran vdout0_101ck1800 FIND v(dout0_101) AT=905.025n

.meas tran vdout0_102ck1800 FIND v(dout0_102) AT=905.025n

.meas tran vdout0_103ck1800 FIND v(dout0_103) AT=905.025n

.meas tran vdout0_104ck1800 FIND v(dout0_104) AT=905.025n

.meas tran vdout0_105ck1800 FIND v(dout0_105) AT=905.025n

.meas tran vdout0_106ck1800 FIND v(dout0_106) AT=905.025n

.meas tran vdout0_107ck1800 FIND v(dout0_107) AT=905.025n

.meas tran vdout0_108ck1800 FIND v(dout0_108) AT=905.025n

.meas tran vdout0_109ck1800 FIND v(dout0_109) AT=905.025n

.meas tran vdout0_110ck1800 FIND v(dout0_110) AT=905.025n

.meas tran vdout0_111ck1800 FIND v(dout0_111) AT=905.025n

.meas tran vdout0_112ck1800 FIND v(dout0_112) AT=905.025n

.meas tran vdout0_113ck1800 FIND v(dout0_113) AT=905.025n

.meas tran vdout0_114ck1800 FIND v(dout0_114) AT=905.025n

.meas tran vdout0_115ck1800 FIND v(dout0_115) AT=905.025n

.meas tran vdout0_116ck1800 FIND v(dout0_116) AT=905.025n

.meas tran vdout0_117ck1800 FIND v(dout0_117) AT=905.025n

.meas tran vdout0_118ck1800 FIND v(dout0_118) AT=905.025n

.meas tran vdout0_119ck1800 FIND v(dout0_119) AT=905.025n

.meas tran vdout0_120ck1800 FIND v(dout0_120) AT=905.025n

.meas tran vdout0_121ck1800 FIND v(dout0_121) AT=905.025n

.meas tran vdout0_122ck1800 FIND v(dout0_122) AT=905.025n

.meas tran vdout0_123ck1800 FIND v(dout0_123) AT=905.025n

.meas tran vdout0_124ck1800 FIND v(dout0_124) AT=905.025n

.meas tran vdout0_125ck1800 FIND v(dout0_125) AT=905.025n

.meas tran vdout0_126ck1800 FIND v(dout0_126) AT=905.025n

.meas tran vdout0_127ck1800 FIND v(dout0_127) AT=905.025n

.meas tran vdout0_128ck1800 FIND v(dout0_128) AT=905.025n

.meas tran vdout0_129ck1800 FIND v(dout0_129) AT=905.025n

.meas tran vdout0_130ck1800 FIND v(dout0_130) AT=905.025n

.meas tran vdout0_131ck1800 FIND v(dout0_131) AT=905.025n

.meas tran vdout0_132ck1800 FIND v(dout0_132) AT=905.025n

.meas tran vdout0_133ck1800 FIND v(dout0_133) AT=905.025n

.meas tran vdout0_134ck1800 FIND v(dout0_134) AT=905.025n

.meas tran vdout0_135ck1800 FIND v(dout0_135) AT=905.025n

.meas tran vdout0_136ck1800 FIND v(dout0_136) AT=905.025n

.meas tran vdout0_137ck1800 FIND v(dout0_137) AT=905.025n

.meas tran vdout0_138ck1800 FIND v(dout0_138) AT=905.025n

.meas tran vdout0_139ck1800 FIND v(dout0_139) AT=905.025n

.meas tran vdout0_140ck1800 FIND v(dout0_140) AT=905.025n

.meas tran vdout0_141ck1800 FIND v(dout0_141) AT=905.025n

.meas tran vdout0_142ck1800 FIND v(dout0_142) AT=905.025n

.meas tran vdout0_143ck1800 FIND v(dout0_143) AT=905.025n

.meas tran vdout0_144ck1800 FIND v(dout0_144) AT=905.025n

.meas tran vdout0_145ck1800 FIND v(dout0_145) AT=905.025n

.meas tran vdout0_146ck1800 FIND v(dout0_146) AT=905.025n

.meas tran vdout0_147ck1800 FIND v(dout0_147) AT=905.025n

.meas tran vdout0_148ck1800 FIND v(dout0_148) AT=905.025n

.meas tran vdout0_149ck1800 FIND v(dout0_149) AT=905.025n

.meas tran vdout0_150ck1800 FIND v(dout0_150) AT=905.025n

.meas tran vdout0_151ck1800 FIND v(dout0_151) AT=905.025n

.meas tran vdout0_152ck1800 FIND v(dout0_152) AT=905.025n

.meas tran vdout0_153ck1800 FIND v(dout0_153) AT=905.025n

.meas tran vdout0_154ck1800 FIND v(dout0_154) AT=905.025n

.meas tran vdout0_155ck1800 FIND v(dout0_155) AT=905.025n

.meas tran vdout0_156ck1800 FIND v(dout0_156) AT=905.025n

.meas tran vdout0_157ck1800 FIND v(dout0_157) AT=905.025n

.meas tran vdout0_158ck1800 FIND v(dout0_158) AT=905.025n

.meas tran vdout0_159ck1800 FIND v(dout0_159) AT=905.025n

.meas tran vdout0_160ck1800 FIND v(dout0_160) AT=905.025n

.meas tran vdout0_161ck1800 FIND v(dout0_161) AT=905.025n

.meas tran vdout0_162ck1800 FIND v(dout0_162) AT=905.025n

.meas tran vdout0_163ck1800 FIND v(dout0_163) AT=905.025n

.meas tran vdout0_164ck1800 FIND v(dout0_164) AT=905.025n

.meas tran vdout0_165ck1800 FIND v(dout0_165) AT=905.025n

.meas tran vdout0_166ck1800 FIND v(dout0_166) AT=905.025n

.meas tran vdout0_167ck1800 FIND v(dout0_167) AT=905.025n

.meas tran vdout0_168ck1800 FIND v(dout0_168) AT=905.025n

.meas tran vdout0_169ck1800 FIND v(dout0_169) AT=905.025n

.meas tran vdout0_170ck1800 FIND v(dout0_170) AT=905.025n

.meas tran vdout0_171ck1800 FIND v(dout0_171) AT=905.025n

.meas tran vdout0_172ck1800 FIND v(dout0_172) AT=905.025n

.meas tran vdout0_173ck1800 FIND v(dout0_173) AT=905.025n

.meas tran vdout0_174ck1800 FIND v(dout0_174) AT=905.025n

.meas tran vdout0_175ck1800 FIND v(dout0_175) AT=905.025n

.meas tran vdout0_176ck1800 FIND v(dout0_176) AT=905.025n

.meas tran vdout0_177ck1800 FIND v(dout0_177) AT=905.025n

.meas tran vdout0_178ck1800 FIND v(dout0_178) AT=905.025n

.meas tran vdout0_179ck1800 FIND v(dout0_179) AT=905.025n

.meas tran vdout0_180ck1800 FIND v(dout0_180) AT=905.025n

.meas tran vdout0_181ck1800 FIND v(dout0_181) AT=905.025n

.meas tran vdout0_182ck1800 FIND v(dout0_182) AT=905.025n

.meas tran vdout0_183ck1800 FIND v(dout0_183) AT=905.025n

.meas tran vdout0_184ck1800 FIND v(dout0_184) AT=905.025n

.meas tran vdout0_185ck1800 FIND v(dout0_185) AT=905.025n

.meas tran vdout0_186ck1800 FIND v(dout0_186) AT=905.025n

.meas tran vdout0_187ck1800 FIND v(dout0_187) AT=905.025n

.meas tran vdout0_188ck1800 FIND v(dout0_188) AT=905.025n

.meas tran vdout0_189ck1800 FIND v(dout0_189) AT=905.025n

.meas tran vdout0_190ck1800 FIND v(dout0_190) AT=905.025n

.meas tran vdout0_191ck1800 FIND v(dout0_191) AT=905.025n

.meas tran vdout0_192ck1800 FIND v(dout0_192) AT=905.025n

.meas tran vdout0_193ck1800 FIND v(dout0_193) AT=905.025n

.meas tran vdout0_194ck1800 FIND v(dout0_194) AT=905.025n

.meas tran vdout0_195ck1800 FIND v(dout0_195) AT=905.025n

.meas tran vdout0_196ck1800 FIND v(dout0_196) AT=905.025n

.meas tran vdout0_197ck1800 FIND v(dout0_197) AT=905.025n

.meas tran vdout0_198ck1800 FIND v(dout0_198) AT=905.025n

.meas tran vdout0_199ck1800 FIND v(dout0_199) AT=905.025n

.meas tran vdout0_200ck1800 FIND v(dout0_200) AT=905.025n

.meas tran vdout0_201ck1800 FIND v(dout0_201) AT=905.025n

.meas tran vdout0_202ck1800 FIND v(dout0_202) AT=905.025n

.meas tran vdout0_203ck1800 FIND v(dout0_203) AT=905.025n

.meas tran vdout0_204ck1800 FIND v(dout0_204) AT=905.025n

.meas tran vdout0_205ck1800 FIND v(dout0_205) AT=905.025n

.meas tran vdout0_206ck1800 FIND v(dout0_206) AT=905.025n

.meas tran vdout0_207ck1800 FIND v(dout0_207) AT=905.025n

.meas tran vdout0_208ck1800 FIND v(dout0_208) AT=905.025n

.meas tran vdout0_209ck1800 FIND v(dout0_209) AT=905.025n

.meas tran vdout0_210ck1800 FIND v(dout0_210) AT=905.025n

.meas tran vdout0_211ck1800 FIND v(dout0_211) AT=905.025n

.meas tran vdout0_212ck1800 FIND v(dout0_212) AT=905.025n

.meas tran vdout0_213ck1800 FIND v(dout0_213) AT=905.025n

.meas tran vdout0_214ck1800 FIND v(dout0_214) AT=905.025n

.meas tran vdout0_215ck1800 FIND v(dout0_215) AT=905.025n

.meas tran vdout0_216ck1800 FIND v(dout0_216) AT=905.025n

.meas tran vdout0_217ck1800 FIND v(dout0_217) AT=905.025n

.meas tran vdout0_218ck1800 FIND v(dout0_218) AT=905.025n

.meas tran vdout0_219ck1800 FIND v(dout0_219) AT=905.025n

.meas tran vdout0_220ck1800 FIND v(dout0_220) AT=905.025n

.meas tran vdout0_221ck1800 FIND v(dout0_221) AT=905.025n

.meas tran vdout0_222ck1800 FIND v(dout0_222) AT=905.025n

.meas tran vdout0_223ck1800 FIND v(dout0_223) AT=905.025n

.meas tran vdout0_224ck1800 FIND v(dout0_224) AT=905.025n

.meas tran vdout0_225ck1800 FIND v(dout0_225) AT=905.025n

.meas tran vdout0_226ck1800 FIND v(dout0_226) AT=905.025n

.meas tran vdout0_227ck1800 FIND v(dout0_227) AT=905.025n

.meas tran vdout0_228ck1800 FIND v(dout0_228) AT=905.025n

.meas tran vdout0_229ck1800 FIND v(dout0_229) AT=905.025n

.meas tran vdout0_230ck1800 FIND v(dout0_230) AT=905.025n

.meas tran vdout0_231ck1800 FIND v(dout0_231) AT=905.025n

.meas tran vdout0_232ck1800 FIND v(dout0_232) AT=905.025n

.meas tran vdout0_233ck1800 FIND v(dout0_233) AT=905.025n

.meas tran vdout0_234ck1800 FIND v(dout0_234) AT=905.025n

.meas tran vdout0_235ck1800 FIND v(dout0_235) AT=905.025n

.meas tran vdout0_236ck1800 FIND v(dout0_236) AT=905.025n

.meas tran vdout0_237ck1800 FIND v(dout0_237) AT=905.025n

.meas tran vdout0_238ck1800 FIND v(dout0_238) AT=905.025n

.meas tran vdout0_239ck1800 FIND v(dout0_239) AT=905.025n

.meas tran vdout0_240ck1800 FIND v(dout0_240) AT=905.025n

.meas tran vdout0_241ck1800 FIND v(dout0_241) AT=905.025n

.meas tran vdout0_242ck1800 FIND v(dout0_242) AT=905.025n

.meas tran vdout0_243ck1800 FIND v(dout0_243) AT=905.025n

.meas tran vdout0_244ck1800 FIND v(dout0_244) AT=905.025n

.meas tran vdout0_245ck1800 FIND v(dout0_245) AT=905.025n

.meas tran vdout0_246ck1800 FIND v(dout0_246) AT=905.025n

.meas tran vdout0_247ck1800 FIND v(dout0_247) AT=905.025n

.meas tran vdout0_248ck1800 FIND v(dout0_248) AT=905.025n

.meas tran vdout0_249ck1800 FIND v(dout0_249) AT=905.025n

.meas tran vdout0_250ck1800 FIND v(dout0_250) AT=905.025n

.meas tran vdout0_251ck1800 FIND v(dout0_251) AT=905.025n

.meas tran vdout0_252ck1800 FIND v(dout0_252) AT=905.025n

.meas tran vdout0_253ck1800 FIND v(dout0_253) AT=905.025n

.meas tran vdout0_254ck1800 FIND v(dout0_254) AT=905.025n

.meas tran vdout0_255ck1800 FIND v(dout0_255) AT=905.025n

.meas tran vdout0_0ck1820 FIND v(dout0_0) AT=915.025n

.meas tran vdout0_1ck1820 FIND v(dout0_1) AT=915.025n

.meas tran vdout0_2ck1820 FIND v(dout0_2) AT=915.025n

.meas tran vdout0_3ck1820 FIND v(dout0_3) AT=915.025n

.meas tran vdout0_4ck1820 FIND v(dout0_4) AT=915.025n

.meas tran vdout0_5ck1820 FIND v(dout0_5) AT=915.025n

.meas tran vdout0_6ck1820 FIND v(dout0_6) AT=915.025n

.meas tran vdout0_7ck1820 FIND v(dout0_7) AT=915.025n

.meas tran vdout0_8ck1820 FIND v(dout0_8) AT=915.025n

.meas tran vdout0_9ck1820 FIND v(dout0_9) AT=915.025n

.meas tran vdout0_10ck1820 FIND v(dout0_10) AT=915.025n

.meas tran vdout0_11ck1820 FIND v(dout0_11) AT=915.025n

.meas tran vdout0_12ck1820 FIND v(dout0_12) AT=915.025n

.meas tran vdout0_13ck1820 FIND v(dout0_13) AT=915.025n

.meas tran vdout0_14ck1820 FIND v(dout0_14) AT=915.025n

.meas tran vdout0_15ck1820 FIND v(dout0_15) AT=915.025n

.meas tran vdout0_16ck1820 FIND v(dout0_16) AT=915.025n

.meas tran vdout0_17ck1820 FIND v(dout0_17) AT=915.025n

.meas tran vdout0_18ck1820 FIND v(dout0_18) AT=915.025n

.meas tran vdout0_19ck1820 FIND v(dout0_19) AT=915.025n

.meas tran vdout0_20ck1820 FIND v(dout0_20) AT=915.025n

.meas tran vdout0_21ck1820 FIND v(dout0_21) AT=915.025n

.meas tran vdout0_22ck1820 FIND v(dout0_22) AT=915.025n

.meas tran vdout0_23ck1820 FIND v(dout0_23) AT=915.025n

.meas tran vdout0_24ck1820 FIND v(dout0_24) AT=915.025n

.meas tran vdout0_25ck1820 FIND v(dout0_25) AT=915.025n

.meas tran vdout0_26ck1820 FIND v(dout0_26) AT=915.025n

.meas tran vdout0_27ck1820 FIND v(dout0_27) AT=915.025n

.meas tran vdout0_28ck1820 FIND v(dout0_28) AT=915.025n

.meas tran vdout0_29ck1820 FIND v(dout0_29) AT=915.025n

.meas tran vdout0_30ck1820 FIND v(dout0_30) AT=915.025n

.meas tran vdout0_31ck1820 FIND v(dout0_31) AT=915.025n

.meas tran vdout0_32ck1820 FIND v(dout0_32) AT=915.025n

.meas tran vdout0_33ck1820 FIND v(dout0_33) AT=915.025n

.meas tran vdout0_34ck1820 FIND v(dout0_34) AT=915.025n

.meas tran vdout0_35ck1820 FIND v(dout0_35) AT=915.025n

.meas tran vdout0_36ck1820 FIND v(dout0_36) AT=915.025n

.meas tran vdout0_37ck1820 FIND v(dout0_37) AT=915.025n

.meas tran vdout0_38ck1820 FIND v(dout0_38) AT=915.025n

.meas tran vdout0_39ck1820 FIND v(dout0_39) AT=915.025n

.meas tran vdout0_40ck1820 FIND v(dout0_40) AT=915.025n

.meas tran vdout0_41ck1820 FIND v(dout0_41) AT=915.025n

.meas tran vdout0_42ck1820 FIND v(dout0_42) AT=915.025n

.meas tran vdout0_43ck1820 FIND v(dout0_43) AT=915.025n

.meas tran vdout0_44ck1820 FIND v(dout0_44) AT=915.025n

.meas tran vdout0_45ck1820 FIND v(dout0_45) AT=915.025n

.meas tran vdout0_46ck1820 FIND v(dout0_46) AT=915.025n

.meas tran vdout0_47ck1820 FIND v(dout0_47) AT=915.025n

.meas tran vdout0_48ck1820 FIND v(dout0_48) AT=915.025n

.meas tran vdout0_49ck1820 FIND v(dout0_49) AT=915.025n

.meas tran vdout0_50ck1820 FIND v(dout0_50) AT=915.025n

.meas tran vdout0_51ck1820 FIND v(dout0_51) AT=915.025n

.meas tran vdout0_52ck1820 FIND v(dout0_52) AT=915.025n

.meas tran vdout0_53ck1820 FIND v(dout0_53) AT=915.025n

.meas tran vdout0_54ck1820 FIND v(dout0_54) AT=915.025n

.meas tran vdout0_55ck1820 FIND v(dout0_55) AT=915.025n

.meas tran vdout0_56ck1820 FIND v(dout0_56) AT=915.025n

.meas tran vdout0_57ck1820 FIND v(dout0_57) AT=915.025n

.meas tran vdout0_58ck1820 FIND v(dout0_58) AT=915.025n

.meas tran vdout0_59ck1820 FIND v(dout0_59) AT=915.025n

.meas tran vdout0_60ck1820 FIND v(dout0_60) AT=915.025n

.meas tran vdout0_61ck1820 FIND v(dout0_61) AT=915.025n

.meas tran vdout0_62ck1820 FIND v(dout0_62) AT=915.025n

.meas tran vdout0_63ck1820 FIND v(dout0_63) AT=915.025n

.meas tran vdout0_64ck1820 FIND v(dout0_64) AT=915.025n

.meas tran vdout0_65ck1820 FIND v(dout0_65) AT=915.025n

.meas tran vdout0_66ck1820 FIND v(dout0_66) AT=915.025n

.meas tran vdout0_67ck1820 FIND v(dout0_67) AT=915.025n

.meas tran vdout0_68ck1820 FIND v(dout0_68) AT=915.025n

.meas tran vdout0_69ck1820 FIND v(dout0_69) AT=915.025n

.meas tran vdout0_70ck1820 FIND v(dout0_70) AT=915.025n

.meas tran vdout0_71ck1820 FIND v(dout0_71) AT=915.025n

.meas tran vdout0_72ck1820 FIND v(dout0_72) AT=915.025n

.meas tran vdout0_73ck1820 FIND v(dout0_73) AT=915.025n

.meas tran vdout0_74ck1820 FIND v(dout0_74) AT=915.025n

.meas tran vdout0_75ck1820 FIND v(dout0_75) AT=915.025n

.meas tran vdout0_76ck1820 FIND v(dout0_76) AT=915.025n

.meas tran vdout0_77ck1820 FIND v(dout0_77) AT=915.025n

.meas tran vdout0_78ck1820 FIND v(dout0_78) AT=915.025n

.meas tran vdout0_79ck1820 FIND v(dout0_79) AT=915.025n

.meas tran vdout0_80ck1820 FIND v(dout0_80) AT=915.025n

.meas tran vdout0_81ck1820 FIND v(dout0_81) AT=915.025n

.meas tran vdout0_82ck1820 FIND v(dout0_82) AT=915.025n

.meas tran vdout0_83ck1820 FIND v(dout0_83) AT=915.025n

.meas tran vdout0_84ck1820 FIND v(dout0_84) AT=915.025n

.meas tran vdout0_85ck1820 FIND v(dout0_85) AT=915.025n

.meas tran vdout0_86ck1820 FIND v(dout0_86) AT=915.025n

.meas tran vdout0_87ck1820 FIND v(dout0_87) AT=915.025n

.meas tran vdout0_88ck1820 FIND v(dout0_88) AT=915.025n

.meas tran vdout0_89ck1820 FIND v(dout0_89) AT=915.025n

.meas tran vdout0_90ck1820 FIND v(dout0_90) AT=915.025n

.meas tran vdout0_91ck1820 FIND v(dout0_91) AT=915.025n

.meas tran vdout0_92ck1820 FIND v(dout0_92) AT=915.025n

.meas tran vdout0_93ck1820 FIND v(dout0_93) AT=915.025n

.meas tran vdout0_94ck1820 FIND v(dout0_94) AT=915.025n

.meas tran vdout0_95ck1820 FIND v(dout0_95) AT=915.025n

.meas tran vdout0_96ck1820 FIND v(dout0_96) AT=915.025n

.meas tran vdout0_97ck1820 FIND v(dout0_97) AT=915.025n

.meas tran vdout0_98ck1820 FIND v(dout0_98) AT=915.025n

.meas tran vdout0_99ck1820 FIND v(dout0_99) AT=915.025n

.meas tran vdout0_100ck1820 FIND v(dout0_100) AT=915.025n

.meas tran vdout0_101ck1820 FIND v(dout0_101) AT=915.025n

.meas tran vdout0_102ck1820 FIND v(dout0_102) AT=915.025n

.meas tran vdout0_103ck1820 FIND v(dout0_103) AT=915.025n

.meas tran vdout0_104ck1820 FIND v(dout0_104) AT=915.025n

.meas tran vdout0_105ck1820 FIND v(dout0_105) AT=915.025n

.meas tran vdout0_106ck1820 FIND v(dout0_106) AT=915.025n

.meas tran vdout0_107ck1820 FIND v(dout0_107) AT=915.025n

.meas tran vdout0_108ck1820 FIND v(dout0_108) AT=915.025n

.meas tran vdout0_109ck1820 FIND v(dout0_109) AT=915.025n

.meas tran vdout0_110ck1820 FIND v(dout0_110) AT=915.025n

.meas tran vdout0_111ck1820 FIND v(dout0_111) AT=915.025n

.meas tran vdout0_112ck1820 FIND v(dout0_112) AT=915.025n

.meas tran vdout0_113ck1820 FIND v(dout0_113) AT=915.025n

.meas tran vdout0_114ck1820 FIND v(dout0_114) AT=915.025n

.meas tran vdout0_115ck1820 FIND v(dout0_115) AT=915.025n

.meas tran vdout0_116ck1820 FIND v(dout0_116) AT=915.025n

.meas tran vdout0_117ck1820 FIND v(dout0_117) AT=915.025n

.meas tran vdout0_118ck1820 FIND v(dout0_118) AT=915.025n

.meas tran vdout0_119ck1820 FIND v(dout0_119) AT=915.025n

.meas tran vdout0_120ck1820 FIND v(dout0_120) AT=915.025n

.meas tran vdout0_121ck1820 FIND v(dout0_121) AT=915.025n

.meas tran vdout0_122ck1820 FIND v(dout0_122) AT=915.025n

.meas tran vdout0_123ck1820 FIND v(dout0_123) AT=915.025n

.meas tran vdout0_124ck1820 FIND v(dout0_124) AT=915.025n

.meas tran vdout0_125ck1820 FIND v(dout0_125) AT=915.025n

.meas tran vdout0_126ck1820 FIND v(dout0_126) AT=915.025n

.meas tran vdout0_127ck1820 FIND v(dout0_127) AT=915.025n

.meas tran vdout0_128ck1820 FIND v(dout0_128) AT=915.025n

.meas tran vdout0_129ck1820 FIND v(dout0_129) AT=915.025n

.meas tran vdout0_130ck1820 FIND v(dout0_130) AT=915.025n

.meas tran vdout0_131ck1820 FIND v(dout0_131) AT=915.025n

.meas tran vdout0_132ck1820 FIND v(dout0_132) AT=915.025n

.meas tran vdout0_133ck1820 FIND v(dout0_133) AT=915.025n

.meas tran vdout0_134ck1820 FIND v(dout0_134) AT=915.025n

.meas tran vdout0_135ck1820 FIND v(dout0_135) AT=915.025n

.meas tran vdout0_136ck1820 FIND v(dout0_136) AT=915.025n

.meas tran vdout0_137ck1820 FIND v(dout0_137) AT=915.025n

.meas tran vdout0_138ck1820 FIND v(dout0_138) AT=915.025n

.meas tran vdout0_139ck1820 FIND v(dout0_139) AT=915.025n

.meas tran vdout0_140ck1820 FIND v(dout0_140) AT=915.025n

.meas tran vdout0_141ck1820 FIND v(dout0_141) AT=915.025n

.meas tran vdout0_142ck1820 FIND v(dout0_142) AT=915.025n

.meas tran vdout0_143ck1820 FIND v(dout0_143) AT=915.025n

.meas tran vdout0_144ck1820 FIND v(dout0_144) AT=915.025n

.meas tran vdout0_145ck1820 FIND v(dout0_145) AT=915.025n

.meas tran vdout0_146ck1820 FIND v(dout0_146) AT=915.025n

.meas tran vdout0_147ck1820 FIND v(dout0_147) AT=915.025n

.meas tran vdout0_148ck1820 FIND v(dout0_148) AT=915.025n

.meas tran vdout0_149ck1820 FIND v(dout0_149) AT=915.025n

.meas tran vdout0_150ck1820 FIND v(dout0_150) AT=915.025n

.meas tran vdout0_151ck1820 FIND v(dout0_151) AT=915.025n

.meas tran vdout0_152ck1820 FIND v(dout0_152) AT=915.025n

.meas tran vdout0_153ck1820 FIND v(dout0_153) AT=915.025n

.meas tran vdout0_154ck1820 FIND v(dout0_154) AT=915.025n

.meas tran vdout0_155ck1820 FIND v(dout0_155) AT=915.025n

.meas tran vdout0_156ck1820 FIND v(dout0_156) AT=915.025n

.meas tran vdout0_157ck1820 FIND v(dout0_157) AT=915.025n

.meas tran vdout0_158ck1820 FIND v(dout0_158) AT=915.025n

.meas tran vdout0_159ck1820 FIND v(dout0_159) AT=915.025n

.meas tran vdout0_160ck1820 FIND v(dout0_160) AT=915.025n

.meas tran vdout0_161ck1820 FIND v(dout0_161) AT=915.025n

.meas tran vdout0_162ck1820 FIND v(dout0_162) AT=915.025n

.meas tran vdout0_163ck1820 FIND v(dout0_163) AT=915.025n

.meas tran vdout0_164ck1820 FIND v(dout0_164) AT=915.025n

.meas tran vdout0_165ck1820 FIND v(dout0_165) AT=915.025n

.meas tran vdout0_166ck1820 FIND v(dout0_166) AT=915.025n

.meas tran vdout0_167ck1820 FIND v(dout0_167) AT=915.025n

.meas tran vdout0_168ck1820 FIND v(dout0_168) AT=915.025n

.meas tran vdout0_169ck1820 FIND v(dout0_169) AT=915.025n

.meas tran vdout0_170ck1820 FIND v(dout0_170) AT=915.025n

.meas tran vdout0_171ck1820 FIND v(dout0_171) AT=915.025n

.meas tran vdout0_172ck1820 FIND v(dout0_172) AT=915.025n

.meas tran vdout0_173ck1820 FIND v(dout0_173) AT=915.025n

.meas tran vdout0_174ck1820 FIND v(dout0_174) AT=915.025n

.meas tran vdout0_175ck1820 FIND v(dout0_175) AT=915.025n

.meas tran vdout0_176ck1820 FIND v(dout0_176) AT=915.025n

.meas tran vdout0_177ck1820 FIND v(dout0_177) AT=915.025n

.meas tran vdout0_178ck1820 FIND v(dout0_178) AT=915.025n

.meas tran vdout0_179ck1820 FIND v(dout0_179) AT=915.025n

.meas tran vdout0_180ck1820 FIND v(dout0_180) AT=915.025n

.meas tran vdout0_181ck1820 FIND v(dout0_181) AT=915.025n

.meas tran vdout0_182ck1820 FIND v(dout0_182) AT=915.025n

.meas tran vdout0_183ck1820 FIND v(dout0_183) AT=915.025n

.meas tran vdout0_184ck1820 FIND v(dout0_184) AT=915.025n

.meas tran vdout0_185ck1820 FIND v(dout0_185) AT=915.025n

.meas tran vdout0_186ck1820 FIND v(dout0_186) AT=915.025n

.meas tran vdout0_187ck1820 FIND v(dout0_187) AT=915.025n

.meas tran vdout0_188ck1820 FIND v(dout0_188) AT=915.025n

.meas tran vdout0_189ck1820 FIND v(dout0_189) AT=915.025n

.meas tran vdout0_190ck1820 FIND v(dout0_190) AT=915.025n

.meas tran vdout0_191ck1820 FIND v(dout0_191) AT=915.025n

.meas tran vdout0_192ck1820 FIND v(dout0_192) AT=915.025n

.meas tran vdout0_193ck1820 FIND v(dout0_193) AT=915.025n

.meas tran vdout0_194ck1820 FIND v(dout0_194) AT=915.025n

.meas tran vdout0_195ck1820 FIND v(dout0_195) AT=915.025n

.meas tran vdout0_196ck1820 FIND v(dout0_196) AT=915.025n

.meas tran vdout0_197ck1820 FIND v(dout0_197) AT=915.025n

.meas tran vdout0_198ck1820 FIND v(dout0_198) AT=915.025n

.meas tran vdout0_199ck1820 FIND v(dout0_199) AT=915.025n

.meas tran vdout0_200ck1820 FIND v(dout0_200) AT=915.025n

.meas tran vdout0_201ck1820 FIND v(dout0_201) AT=915.025n

.meas tran vdout0_202ck1820 FIND v(dout0_202) AT=915.025n

.meas tran vdout0_203ck1820 FIND v(dout0_203) AT=915.025n

.meas tran vdout0_204ck1820 FIND v(dout0_204) AT=915.025n

.meas tran vdout0_205ck1820 FIND v(dout0_205) AT=915.025n

.meas tran vdout0_206ck1820 FIND v(dout0_206) AT=915.025n

.meas tran vdout0_207ck1820 FIND v(dout0_207) AT=915.025n

.meas tran vdout0_208ck1820 FIND v(dout0_208) AT=915.025n

.meas tran vdout0_209ck1820 FIND v(dout0_209) AT=915.025n

.meas tran vdout0_210ck1820 FIND v(dout0_210) AT=915.025n

.meas tran vdout0_211ck1820 FIND v(dout0_211) AT=915.025n

.meas tran vdout0_212ck1820 FIND v(dout0_212) AT=915.025n

.meas tran vdout0_213ck1820 FIND v(dout0_213) AT=915.025n

.meas tran vdout0_214ck1820 FIND v(dout0_214) AT=915.025n

.meas tran vdout0_215ck1820 FIND v(dout0_215) AT=915.025n

.meas tran vdout0_216ck1820 FIND v(dout0_216) AT=915.025n

.meas tran vdout0_217ck1820 FIND v(dout0_217) AT=915.025n

.meas tran vdout0_218ck1820 FIND v(dout0_218) AT=915.025n

.meas tran vdout0_219ck1820 FIND v(dout0_219) AT=915.025n

.meas tran vdout0_220ck1820 FIND v(dout0_220) AT=915.025n

.meas tran vdout0_221ck1820 FIND v(dout0_221) AT=915.025n

.meas tran vdout0_222ck1820 FIND v(dout0_222) AT=915.025n

.meas tran vdout0_223ck1820 FIND v(dout0_223) AT=915.025n

.meas tran vdout0_224ck1820 FIND v(dout0_224) AT=915.025n

.meas tran vdout0_225ck1820 FIND v(dout0_225) AT=915.025n

.meas tran vdout0_226ck1820 FIND v(dout0_226) AT=915.025n

.meas tran vdout0_227ck1820 FIND v(dout0_227) AT=915.025n

.meas tran vdout0_228ck1820 FIND v(dout0_228) AT=915.025n

.meas tran vdout0_229ck1820 FIND v(dout0_229) AT=915.025n

.meas tran vdout0_230ck1820 FIND v(dout0_230) AT=915.025n

.meas tran vdout0_231ck1820 FIND v(dout0_231) AT=915.025n

.meas tran vdout0_232ck1820 FIND v(dout0_232) AT=915.025n

.meas tran vdout0_233ck1820 FIND v(dout0_233) AT=915.025n

.meas tran vdout0_234ck1820 FIND v(dout0_234) AT=915.025n

.meas tran vdout0_235ck1820 FIND v(dout0_235) AT=915.025n

.meas tran vdout0_236ck1820 FIND v(dout0_236) AT=915.025n

.meas tran vdout0_237ck1820 FIND v(dout0_237) AT=915.025n

.meas tran vdout0_238ck1820 FIND v(dout0_238) AT=915.025n

.meas tran vdout0_239ck1820 FIND v(dout0_239) AT=915.025n

.meas tran vdout0_240ck1820 FIND v(dout0_240) AT=915.025n

.meas tran vdout0_241ck1820 FIND v(dout0_241) AT=915.025n

.meas tran vdout0_242ck1820 FIND v(dout0_242) AT=915.025n

.meas tran vdout0_243ck1820 FIND v(dout0_243) AT=915.025n

.meas tran vdout0_244ck1820 FIND v(dout0_244) AT=915.025n

.meas tran vdout0_245ck1820 FIND v(dout0_245) AT=915.025n

.meas tran vdout0_246ck1820 FIND v(dout0_246) AT=915.025n

.meas tran vdout0_247ck1820 FIND v(dout0_247) AT=915.025n

.meas tran vdout0_248ck1820 FIND v(dout0_248) AT=915.025n

.meas tran vdout0_249ck1820 FIND v(dout0_249) AT=915.025n

.meas tran vdout0_250ck1820 FIND v(dout0_250) AT=915.025n

.meas tran vdout0_251ck1820 FIND v(dout0_251) AT=915.025n

.meas tran vdout0_252ck1820 FIND v(dout0_252) AT=915.025n

.meas tran vdout0_253ck1820 FIND v(dout0_253) AT=915.025n

.meas tran vdout0_254ck1820 FIND v(dout0_254) AT=915.025n

.meas tran vdout0_255ck1820 FIND v(dout0_255) AT=915.025n

.meas tran vdout0_0ck1840 FIND v(dout0_0) AT=925.025n

.meas tran vdout0_1ck1840 FIND v(dout0_1) AT=925.025n

.meas tran vdout0_2ck1840 FIND v(dout0_2) AT=925.025n

.meas tran vdout0_3ck1840 FIND v(dout0_3) AT=925.025n

.meas tran vdout0_4ck1840 FIND v(dout0_4) AT=925.025n

.meas tran vdout0_5ck1840 FIND v(dout0_5) AT=925.025n

.meas tran vdout0_6ck1840 FIND v(dout0_6) AT=925.025n

.meas tran vdout0_7ck1840 FIND v(dout0_7) AT=925.025n

.meas tran vdout0_8ck1840 FIND v(dout0_8) AT=925.025n

.meas tran vdout0_9ck1840 FIND v(dout0_9) AT=925.025n

.meas tran vdout0_10ck1840 FIND v(dout0_10) AT=925.025n

.meas tran vdout0_11ck1840 FIND v(dout0_11) AT=925.025n

.meas tran vdout0_12ck1840 FIND v(dout0_12) AT=925.025n

.meas tran vdout0_13ck1840 FIND v(dout0_13) AT=925.025n

.meas tran vdout0_14ck1840 FIND v(dout0_14) AT=925.025n

.meas tran vdout0_15ck1840 FIND v(dout0_15) AT=925.025n

.meas tran vdout0_16ck1840 FIND v(dout0_16) AT=925.025n

.meas tran vdout0_17ck1840 FIND v(dout0_17) AT=925.025n

.meas tran vdout0_18ck1840 FIND v(dout0_18) AT=925.025n

.meas tran vdout0_19ck1840 FIND v(dout0_19) AT=925.025n

.meas tran vdout0_20ck1840 FIND v(dout0_20) AT=925.025n

.meas tran vdout0_21ck1840 FIND v(dout0_21) AT=925.025n

.meas tran vdout0_22ck1840 FIND v(dout0_22) AT=925.025n

.meas tran vdout0_23ck1840 FIND v(dout0_23) AT=925.025n

.meas tran vdout0_24ck1840 FIND v(dout0_24) AT=925.025n

.meas tran vdout0_25ck1840 FIND v(dout0_25) AT=925.025n

.meas tran vdout0_26ck1840 FIND v(dout0_26) AT=925.025n

.meas tran vdout0_27ck1840 FIND v(dout0_27) AT=925.025n

.meas tran vdout0_28ck1840 FIND v(dout0_28) AT=925.025n

.meas tran vdout0_29ck1840 FIND v(dout0_29) AT=925.025n

.meas tran vdout0_30ck1840 FIND v(dout0_30) AT=925.025n

.meas tran vdout0_31ck1840 FIND v(dout0_31) AT=925.025n

.meas tran vdout0_32ck1840 FIND v(dout0_32) AT=925.025n

.meas tran vdout0_33ck1840 FIND v(dout0_33) AT=925.025n

.meas tran vdout0_34ck1840 FIND v(dout0_34) AT=925.025n

.meas tran vdout0_35ck1840 FIND v(dout0_35) AT=925.025n

.meas tran vdout0_36ck1840 FIND v(dout0_36) AT=925.025n

.meas tran vdout0_37ck1840 FIND v(dout0_37) AT=925.025n

.meas tran vdout0_38ck1840 FIND v(dout0_38) AT=925.025n

.meas tran vdout0_39ck1840 FIND v(dout0_39) AT=925.025n

.meas tran vdout0_40ck1840 FIND v(dout0_40) AT=925.025n

.meas tran vdout0_41ck1840 FIND v(dout0_41) AT=925.025n

.meas tran vdout0_42ck1840 FIND v(dout0_42) AT=925.025n

.meas tran vdout0_43ck1840 FIND v(dout0_43) AT=925.025n

.meas tran vdout0_44ck1840 FIND v(dout0_44) AT=925.025n

.meas tran vdout0_45ck1840 FIND v(dout0_45) AT=925.025n

.meas tran vdout0_46ck1840 FIND v(dout0_46) AT=925.025n

.meas tran vdout0_47ck1840 FIND v(dout0_47) AT=925.025n

.meas tran vdout0_48ck1840 FIND v(dout0_48) AT=925.025n

.meas tran vdout0_49ck1840 FIND v(dout0_49) AT=925.025n

.meas tran vdout0_50ck1840 FIND v(dout0_50) AT=925.025n

.meas tran vdout0_51ck1840 FIND v(dout0_51) AT=925.025n

.meas tran vdout0_52ck1840 FIND v(dout0_52) AT=925.025n

.meas tran vdout0_53ck1840 FIND v(dout0_53) AT=925.025n

.meas tran vdout0_54ck1840 FIND v(dout0_54) AT=925.025n

.meas tran vdout0_55ck1840 FIND v(dout0_55) AT=925.025n

.meas tran vdout0_56ck1840 FIND v(dout0_56) AT=925.025n

.meas tran vdout0_57ck1840 FIND v(dout0_57) AT=925.025n

.meas tran vdout0_58ck1840 FIND v(dout0_58) AT=925.025n

.meas tran vdout0_59ck1840 FIND v(dout0_59) AT=925.025n

.meas tran vdout0_60ck1840 FIND v(dout0_60) AT=925.025n

.meas tran vdout0_61ck1840 FIND v(dout0_61) AT=925.025n

.meas tran vdout0_62ck1840 FIND v(dout0_62) AT=925.025n

.meas tran vdout0_63ck1840 FIND v(dout0_63) AT=925.025n

.meas tran vdout0_64ck1840 FIND v(dout0_64) AT=925.025n

.meas tran vdout0_65ck1840 FIND v(dout0_65) AT=925.025n

.meas tran vdout0_66ck1840 FIND v(dout0_66) AT=925.025n

.meas tran vdout0_67ck1840 FIND v(dout0_67) AT=925.025n

.meas tran vdout0_68ck1840 FIND v(dout0_68) AT=925.025n

.meas tran vdout0_69ck1840 FIND v(dout0_69) AT=925.025n

.meas tran vdout0_70ck1840 FIND v(dout0_70) AT=925.025n

.meas tran vdout0_71ck1840 FIND v(dout0_71) AT=925.025n

.meas tran vdout0_72ck1840 FIND v(dout0_72) AT=925.025n

.meas tran vdout0_73ck1840 FIND v(dout0_73) AT=925.025n

.meas tran vdout0_74ck1840 FIND v(dout0_74) AT=925.025n

.meas tran vdout0_75ck1840 FIND v(dout0_75) AT=925.025n

.meas tran vdout0_76ck1840 FIND v(dout0_76) AT=925.025n

.meas tran vdout0_77ck1840 FIND v(dout0_77) AT=925.025n

.meas tran vdout0_78ck1840 FIND v(dout0_78) AT=925.025n

.meas tran vdout0_79ck1840 FIND v(dout0_79) AT=925.025n

.meas tran vdout0_80ck1840 FIND v(dout0_80) AT=925.025n

.meas tran vdout0_81ck1840 FIND v(dout0_81) AT=925.025n

.meas tran vdout0_82ck1840 FIND v(dout0_82) AT=925.025n

.meas tran vdout0_83ck1840 FIND v(dout0_83) AT=925.025n

.meas tran vdout0_84ck1840 FIND v(dout0_84) AT=925.025n

.meas tran vdout0_85ck1840 FIND v(dout0_85) AT=925.025n

.meas tran vdout0_86ck1840 FIND v(dout0_86) AT=925.025n

.meas tran vdout0_87ck1840 FIND v(dout0_87) AT=925.025n

.meas tran vdout0_88ck1840 FIND v(dout0_88) AT=925.025n

.meas tran vdout0_89ck1840 FIND v(dout0_89) AT=925.025n

.meas tran vdout0_90ck1840 FIND v(dout0_90) AT=925.025n

.meas tran vdout0_91ck1840 FIND v(dout0_91) AT=925.025n

.meas tran vdout0_92ck1840 FIND v(dout0_92) AT=925.025n

.meas tran vdout0_93ck1840 FIND v(dout0_93) AT=925.025n

.meas tran vdout0_94ck1840 FIND v(dout0_94) AT=925.025n

.meas tran vdout0_95ck1840 FIND v(dout0_95) AT=925.025n

.meas tran vdout0_96ck1840 FIND v(dout0_96) AT=925.025n

.meas tran vdout0_97ck1840 FIND v(dout0_97) AT=925.025n

.meas tran vdout0_98ck1840 FIND v(dout0_98) AT=925.025n

.meas tran vdout0_99ck1840 FIND v(dout0_99) AT=925.025n

.meas tran vdout0_100ck1840 FIND v(dout0_100) AT=925.025n

.meas tran vdout0_101ck1840 FIND v(dout0_101) AT=925.025n

.meas tran vdout0_102ck1840 FIND v(dout0_102) AT=925.025n

.meas tran vdout0_103ck1840 FIND v(dout0_103) AT=925.025n

.meas tran vdout0_104ck1840 FIND v(dout0_104) AT=925.025n

.meas tran vdout0_105ck1840 FIND v(dout0_105) AT=925.025n

.meas tran vdout0_106ck1840 FIND v(dout0_106) AT=925.025n

.meas tran vdout0_107ck1840 FIND v(dout0_107) AT=925.025n

.meas tran vdout0_108ck1840 FIND v(dout0_108) AT=925.025n

.meas tran vdout0_109ck1840 FIND v(dout0_109) AT=925.025n

.meas tran vdout0_110ck1840 FIND v(dout0_110) AT=925.025n

.meas tran vdout0_111ck1840 FIND v(dout0_111) AT=925.025n

.meas tran vdout0_112ck1840 FIND v(dout0_112) AT=925.025n

.meas tran vdout0_113ck1840 FIND v(dout0_113) AT=925.025n

.meas tran vdout0_114ck1840 FIND v(dout0_114) AT=925.025n

.meas tran vdout0_115ck1840 FIND v(dout0_115) AT=925.025n

.meas tran vdout0_116ck1840 FIND v(dout0_116) AT=925.025n

.meas tran vdout0_117ck1840 FIND v(dout0_117) AT=925.025n

.meas tran vdout0_118ck1840 FIND v(dout0_118) AT=925.025n

.meas tran vdout0_119ck1840 FIND v(dout0_119) AT=925.025n

.meas tran vdout0_120ck1840 FIND v(dout0_120) AT=925.025n

.meas tran vdout0_121ck1840 FIND v(dout0_121) AT=925.025n

.meas tran vdout0_122ck1840 FIND v(dout0_122) AT=925.025n

.meas tran vdout0_123ck1840 FIND v(dout0_123) AT=925.025n

.meas tran vdout0_124ck1840 FIND v(dout0_124) AT=925.025n

.meas tran vdout0_125ck1840 FIND v(dout0_125) AT=925.025n

.meas tran vdout0_126ck1840 FIND v(dout0_126) AT=925.025n

.meas tran vdout0_127ck1840 FIND v(dout0_127) AT=925.025n

.meas tran vdout0_128ck1840 FIND v(dout0_128) AT=925.025n

.meas tran vdout0_129ck1840 FIND v(dout0_129) AT=925.025n

.meas tran vdout0_130ck1840 FIND v(dout0_130) AT=925.025n

.meas tran vdout0_131ck1840 FIND v(dout0_131) AT=925.025n

.meas tran vdout0_132ck1840 FIND v(dout0_132) AT=925.025n

.meas tran vdout0_133ck1840 FIND v(dout0_133) AT=925.025n

.meas tran vdout0_134ck1840 FIND v(dout0_134) AT=925.025n

.meas tran vdout0_135ck1840 FIND v(dout0_135) AT=925.025n

.meas tran vdout0_136ck1840 FIND v(dout0_136) AT=925.025n

.meas tran vdout0_137ck1840 FIND v(dout0_137) AT=925.025n

.meas tran vdout0_138ck1840 FIND v(dout0_138) AT=925.025n

.meas tran vdout0_139ck1840 FIND v(dout0_139) AT=925.025n

.meas tran vdout0_140ck1840 FIND v(dout0_140) AT=925.025n

.meas tran vdout0_141ck1840 FIND v(dout0_141) AT=925.025n

.meas tran vdout0_142ck1840 FIND v(dout0_142) AT=925.025n

.meas tran vdout0_143ck1840 FIND v(dout0_143) AT=925.025n

.meas tran vdout0_144ck1840 FIND v(dout0_144) AT=925.025n

.meas tran vdout0_145ck1840 FIND v(dout0_145) AT=925.025n

.meas tran vdout0_146ck1840 FIND v(dout0_146) AT=925.025n

.meas tran vdout0_147ck1840 FIND v(dout0_147) AT=925.025n

.meas tran vdout0_148ck1840 FIND v(dout0_148) AT=925.025n

.meas tran vdout0_149ck1840 FIND v(dout0_149) AT=925.025n

.meas tran vdout0_150ck1840 FIND v(dout0_150) AT=925.025n

.meas tran vdout0_151ck1840 FIND v(dout0_151) AT=925.025n

.meas tran vdout0_152ck1840 FIND v(dout0_152) AT=925.025n

.meas tran vdout0_153ck1840 FIND v(dout0_153) AT=925.025n

.meas tran vdout0_154ck1840 FIND v(dout0_154) AT=925.025n

.meas tran vdout0_155ck1840 FIND v(dout0_155) AT=925.025n

.meas tran vdout0_156ck1840 FIND v(dout0_156) AT=925.025n

.meas tran vdout0_157ck1840 FIND v(dout0_157) AT=925.025n

.meas tran vdout0_158ck1840 FIND v(dout0_158) AT=925.025n

.meas tran vdout0_159ck1840 FIND v(dout0_159) AT=925.025n

.meas tran vdout0_160ck1840 FIND v(dout0_160) AT=925.025n

.meas tran vdout0_161ck1840 FIND v(dout0_161) AT=925.025n

.meas tran vdout0_162ck1840 FIND v(dout0_162) AT=925.025n

.meas tran vdout0_163ck1840 FIND v(dout0_163) AT=925.025n

.meas tran vdout0_164ck1840 FIND v(dout0_164) AT=925.025n

.meas tran vdout0_165ck1840 FIND v(dout0_165) AT=925.025n

.meas tran vdout0_166ck1840 FIND v(dout0_166) AT=925.025n

.meas tran vdout0_167ck1840 FIND v(dout0_167) AT=925.025n

.meas tran vdout0_168ck1840 FIND v(dout0_168) AT=925.025n

.meas tran vdout0_169ck1840 FIND v(dout0_169) AT=925.025n

.meas tran vdout0_170ck1840 FIND v(dout0_170) AT=925.025n

.meas tran vdout0_171ck1840 FIND v(dout0_171) AT=925.025n

.meas tran vdout0_172ck1840 FIND v(dout0_172) AT=925.025n

.meas tran vdout0_173ck1840 FIND v(dout0_173) AT=925.025n

.meas tran vdout0_174ck1840 FIND v(dout0_174) AT=925.025n

.meas tran vdout0_175ck1840 FIND v(dout0_175) AT=925.025n

.meas tran vdout0_176ck1840 FIND v(dout0_176) AT=925.025n

.meas tran vdout0_177ck1840 FIND v(dout0_177) AT=925.025n

.meas tran vdout0_178ck1840 FIND v(dout0_178) AT=925.025n

.meas tran vdout0_179ck1840 FIND v(dout0_179) AT=925.025n

.meas tran vdout0_180ck1840 FIND v(dout0_180) AT=925.025n

.meas tran vdout0_181ck1840 FIND v(dout0_181) AT=925.025n

.meas tran vdout0_182ck1840 FIND v(dout0_182) AT=925.025n

.meas tran vdout0_183ck1840 FIND v(dout0_183) AT=925.025n

.meas tran vdout0_184ck1840 FIND v(dout0_184) AT=925.025n

.meas tran vdout0_185ck1840 FIND v(dout0_185) AT=925.025n

.meas tran vdout0_186ck1840 FIND v(dout0_186) AT=925.025n

.meas tran vdout0_187ck1840 FIND v(dout0_187) AT=925.025n

.meas tran vdout0_188ck1840 FIND v(dout0_188) AT=925.025n

.meas tran vdout0_189ck1840 FIND v(dout0_189) AT=925.025n

.meas tran vdout0_190ck1840 FIND v(dout0_190) AT=925.025n

.meas tran vdout0_191ck1840 FIND v(dout0_191) AT=925.025n

.meas tran vdout0_192ck1840 FIND v(dout0_192) AT=925.025n

.meas tran vdout0_193ck1840 FIND v(dout0_193) AT=925.025n

.meas tran vdout0_194ck1840 FIND v(dout0_194) AT=925.025n

.meas tran vdout0_195ck1840 FIND v(dout0_195) AT=925.025n

.meas tran vdout0_196ck1840 FIND v(dout0_196) AT=925.025n

.meas tran vdout0_197ck1840 FIND v(dout0_197) AT=925.025n

.meas tran vdout0_198ck1840 FIND v(dout0_198) AT=925.025n

.meas tran vdout0_199ck1840 FIND v(dout0_199) AT=925.025n

.meas tran vdout0_200ck1840 FIND v(dout0_200) AT=925.025n

.meas tran vdout0_201ck1840 FIND v(dout0_201) AT=925.025n

.meas tran vdout0_202ck1840 FIND v(dout0_202) AT=925.025n

.meas tran vdout0_203ck1840 FIND v(dout0_203) AT=925.025n

.meas tran vdout0_204ck1840 FIND v(dout0_204) AT=925.025n

.meas tran vdout0_205ck1840 FIND v(dout0_205) AT=925.025n

.meas tran vdout0_206ck1840 FIND v(dout0_206) AT=925.025n

.meas tran vdout0_207ck1840 FIND v(dout0_207) AT=925.025n

.meas tran vdout0_208ck1840 FIND v(dout0_208) AT=925.025n

.meas tran vdout0_209ck1840 FIND v(dout0_209) AT=925.025n

.meas tran vdout0_210ck1840 FIND v(dout0_210) AT=925.025n

.meas tran vdout0_211ck1840 FIND v(dout0_211) AT=925.025n

.meas tran vdout0_212ck1840 FIND v(dout0_212) AT=925.025n

.meas tran vdout0_213ck1840 FIND v(dout0_213) AT=925.025n

.meas tran vdout0_214ck1840 FIND v(dout0_214) AT=925.025n

.meas tran vdout0_215ck1840 FIND v(dout0_215) AT=925.025n

.meas tran vdout0_216ck1840 FIND v(dout0_216) AT=925.025n

.meas tran vdout0_217ck1840 FIND v(dout0_217) AT=925.025n

.meas tran vdout0_218ck1840 FIND v(dout0_218) AT=925.025n

.meas tran vdout0_219ck1840 FIND v(dout0_219) AT=925.025n

.meas tran vdout0_220ck1840 FIND v(dout0_220) AT=925.025n

.meas tran vdout0_221ck1840 FIND v(dout0_221) AT=925.025n

.meas tran vdout0_222ck1840 FIND v(dout0_222) AT=925.025n

.meas tran vdout0_223ck1840 FIND v(dout0_223) AT=925.025n

.meas tran vdout0_224ck1840 FIND v(dout0_224) AT=925.025n

.meas tran vdout0_225ck1840 FIND v(dout0_225) AT=925.025n

.meas tran vdout0_226ck1840 FIND v(dout0_226) AT=925.025n

.meas tran vdout0_227ck1840 FIND v(dout0_227) AT=925.025n

.meas tran vdout0_228ck1840 FIND v(dout0_228) AT=925.025n

.meas tran vdout0_229ck1840 FIND v(dout0_229) AT=925.025n

.meas tran vdout0_230ck1840 FIND v(dout0_230) AT=925.025n

.meas tran vdout0_231ck1840 FIND v(dout0_231) AT=925.025n

.meas tran vdout0_232ck1840 FIND v(dout0_232) AT=925.025n

.meas tran vdout0_233ck1840 FIND v(dout0_233) AT=925.025n

.meas tran vdout0_234ck1840 FIND v(dout0_234) AT=925.025n

.meas tran vdout0_235ck1840 FIND v(dout0_235) AT=925.025n

.meas tran vdout0_236ck1840 FIND v(dout0_236) AT=925.025n

.meas tran vdout0_237ck1840 FIND v(dout0_237) AT=925.025n

.meas tran vdout0_238ck1840 FIND v(dout0_238) AT=925.025n

.meas tran vdout0_239ck1840 FIND v(dout0_239) AT=925.025n

.meas tran vdout0_240ck1840 FIND v(dout0_240) AT=925.025n

.meas tran vdout0_241ck1840 FIND v(dout0_241) AT=925.025n

.meas tran vdout0_242ck1840 FIND v(dout0_242) AT=925.025n

.meas tran vdout0_243ck1840 FIND v(dout0_243) AT=925.025n

.meas tran vdout0_244ck1840 FIND v(dout0_244) AT=925.025n

.meas tran vdout0_245ck1840 FIND v(dout0_245) AT=925.025n

.meas tran vdout0_246ck1840 FIND v(dout0_246) AT=925.025n

.meas tran vdout0_247ck1840 FIND v(dout0_247) AT=925.025n

.meas tran vdout0_248ck1840 FIND v(dout0_248) AT=925.025n

.meas tran vdout0_249ck1840 FIND v(dout0_249) AT=925.025n

.meas tran vdout0_250ck1840 FIND v(dout0_250) AT=925.025n

.meas tran vdout0_251ck1840 FIND v(dout0_251) AT=925.025n

.meas tran vdout0_252ck1840 FIND v(dout0_252) AT=925.025n

.meas tran vdout0_253ck1840 FIND v(dout0_253) AT=925.025n

.meas tran vdout0_254ck1840 FIND v(dout0_254) AT=925.025n

.meas tran vdout0_255ck1840 FIND v(dout0_255) AT=925.025n

.meas tran vdout0_0ck1850 FIND v(dout0_0) AT=930.025n

.meas tran vdout0_1ck1850 FIND v(dout0_1) AT=930.025n

.meas tran vdout0_2ck1850 FIND v(dout0_2) AT=930.025n

.meas tran vdout0_3ck1850 FIND v(dout0_3) AT=930.025n

.meas tran vdout0_4ck1850 FIND v(dout0_4) AT=930.025n

.meas tran vdout0_5ck1850 FIND v(dout0_5) AT=930.025n

.meas tran vdout0_6ck1850 FIND v(dout0_6) AT=930.025n

.meas tran vdout0_7ck1850 FIND v(dout0_7) AT=930.025n

.meas tran vdout0_8ck1850 FIND v(dout0_8) AT=930.025n

.meas tran vdout0_9ck1850 FIND v(dout0_9) AT=930.025n

.meas tran vdout0_10ck1850 FIND v(dout0_10) AT=930.025n

.meas tran vdout0_11ck1850 FIND v(dout0_11) AT=930.025n

.meas tran vdout0_12ck1850 FIND v(dout0_12) AT=930.025n

.meas tran vdout0_13ck1850 FIND v(dout0_13) AT=930.025n

.meas tran vdout0_14ck1850 FIND v(dout0_14) AT=930.025n

.meas tran vdout0_15ck1850 FIND v(dout0_15) AT=930.025n

.meas tran vdout0_16ck1850 FIND v(dout0_16) AT=930.025n

.meas tran vdout0_17ck1850 FIND v(dout0_17) AT=930.025n

.meas tran vdout0_18ck1850 FIND v(dout0_18) AT=930.025n

.meas tran vdout0_19ck1850 FIND v(dout0_19) AT=930.025n

.meas tran vdout0_20ck1850 FIND v(dout0_20) AT=930.025n

.meas tran vdout0_21ck1850 FIND v(dout0_21) AT=930.025n

.meas tran vdout0_22ck1850 FIND v(dout0_22) AT=930.025n

.meas tran vdout0_23ck1850 FIND v(dout0_23) AT=930.025n

.meas tran vdout0_24ck1850 FIND v(dout0_24) AT=930.025n

.meas tran vdout0_25ck1850 FIND v(dout0_25) AT=930.025n

.meas tran vdout0_26ck1850 FIND v(dout0_26) AT=930.025n

.meas tran vdout0_27ck1850 FIND v(dout0_27) AT=930.025n

.meas tran vdout0_28ck1850 FIND v(dout0_28) AT=930.025n

.meas tran vdout0_29ck1850 FIND v(dout0_29) AT=930.025n

.meas tran vdout0_30ck1850 FIND v(dout0_30) AT=930.025n

.meas tran vdout0_31ck1850 FIND v(dout0_31) AT=930.025n

.meas tran vdout0_32ck1850 FIND v(dout0_32) AT=930.025n

.meas tran vdout0_33ck1850 FIND v(dout0_33) AT=930.025n

.meas tran vdout0_34ck1850 FIND v(dout0_34) AT=930.025n

.meas tran vdout0_35ck1850 FIND v(dout0_35) AT=930.025n

.meas tran vdout0_36ck1850 FIND v(dout0_36) AT=930.025n

.meas tran vdout0_37ck1850 FIND v(dout0_37) AT=930.025n

.meas tran vdout0_38ck1850 FIND v(dout0_38) AT=930.025n

.meas tran vdout0_39ck1850 FIND v(dout0_39) AT=930.025n

.meas tran vdout0_40ck1850 FIND v(dout0_40) AT=930.025n

.meas tran vdout0_41ck1850 FIND v(dout0_41) AT=930.025n

.meas tran vdout0_42ck1850 FIND v(dout0_42) AT=930.025n

.meas tran vdout0_43ck1850 FIND v(dout0_43) AT=930.025n

.meas tran vdout0_44ck1850 FIND v(dout0_44) AT=930.025n

.meas tran vdout0_45ck1850 FIND v(dout0_45) AT=930.025n

.meas tran vdout0_46ck1850 FIND v(dout0_46) AT=930.025n

.meas tran vdout0_47ck1850 FIND v(dout0_47) AT=930.025n

.meas tran vdout0_48ck1850 FIND v(dout0_48) AT=930.025n

.meas tran vdout0_49ck1850 FIND v(dout0_49) AT=930.025n

.meas tran vdout0_50ck1850 FIND v(dout0_50) AT=930.025n

.meas tran vdout0_51ck1850 FIND v(dout0_51) AT=930.025n

.meas tran vdout0_52ck1850 FIND v(dout0_52) AT=930.025n

.meas tran vdout0_53ck1850 FIND v(dout0_53) AT=930.025n

.meas tran vdout0_54ck1850 FIND v(dout0_54) AT=930.025n

.meas tran vdout0_55ck1850 FIND v(dout0_55) AT=930.025n

.meas tran vdout0_56ck1850 FIND v(dout0_56) AT=930.025n

.meas tran vdout0_57ck1850 FIND v(dout0_57) AT=930.025n

.meas tran vdout0_58ck1850 FIND v(dout0_58) AT=930.025n

.meas tran vdout0_59ck1850 FIND v(dout0_59) AT=930.025n

.meas tran vdout0_60ck1850 FIND v(dout0_60) AT=930.025n

.meas tran vdout0_61ck1850 FIND v(dout0_61) AT=930.025n

.meas tran vdout0_62ck1850 FIND v(dout0_62) AT=930.025n

.meas tran vdout0_63ck1850 FIND v(dout0_63) AT=930.025n

.meas tran vdout0_64ck1850 FIND v(dout0_64) AT=930.025n

.meas tran vdout0_65ck1850 FIND v(dout0_65) AT=930.025n

.meas tran vdout0_66ck1850 FIND v(dout0_66) AT=930.025n

.meas tran vdout0_67ck1850 FIND v(dout0_67) AT=930.025n

.meas tran vdout0_68ck1850 FIND v(dout0_68) AT=930.025n

.meas tran vdout0_69ck1850 FIND v(dout0_69) AT=930.025n

.meas tran vdout0_70ck1850 FIND v(dout0_70) AT=930.025n

.meas tran vdout0_71ck1850 FIND v(dout0_71) AT=930.025n

.meas tran vdout0_72ck1850 FIND v(dout0_72) AT=930.025n

.meas tran vdout0_73ck1850 FIND v(dout0_73) AT=930.025n

.meas tran vdout0_74ck1850 FIND v(dout0_74) AT=930.025n

.meas tran vdout0_75ck1850 FIND v(dout0_75) AT=930.025n

.meas tran vdout0_76ck1850 FIND v(dout0_76) AT=930.025n

.meas tran vdout0_77ck1850 FIND v(dout0_77) AT=930.025n

.meas tran vdout0_78ck1850 FIND v(dout0_78) AT=930.025n

.meas tran vdout0_79ck1850 FIND v(dout0_79) AT=930.025n

.meas tran vdout0_80ck1850 FIND v(dout0_80) AT=930.025n

.meas tran vdout0_81ck1850 FIND v(dout0_81) AT=930.025n

.meas tran vdout0_82ck1850 FIND v(dout0_82) AT=930.025n

.meas tran vdout0_83ck1850 FIND v(dout0_83) AT=930.025n

.meas tran vdout0_84ck1850 FIND v(dout0_84) AT=930.025n

.meas tran vdout0_85ck1850 FIND v(dout0_85) AT=930.025n

.meas tran vdout0_86ck1850 FIND v(dout0_86) AT=930.025n

.meas tran vdout0_87ck1850 FIND v(dout0_87) AT=930.025n

.meas tran vdout0_88ck1850 FIND v(dout0_88) AT=930.025n

.meas tran vdout0_89ck1850 FIND v(dout0_89) AT=930.025n

.meas tran vdout0_90ck1850 FIND v(dout0_90) AT=930.025n

.meas tran vdout0_91ck1850 FIND v(dout0_91) AT=930.025n

.meas tran vdout0_92ck1850 FIND v(dout0_92) AT=930.025n

.meas tran vdout0_93ck1850 FIND v(dout0_93) AT=930.025n

.meas tran vdout0_94ck1850 FIND v(dout0_94) AT=930.025n

.meas tran vdout0_95ck1850 FIND v(dout0_95) AT=930.025n

.meas tran vdout0_96ck1850 FIND v(dout0_96) AT=930.025n

.meas tran vdout0_97ck1850 FIND v(dout0_97) AT=930.025n

.meas tran vdout0_98ck1850 FIND v(dout0_98) AT=930.025n

.meas tran vdout0_99ck1850 FIND v(dout0_99) AT=930.025n

.meas tran vdout0_100ck1850 FIND v(dout0_100) AT=930.025n

.meas tran vdout0_101ck1850 FIND v(dout0_101) AT=930.025n

.meas tran vdout0_102ck1850 FIND v(dout0_102) AT=930.025n

.meas tran vdout0_103ck1850 FIND v(dout0_103) AT=930.025n

.meas tran vdout0_104ck1850 FIND v(dout0_104) AT=930.025n

.meas tran vdout0_105ck1850 FIND v(dout0_105) AT=930.025n

.meas tran vdout0_106ck1850 FIND v(dout0_106) AT=930.025n

.meas tran vdout0_107ck1850 FIND v(dout0_107) AT=930.025n

.meas tran vdout0_108ck1850 FIND v(dout0_108) AT=930.025n

.meas tran vdout0_109ck1850 FIND v(dout0_109) AT=930.025n

.meas tran vdout0_110ck1850 FIND v(dout0_110) AT=930.025n

.meas tran vdout0_111ck1850 FIND v(dout0_111) AT=930.025n

.meas tran vdout0_112ck1850 FIND v(dout0_112) AT=930.025n

.meas tran vdout0_113ck1850 FIND v(dout0_113) AT=930.025n

.meas tran vdout0_114ck1850 FIND v(dout0_114) AT=930.025n

.meas tran vdout0_115ck1850 FIND v(dout0_115) AT=930.025n

.meas tran vdout0_116ck1850 FIND v(dout0_116) AT=930.025n

.meas tran vdout0_117ck1850 FIND v(dout0_117) AT=930.025n

.meas tran vdout0_118ck1850 FIND v(dout0_118) AT=930.025n

.meas tran vdout0_119ck1850 FIND v(dout0_119) AT=930.025n

.meas tran vdout0_120ck1850 FIND v(dout0_120) AT=930.025n

.meas tran vdout0_121ck1850 FIND v(dout0_121) AT=930.025n

.meas tran vdout0_122ck1850 FIND v(dout0_122) AT=930.025n

.meas tran vdout0_123ck1850 FIND v(dout0_123) AT=930.025n

.meas tran vdout0_124ck1850 FIND v(dout0_124) AT=930.025n

.meas tran vdout0_125ck1850 FIND v(dout0_125) AT=930.025n

.meas tran vdout0_126ck1850 FIND v(dout0_126) AT=930.025n

.meas tran vdout0_127ck1850 FIND v(dout0_127) AT=930.025n

.meas tran vdout0_128ck1850 FIND v(dout0_128) AT=930.025n

.meas tran vdout0_129ck1850 FIND v(dout0_129) AT=930.025n

.meas tran vdout0_130ck1850 FIND v(dout0_130) AT=930.025n

.meas tran vdout0_131ck1850 FIND v(dout0_131) AT=930.025n

.meas tran vdout0_132ck1850 FIND v(dout0_132) AT=930.025n

.meas tran vdout0_133ck1850 FIND v(dout0_133) AT=930.025n

.meas tran vdout0_134ck1850 FIND v(dout0_134) AT=930.025n

.meas tran vdout0_135ck1850 FIND v(dout0_135) AT=930.025n

.meas tran vdout0_136ck1850 FIND v(dout0_136) AT=930.025n

.meas tran vdout0_137ck1850 FIND v(dout0_137) AT=930.025n

.meas tran vdout0_138ck1850 FIND v(dout0_138) AT=930.025n

.meas tran vdout0_139ck1850 FIND v(dout0_139) AT=930.025n

.meas tran vdout0_140ck1850 FIND v(dout0_140) AT=930.025n

.meas tran vdout0_141ck1850 FIND v(dout0_141) AT=930.025n

.meas tran vdout0_142ck1850 FIND v(dout0_142) AT=930.025n

.meas tran vdout0_143ck1850 FIND v(dout0_143) AT=930.025n

.meas tran vdout0_144ck1850 FIND v(dout0_144) AT=930.025n

.meas tran vdout0_145ck1850 FIND v(dout0_145) AT=930.025n

.meas tran vdout0_146ck1850 FIND v(dout0_146) AT=930.025n

.meas tran vdout0_147ck1850 FIND v(dout0_147) AT=930.025n

.meas tran vdout0_148ck1850 FIND v(dout0_148) AT=930.025n

.meas tran vdout0_149ck1850 FIND v(dout0_149) AT=930.025n

.meas tran vdout0_150ck1850 FIND v(dout0_150) AT=930.025n

.meas tran vdout0_151ck1850 FIND v(dout0_151) AT=930.025n

.meas tran vdout0_152ck1850 FIND v(dout0_152) AT=930.025n

.meas tran vdout0_153ck1850 FIND v(dout0_153) AT=930.025n

.meas tran vdout0_154ck1850 FIND v(dout0_154) AT=930.025n

.meas tran vdout0_155ck1850 FIND v(dout0_155) AT=930.025n

.meas tran vdout0_156ck1850 FIND v(dout0_156) AT=930.025n

.meas tran vdout0_157ck1850 FIND v(dout0_157) AT=930.025n

.meas tran vdout0_158ck1850 FIND v(dout0_158) AT=930.025n

.meas tran vdout0_159ck1850 FIND v(dout0_159) AT=930.025n

.meas tran vdout0_160ck1850 FIND v(dout0_160) AT=930.025n

.meas tran vdout0_161ck1850 FIND v(dout0_161) AT=930.025n

.meas tran vdout0_162ck1850 FIND v(dout0_162) AT=930.025n

.meas tran vdout0_163ck1850 FIND v(dout0_163) AT=930.025n

.meas tran vdout0_164ck1850 FIND v(dout0_164) AT=930.025n

.meas tran vdout0_165ck1850 FIND v(dout0_165) AT=930.025n

.meas tran vdout0_166ck1850 FIND v(dout0_166) AT=930.025n

.meas tran vdout0_167ck1850 FIND v(dout0_167) AT=930.025n

.meas tran vdout0_168ck1850 FIND v(dout0_168) AT=930.025n

.meas tran vdout0_169ck1850 FIND v(dout0_169) AT=930.025n

.meas tran vdout0_170ck1850 FIND v(dout0_170) AT=930.025n

.meas tran vdout0_171ck1850 FIND v(dout0_171) AT=930.025n

.meas tran vdout0_172ck1850 FIND v(dout0_172) AT=930.025n

.meas tran vdout0_173ck1850 FIND v(dout0_173) AT=930.025n

.meas tran vdout0_174ck1850 FIND v(dout0_174) AT=930.025n

.meas tran vdout0_175ck1850 FIND v(dout0_175) AT=930.025n

.meas tran vdout0_176ck1850 FIND v(dout0_176) AT=930.025n

.meas tran vdout0_177ck1850 FIND v(dout0_177) AT=930.025n

.meas tran vdout0_178ck1850 FIND v(dout0_178) AT=930.025n

.meas tran vdout0_179ck1850 FIND v(dout0_179) AT=930.025n

.meas tran vdout0_180ck1850 FIND v(dout0_180) AT=930.025n

.meas tran vdout0_181ck1850 FIND v(dout0_181) AT=930.025n

.meas tran vdout0_182ck1850 FIND v(dout0_182) AT=930.025n

.meas tran vdout0_183ck1850 FIND v(dout0_183) AT=930.025n

.meas tran vdout0_184ck1850 FIND v(dout0_184) AT=930.025n

.meas tran vdout0_185ck1850 FIND v(dout0_185) AT=930.025n

.meas tran vdout0_186ck1850 FIND v(dout0_186) AT=930.025n

.meas tran vdout0_187ck1850 FIND v(dout0_187) AT=930.025n

.meas tran vdout0_188ck1850 FIND v(dout0_188) AT=930.025n

.meas tran vdout0_189ck1850 FIND v(dout0_189) AT=930.025n

.meas tran vdout0_190ck1850 FIND v(dout0_190) AT=930.025n

.meas tran vdout0_191ck1850 FIND v(dout0_191) AT=930.025n

.meas tran vdout0_192ck1850 FIND v(dout0_192) AT=930.025n

.meas tran vdout0_193ck1850 FIND v(dout0_193) AT=930.025n

.meas tran vdout0_194ck1850 FIND v(dout0_194) AT=930.025n

.meas tran vdout0_195ck1850 FIND v(dout0_195) AT=930.025n

.meas tran vdout0_196ck1850 FIND v(dout0_196) AT=930.025n

.meas tran vdout0_197ck1850 FIND v(dout0_197) AT=930.025n

.meas tran vdout0_198ck1850 FIND v(dout0_198) AT=930.025n

.meas tran vdout0_199ck1850 FIND v(dout0_199) AT=930.025n

.meas tran vdout0_200ck1850 FIND v(dout0_200) AT=930.025n

.meas tran vdout0_201ck1850 FIND v(dout0_201) AT=930.025n

.meas tran vdout0_202ck1850 FIND v(dout0_202) AT=930.025n

.meas tran vdout0_203ck1850 FIND v(dout0_203) AT=930.025n

.meas tran vdout0_204ck1850 FIND v(dout0_204) AT=930.025n

.meas tran vdout0_205ck1850 FIND v(dout0_205) AT=930.025n

.meas tran vdout0_206ck1850 FIND v(dout0_206) AT=930.025n

.meas tran vdout0_207ck1850 FIND v(dout0_207) AT=930.025n

.meas tran vdout0_208ck1850 FIND v(dout0_208) AT=930.025n

.meas tran vdout0_209ck1850 FIND v(dout0_209) AT=930.025n

.meas tran vdout0_210ck1850 FIND v(dout0_210) AT=930.025n

.meas tran vdout0_211ck1850 FIND v(dout0_211) AT=930.025n

.meas tran vdout0_212ck1850 FIND v(dout0_212) AT=930.025n

.meas tran vdout0_213ck1850 FIND v(dout0_213) AT=930.025n

.meas tran vdout0_214ck1850 FIND v(dout0_214) AT=930.025n

.meas tran vdout0_215ck1850 FIND v(dout0_215) AT=930.025n

.meas tran vdout0_216ck1850 FIND v(dout0_216) AT=930.025n

.meas tran vdout0_217ck1850 FIND v(dout0_217) AT=930.025n

.meas tran vdout0_218ck1850 FIND v(dout0_218) AT=930.025n

.meas tran vdout0_219ck1850 FIND v(dout0_219) AT=930.025n

.meas tran vdout0_220ck1850 FIND v(dout0_220) AT=930.025n

.meas tran vdout0_221ck1850 FIND v(dout0_221) AT=930.025n

.meas tran vdout0_222ck1850 FIND v(dout0_222) AT=930.025n

.meas tran vdout0_223ck1850 FIND v(dout0_223) AT=930.025n

.meas tran vdout0_224ck1850 FIND v(dout0_224) AT=930.025n

.meas tran vdout0_225ck1850 FIND v(dout0_225) AT=930.025n

.meas tran vdout0_226ck1850 FIND v(dout0_226) AT=930.025n

.meas tran vdout0_227ck1850 FIND v(dout0_227) AT=930.025n

.meas tran vdout0_228ck1850 FIND v(dout0_228) AT=930.025n

.meas tran vdout0_229ck1850 FIND v(dout0_229) AT=930.025n

.meas tran vdout0_230ck1850 FIND v(dout0_230) AT=930.025n

.meas tran vdout0_231ck1850 FIND v(dout0_231) AT=930.025n

.meas tran vdout0_232ck1850 FIND v(dout0_232) AT=930.025n

.meas tran vdout0_233ck1850 FIND v(dout0_233) AT=930.025n

.meas tran vdout0_234ck1850 FIND v(dout0_234) AT=930.025n

.meas tran vdout0_235ck1850 FIND v(dout0_235) AT=930.025n

.meas tran vdout0_236ck1850 FIND v(dout0_236) AT=930.025n

.meas tran vdout0_237ck1850 FIND v(dout0_237) AT=930.025n

.meas tran vdout0_238ck1850 FIND v(dout0_238) AT=930.025n

.meas tran vdout0_239ck1850 FIND v(dout0_239) AT=930.025n

.meas tran vdout0_240ck1850 FIND v(dout0_240) AT=930.025n

.meas tran vdout0_241ck1850 FIND v(dout0_241) AT=930.025n

.meas tran vdout0_242ck1850 FIND v(dout0_242) AT=930.025n

.meas tran vdout0_243ck1850 FIND v(dout0_243) AT=930.025n

.meas tran vdout0_244ck1850 FIND v(dout0_244) AT=930.025n

.meas tran vdout0_245ck1850 FIND v(dout0_245) AT=930.025n

.meas tran vdout0_246ck1850 FIND v(dout0_246) AT=930.025n

.meas tran vdout0_247ck1850 FIND v(dout0_247) AT=930.025n

.meas tran vdout0_248ck1850 FIND v(dout0_248) AT=930.025n

.meas tran vdout0_249ck1850 FIND v(dout0_249) AT=930.025n

.meas tran vdout0_250ck1850 FIND v(dout0_250) AT=930.025n

.meas tran vdout0_251ck1850 FIND v(dout0_251) AT=930.025n

.meas tran vdout0_252ck1850 FIND v(dout0_252) AT=930.025n

.meas tran vdout0_253ck1850 FIND v(dout0_253) AT=930.025n

.meas tran vdout0_254ck1850 FIND v(dout0_254) AT=930.025n

.meas tran vdout0_255ck1850 FIND v(dout0_255) AT=930.025n

.meas tran vdout0_0ck1910 FIND v(dout0_0) AT=960.025n

.meas tran vdout0_1ck1910 FIND v(dout0_1) AT=960.025n

.meas tran vdout0_2ck1910 FIND v(dout0_2) AT=960.025n

.meas tran vdout0_3ck1910 FIND v(dout0_3) AT=960.025n

.meas tran vdout0_4ck1910 FIND v(dout0_4) AT=960.025n

.meas tran vdout0_5ck1910 FIND v(dout0_5) AT=960.025n

.meas tran vdout0_6ck1910 FIND v(dout0_6) AT=960.025n

.meas tran vdout0_7ck1910 FIND v(dout0_7) AT=960.025n

.meas tran vdout0_8ck1910 FIND v(dout0_8) AT=960.025n

.meas tran vdout0_9ck1910 FIND v(dout0_9) AT=960.025n

.meas tran vdout0_10ck1910 FIND v(dout0_10) AT=960.025n

.meas tran vdout0_11ck1910 FIND v(dout0_11) AT=960.025n

.meas tran vdout0_12ck1910 FIND v(dout0_12) AT=960.025n

.meas tran vdout0_13ck1910 FIND v(dout0_13) AT=960.025n

.meas tran vdout0_14ck1910 FIND v(dout0_14) AT=960.025n

.meas tran vdout0_15ck1910 FIND v(dout0_15) AT=960.025n

.meas tran vdout0_16ck1910 FIND v(dout0_16) AT=960.025n

.meas tran vdout0_17ck1910 FIND v(dout0_17) AT=960.025n

.meas tran vdout0_18ck1910 FIND v(dout0_18) AT=960.025n

.meas tran vdout0_19ck1910 FIND v(dout0_19) AT=960.025n

.meas tran vdout0_20ck1910 FIND v(dout0_20) AT=960.025n

.meas tran vdout0_21ck1910 FIND v(dout0_21) AT=960.025n

.meas tran vdout0_22ck1910 FIND v(dout0_22) AT=960.025n

.meas tran vdout0_23ck1910 FIND v(dout0_23) AT=960.025n

.meas tran vdout0_24ck1910 FIND v(dout0_24) AT=960.025n

.meas tran vdout0_25ck1910 FIND v(dout0_25) AT=960.025n

.meas tran vdout0_26ck1910 FIND v(dout0_26) AT=960.025n

.meas tran vdout0_27ck1910 FIND v(dout0_27) AT=960.025n

.meas tran vdout0_28ck1910 FIND v(dout0_28) AT=960.025n

.meas tran vdout0_29ck1910 FIND v(dout0_29) AT=960.025n

.meas tran vdout0_30ck1910 FIND v(dout0_30) AT=960.025n

.meas tran vdout0_31ck1910 FIND v(dout0_31) AT=960.025n

.meas tran vdout0_32ck1910 FIND v(dout0_32) AT=960.025n

.meas tran vdout0_33ck1910 FIND v(dout0_33) AT=960.025n

.meas tran vdout0_34ck1910 FIND v(dout0_34) AT=960.025n

.meas tran vdout0_35ck1910 FIND v(dout0_35) AT=960.025n

.meas tran vdout0_36ck1910 FIND v(dout0_36) AT=960.025n

.meas tran vdout0_37ck1910 FIND v(dout0_37) AT=960.025n

.meas tran vdout0_38ck1910 FIND v(dout0_38) AT=960.025n

.meas tran vdout0_39ck1910 FIND v(dout0_39) AT=960.025n

.meas tran vdout0_40ck1910 FIND v(dout0_40) AT=960.025n

.meas tran vdout0_41ck1910 FIND v(dout0_41) AT=960.025n

.meas tran vdout0_42ck1910 FIND v(dout0_42) AT=960.025n

.meas tran vdout0_43ck1910 FIND v(dout0_43) AT=960.025n

.meas tran vdout0_44ck1910 FIND v(dout0_44) AT=960.025n

.meas tran vdout0_45ck1910 FIND v(dout0_45) AT=960.025n

.meas tran vdout0_46ck1910 FIND v(dout0_46) AT=960.025n

.meas tran vdout0_47ck1910 FIND v(dout0_47) AT=960.025n

.meas tran vdout0_48ck1910 FIND v(dout0_48) AT=960.025n

.meas tran vdout0_49ck1910 FIND v(dout0_49) AT=960.025n

.meas tran vdout0_50ck1910 FIND v(dout0_50) AT=960.025n

.meas tran vdout0_51ck1910 FIND v(dout0_51) AT=960.025n

.meas tran vdout0_52ck1910 FIND v(dout0_52) AT=960.025n

.meas tran vdout0_53ck1910 FIND v(dout0_53) AT=960.025n

.meas tran vdout0_54ck1910 FIND v(dout0_54) AT=960.025n

.meas tran vdout0_55ck1910 FIND v(dout0_55) AT=960.025n

.meas tran vdout0_56ck1910 FIND v(dout0_56) AT=960.025n

.meas tran vdout0_57ck1910 FIND v(dout0_57) AT=960.025n

.meas tran vdout0_58ck1910 FIND v(dout0_58) AT=960.025n

.meas tran vdout0_59ck1910 FIND v(dout0_59) AT=960.025n

.meas tran vdout0_60ck1910 FIND v(dout0_60) AT=960.025n

.meas tran vdout0_61ck1910 FIND v(dout0_61) AT=960.025n

.meas tran vdout0_62ck1910 FIND v(dout0_62) AT=960.025n

.meas tran vdout0_63ck1910 FIND v(dout0_63) AT=960.025n

.meas tran vdout0_64ck1910 FIND v(dout0_64) AT=960.025n

.meas tran vdout0_65ck1910 FIND v(dout0_65) AT=960.025n

.meas tran vdout0_66ck1910 FIND v(dout0_66) AT=960.025n

.meas tran vdout0_67ck1910 FIND v(dout0_67) AT=960.025n

.meas tran vdout0_68ck1910 FIND v(dout0_68) AT=960.025n

.meas tran vdout0_69ck1910 FIND v(dout0_69) AT=960.025n

.meas tran vdout0_70ck1910 FIND v(dout0_70) AT=960.025n

.meas tran vdout0_71ck1910 FIND v(dout0_71) AT=960.025n

.meas tran vdout0_72ck1910 FIND v(dout0_72) AT=960.025n

.meas tran vdout0_73ck1910 FIND v(dout0_73) AT=960.025n

.meas tran vdout0_74ck1910 FIND v(dout0_74) AT=960.025n

.meas tran vdout0_75ck1910 FIND v(dout0_75) AT=960.025n

.meas tran vdout0_76ck1910 FIND v(dout0_76) AT=960.025n

.meas tran vdout0_77ck1910 FIND v(dout0_77) AT=960.025n

.meas tran vdout0_78ck1910 FIND v(dout0_78) AT=960.025n

.meas tran vdout0_79ck1910 FIND v(dout0_79) AT=960.025n

.meas tran vdout0_80ck1910 FIND v(dout0_80) AT=960.025n

.meas tran vdout0_81ck1910 FIND v(dout0_81) AT=960.025n

.meas tran vdout0_82ck1910 FIND v(dout0_82) AT=960.025n

.meas tran vdout0_83ck1910 FIND v(dout0_83) AT=960.025n

.meas tran vdout0_84ck1910 FIND v(dout0_84) AT=960.025n

.meas tran vdout0_85ck1910 FIND v(dout0_85) AT=960.025n

.meas tran vdout0_86ck1910 FIND v(dout0_86) AT=960.025n

.meas tran vdout0_87ck1910 FIND v(dout0_87) AT=960.025n

.meas tran vdout0_88ck1910 FIND v(dout0_88) AT=960.025n

.meas tran vdout0_89ck1910 FIND v(dout0_89) AT=960.025n

.meas tran vdout0_90ck1910 FIND v(dout0_90) AT=960.025n

.meas tran vdout0_91ck1910 FIND v(dout0_91) AT=960.025n

.meas tran vdout0_92ck1910 FIND v(dout0_92) AT=960.025n

.meas tran vdout0_93ck1910 FIND v(dout0_93) AT=960.025n

.meas tran vdout0_94ck1910 FIND v(dout0_94) AT=960.025n

.meas tran vdout0_95ck1910 FIND v(dout0_95) AT=960.025n

.meas tran vdout0_96ck1910 FIND v(dout0_96) AT=960.025n

.meas tran vdout0_97ck1910 FIND v(dout0_97) AT=960.025n

.meas tran vdout0_98ck1910 FIND v(dout0_98) AT=960.025n

.meas tran vdout0_99ck1910 FIND v(dout0_99) AT=960.025n

.meas tran vdout0_100ck1910 FIND v(dout0_100) AT=960.025n

.meas tran vdout0_101ck1910 FIND v(dout0_101) AT=960.025n

.meas tran vdout0_102ck1910 FIND v(dout0_102) AT=960.025n

.meas tran vdout0_103ck1910 FIND v(dout0_103) AT=960.025n

.meas tran vdout0_104ck1910 FIND v(dout0_104) AT=960.025n

.meas tran vdout0_105ck1910 FIND v(dout0_105) AT=960.025n

.meas tran vdout0_106ck1910 FIND v(dout0_106) AT=960.025n

.meas tran vdout0_107ck1910 FIND v(dout0_107) AT=960.025n

.meas tran vdout0_108ck1910 FIND v(dout0_108) AT=960.025n

.meas tran vdout0_109ck1910 FIND v(dout0_109) AT=960.025n

.meas tran vdout0_110ck1910 FIND v(dout0_110) AT=960.025n

.meas tran vdout0_111ck1910 FIND v(dout0_111) AT=960.025n

.meas tran vdout0_112ck1910 FIND v(dout0_112) AT=960.025n

.meas tran vdout0_113ck1910 FIND v(dout0_113) AT=960.025n

.meas tran vdout0_114ck1910 FIND v(dout0_114) AT=960.025n

.meas tran vdout0_115ck1910 FIND v(dout0_115) AT=960.025n

.meas tran vdout0_116ck1910 FIND v(dout0_116) AT=960.025n

.meas tran vdout0_117ck1910 FIND v(dout0_117) AT=960.025n

.meas tran vdout0_118ck1910 FIND v(dout0_118) AT=960.025n

.meas tran vdout0_119ck1910 FIND v(dout0_119) AT=960.025n

.meas tran vdout0_120ck1910 FIND v(dout0_120) AT=960.025n

.meas tran vdout0_121ck1910 FIND v(dout0_121) AT=960.025n

.meas tran vdout0_122ck1910 FIND v(dout0_122) AT=960.025n

.meas tran vdout0_123ck1910 FIND v(dout0_123) AT=960.025n

.meas tran vdout0_124ck1910 FIND v(dout0_124) AT=960.025n

.meas tran vdout0_125ck1910 FIND v(dout0_125) AT=960.025n

.meas tran vdout0_126ck1910 FIND v(dout0_126) AT=960.025n

.meas tran vdout0_127ck1910 FIND v(dout0_127) AT=960.025n

.meas tran vdout0_128ck1910 FIND v(dout0_128) AT=960.025n

.meas tran vdout0_129ck1910 FIND v(dout0_129) AT=960.025n

.meas tran vdout0_130ck1910 FIND v(dout0_130) AT=960.025n

.meas tran vdout0_131ck1910 FIND v(dout0_131) AT=960.025n

.meas tran vdout0_132ck1910 FIND v(dout0_132) AT=960.025n

.meas tran vdout0_133ck1910 FIND v(dout0_133) AT=960.025n

.meas tran vdout0_134ck1910 FIND v(dout0_134) AT=960.025n

.meas tran vdout0_135ck1910 FIND v(dout0_135) AT=960.025n

.meas tran vdout0_136ck1910 FIND v(dout0_136) AT=960.025n

.meas tran vdout0_137ck1910 FIND v(dout0_137) AT=960.025n

.meas tran vdout0_138ck1910 FIND v(dout0_138) AT=960.025n

.meas tran vdout0_139ck1910 FIND v(dout0_139) AT=960.025n

.meas tran vdout0_140ck1910 FIND v(dout0_140) AT=960.025n

.meas tran vdout0_141ck1910 FIND v(dout0_141) AT=960.025n

.meas tran vdout0_142ck1910 FIND v(dout0_142) AT=960.025n

.meas tran vdout0_143ck1910 FIND v(dout0_143) AT=960.025n

.meas tran vdout0_144ck1910 FIND v(dout0_144) AT=960.025n

.meas tran vdout0_145ck1910 FIND v(dout0_145) AT=960.025n

.meas tran vdout0_146ck1910 FIND v(dout0_146) AT=960.025n

.meas tran vdout0_147ck1910 FIND v(dout0_147) AT=960.025n

.meas tran vdout0_148ck1910 FIND v(dout0_148) AT=960.025n

.meas tran vdout0_149ck1910 FIND v(dout0_149) AT=960.025n

.meas tran vdout0_150ck1910 FIND v(dout0_150) AT=960.025n

.meas tran vdout0_151ck1910 FIND v(dout0_151) AT=960.025n

.meas tran vdout0_152ck1910 FIND v(dout0_152) AT=960.025n

.meas tran vdout0_153ck1910 FIND v(dout0_153) AT=960.025n

.meas tran vdout0_154ck1910 FIND v(dout0_154) AT=960.025n

.meas tran vdout0_155ck1910 FIND v(dout0_155) AT=960.025n

.meas tran vdout0_156ck1910 FIND v(dout0_156) AT=960.025n

.meas tran vdout0_157ck1910 FIND v(dout0_157) AT=960.025n

.meas tran vdout0_158ck1910 FIND v(dout0_158) AT=960.025n

.meas tran vdout0_159ck1910 FIND v(dout0_159) AT=960.025n

.meas tran vdout0_160ck1910 FIND v(dout0_160) AT=960.025n

.meas tran vdout0_161ck1910 FIND v(dout0_161) AT=960.025n

.meas tran vdout0_162ck1910 FIND v(dout0_162) AT=960.025n

.meas tran vdout0_163ck1910 FIND v(dout0_163) AT=960.025n

.meas tran vdout0_164ck1910 FIND v(dout0_164) AT=960.025n

.meas tran vdout0_165ck1910 FIND v(dout0_165) AT=960.025n

.meas tran vdout0_166ck1910 FIND v(dout0_166) AT=960.025n

.meas tran vdout0_167ck1910 FIND v(dout0_167) AT=960.025n

.meas tran vdout0_168ck1910 FIND v(dout0_168) AT=960.025n

.meas tran vdout0_169ck1910 FIND v(dout0_169) AT=960.025n

.meas tran vdout0_170ck1910 FIND v(dout0_170) AT=960.025n

.meas tran vdout0_171ck1910 FIND v(dout0_171) AT=960.025n

.meas tran vdout0_172ck1910 FIND v(dout0_172) AT=960.025n

.meas tran vdout0_173ck1910 FIND v(dout0_173) AT=960.025n

.meas tran vdout0_174ck1910 FIND v(dout0_174) AT=960.025n

.meas tran vdout0_175ck1910 FIND v(dout0_175) AT=960.025n

.meas tran vdout0_176ck1910 FIND v(dout0_176) AT=960.025n

.meas tran vdout0_177ck1910 FIND v(dout0_177) AT=960.025n

.meas tran vdout0_178ck1910 FIND v(dout0_178) AT=960.025n

.meas tran vdout0_179ck1910 FIND v(dout0_179) AT=960.025n

.meas tran vdout0_180ck1910 FIND v(dout0_180) AT=960.025n

.meas tran vdout0_181ck1910 FIND v(dout0_181) AT=960.025n

.meas tran vdout0_182ck1910 FIND v(dout0_182) AT=960.025n

.meas tran vdout0_183ck1910 FIND v(dout0_183) AT=960.025n

.meas tran vdout0_184ck1910 FIND v(dout0_184) AT=960.025n

.meas tran vdout0_185ck1910 FIND v(dout0_185) AT=960.025n

.meas tran vdout0_186ck1910 FIND v(dout0_186) AT=960.025n

.meas tran vdout0_187ck1910 FIND v(dout0_187) AT=960.025n

.meas tran vdout0_188ck1910 FIND v(dout0_188) AT=960.025n

.meas tran vdout0_189ck1910 FIND v(dout0_189) AT=960.025n

.meas tran vdout0_190ck1910 FIND v(dout0_190) AT=960.025n

.meas tran vdout0_191ck1910 FIND v(dout0_191) AT=960.025n

.meas tran vdout0_192ck1910 FIND v(dout0_192) AT=960.025n

.meas tran vdout0_193ck1910 FIND v(dout0_193) AT=960.025n

.meas tran vdout0_194ck1910 FIND v(dout0_194) AT=960.025n

.meas tran vdout0_195ck1910 FIND v(dout0_195) AT=960.025n

.meas tran vdout0_196ck1910 FIND v(dout0_196) AT=960.025n

.meas tran vdout0_197ck1910 FIND v(dout0_197) AT=960.025n

.meas tran vdout0_198ck1910 FIND v(dout0_198) AT=960.025n

.meas tran vdout0_199ck1910 FIND v(dout0_199) AT=960.025n

.meas tran vdout0_200ck1910 FIND v(dout0_200) AT=960.025n

.meas tran vdout0_201ck1910 FIND v(dout0_201) AT=960.025n

.meas tran vdout0_202ck1910 FIND v(dout0_202) AT=960.025n

.meas tran vdout0_203ck1910 FIND v(dout0_203) AT=960.025n

.meas tran vdout0_204ck1910 FIND v(dout0_204) AT=960.025n

.meas tran vdout0_205ck1910 FIND v(dout0_205) AT=960.025n

.meas tran vdout0_206ck1910 FIND v(dout0_206) AT=960.025n

.meas tran vdout0_207ck1910 FIND v(dout0_207) AT=960.025n

.meas tran vdout0_208ck1910 FIND v(dout0_208) AT=960.025n

.meas tran vdout0_209ck1910 FIND v(dout0_209) AT=960.025n

.meas tran vdout0_210ck1910 FIND v(dout0_210) AT=960.025n

.meas tran vdout0_211ck1910 FIND v(dout0_211) AT=960.025n

.meas tran vdout0_212ck1910 FIND v(dout0_212) AT=960.025n

.meas tran vdout0_213ck1910 FIND v(dout0_213) AT=960.025n

.meas tran vdout0_214ck1910 FIND v(dout0_214) AT=960.025n

.meas tran vdout0_215ck1910 FIND v(dout0_215) AT=960.025n

.meas tran vdout0_216ck1910 FIND v(dout0_216) AT=960.025n

.meas tran vdout0_217ck1910 FIND v(dout0_217) AT=960.025n

.meas tran vdout0_218ck1910 FIND v(dout0_218) AT=960.025n

.meas tran vdout0_219ck1910 FIND v(dout0_219) AT=960.025n

.meas tran vdout0_220ck1910 FIND v(dout0_220) AT=960.025n

.meas tran vdout0_221ck1910 FIND v(dout0_221) AT=960.025n

.meas tran vdout0_222ck1910 FIND v(dout0_222) AT=960.025n

.meas tran vdout0_223ck1910 FIND v(dout0_223) AT=960.025n

.meas tran vdout0_224ck1910 FIND v(dout0_224) AT=960.025n

.meas tran vdout0_225ck1910 FIND v(dout0_225) AT=960.025n

.meas tran vdout0_226ck1910 FIND v(dout0_226) AT=960.025n

.meas tran vdout0_227ck1910 FIND v(dout0_227) AT=960.025n

.meas tran vdout0_228ck1910 FIND v(dout0_228) AT=960.025n

.meas tran vdout0_229ck1910 FIND v(dout0_229) AT=960.025n

.meas tran vdout0_230ck1910 FIND v(dout0_230) AT=960.025n

.meas tran vdout0_231ck1910 FIND v(dout0_231) AT=960.025n

.meas tran vdout0_232ck1910 FIND v(dout0_232) AT=960.025n

.meas tran vdout0_233ck1910 FIND v(dout0_233) AT=960.025n

.meas tran vdout0_234ck1910 FIND v(dout0_234) AT=960.025n

.meas tran vdout0_235ck1910 FIND v(dout0_235) AT=960.025n

.meas tran vdout0_236ck1910 FIND v(dout0_236) AT=960.025n

.meas tran vdout0_237ck1910 FIND v(dout0_237) AT=960.025n

.meas tran vdout0_238ck1910 FIND v(dout0_238) AT=960.025n

.meas tran vdout0_239ck1910 FIND v(dout0_239) AT=960.025n

.meas tran vdout0_240ck1910 FIND v(dout0_240) AT=960.025n

.meas tran vdout0_241ck1910 FIND v(dout0_241) AT=960.025n

.meas tran vdout0_242ck1910 FIND v(dout0_242) AT=960.025n

.meas tran vdout0_243ck1910 FIND v(dout0_243) AT=960.025n

.meas tran vdout0_244ck1910 FIND v(dout0_244) AT=960.025n

.meas tran vdout0_245ck1910 FIND v(dout0_245) AT=960.025n

.meas tran vdout0_246ck1910 FIND v(dout0_246) AT=960.025n

.meas tran vdout0_247ck1910 FIND v(dout0_247) AT=960.025n

.meas tran vdout0_248ck1910 FIND v(dout0_248) AT=960.025n

.meas tran vdout0_249ck1910 FIND v(dout0_249) AT=960.025n

.meas tran vdout0_250ck1910 FIND v(dout0_250) AT=960.025n

.meas tran vdout0_251ck1910 FIND v(dout0_251) AT=960.025n

.meas tran vdout0_252ck1910 FIND v(dout0_252) AT=960.025n

.meas tran vdout0_253ck1910 FIND v(dout0_253) AT=960.025n

.meas tran vdout0_254ck1910 FIND v(dout0_254) AT=960.025n

.meas tran vdout0_255ck1910 FIND v(dout0_255) AT=960.025n

.meas tran vdout0_0ck1920 FIND v(dout0_0) AT=965.025n

.meas tran vdout0_1ck1920 FIND v(dout0_1) AT=965.025n

.meas tran vdout0_2ck1920 FIND v(dout0_2) AT=965.025n

.meas tran vdout0_3ck1920 FIND v(dout0_3) AT=965.025n

.meas tran vdout0_4ck1920 FIND v(dout0_4) AT=965.025n

.meas tran vdout0_5ck1920 FIND v(dout0_5) AT=965.025n

.meas tran vdout0_6ck1920 FIND v(dout0_6) AT=965.025n

.meas tran vdout0_7ck1920 FIND v(dout0_7) AT=965.025n

.meas tran vdout0_8ck1920 FIND v(dout0_8) AT=965.025n

.meas tran vdout0_9ck1920 FIND v(dout0_9) AT=965.025n

.meas tran vdout0_10ck1920 FIND v(dout0_10) AT=965.025n

.meas tran vdout0_11ck1920 FIND v(dout0_11) AT=965.025n

.meas tran vdout0_12ck1920 FIND v(dout0_12) AT=965.025n

.meas tran vdout0_13ck1920 FIND v(dout0_13) AT=965.025n

.meas tran vdout0_14ck1920 FIND v(dout0_14) AT=965.025n

.meas tran vdout0_15ck1920 FIND v(dout0_15) AT=965.025n

.meas tran vdout0_16ck1920 FIND v(dout0_16) AT=965.025n

.meas tran vdout0_17ck1920 FIND v(dout0_17) AT=965.025n

.meas tran vdout0_18ck1920 FIND v(dout0_18) AT=965.025n

.meas tran vdout0_19ck1920 FIND v(dout0_19) AT=965.025n

.meas tran vdout0_20ck1920 FIND v(dout0_20) AT=965.025n

.meas tran vdout0_21ck1920 FIND v(dout0_21) AT=965.025n

.meas tran vdout0_22ck1920 FIND v(dout0_22) AT=965.025n

.meas tran vdout0_23ck1920 FIND v(dout0_23) AT=965.025n

.meas tran vdout0_24ck1920 FIND v(dout0_24) AT=965.025n

.meas tran vdout0_25ck1920 FIND v(dout0_25) AT=965.025n

.meas tran vdout0_26ck1920 FIND v(dout0_26) AT=965.025n

.meas tran vdout0_27ck1920 FIND v(dout0_27) AT=965.025n

.meas tran vdout0_28ck1920 FIND v(dout0_28) AT=965.025n

.meas tran vdout0_29ck1920 FIND v(dout0_29) AT=965.025n

.meas tran vdout0_30ck1920 FIND v(dout0_30) AT=965.025n

.meas tran vdout0_31ck1920 FIND v(dout0_31) AT=965.025n

.meas tran vdout0_32ck1920 FIND v(dout0_32) AT=965.025n

.meas tran vdout0_33ck1920 FIND v(dout0_33) AT=965.025n

.meas tran vdout0_34ck1920 FIND v(dout0_34) AT=965.025n

.meas tran vdout0_35ck1920 FIND v(dout0_35) AT=965.025n

.meas tran vdout0_36ck1920 FIND v(dout0_36) AT=965.025n

.meas tran vdout0_37ck1920 FIND v(dout0_37) AT=965.025n

.meas tran vdout0_38ck1920 FIND v(dout0_38) AT=965.025n

.meas tran vdout0_39ck1920 FIND v(dout0_39) AT=965.025n

.meas tran vdout0_40ck1920 FIND v(dout0_40) AT=965.025n

.meas tran vdout0_41ck1920 FIND v(dout0_41) AT=965.025n

.meas tran vdout0_42ck1920 FIND v(dout0_42) AT=965.025n

.meas tran vdout0_43ck1920 FIND v(dout0_43) AT=965.025n

.meas tran vdout0_44ck1920 FIND v(dout0_44) AT=965.025n

.meas tran vdout0_45ck1920 FIND v(dout0_45) AT=965.025n

.meas tran vdout0_46ck1920 FIND v(dout0_46) AT=965.025n

.meas tran vdout0_47ck1920 FIND v(dout0_47) AT=965.025n

.meas tran vdout0_48ck1920 FIND v(dout0_48) AT=965.025n

.meas tran vdout0_49ck1920 FIND v(dout0_49) AT=965.025n

.meas tran vdout0_50ck1920 FIND v(dout0_50) AT=965.025n

.meas tran vdout0_51ck1920 FIND v(dout0_51) AT=965.025n

.meas tran vdout0_52ck1920 FIND v(dout0_52) AT=965.025n

.meas tran vdout0_53ck1920 FIND v(dout0_53) AT=965.025n

.meas tran vdout0_54ck1920 FIND v(dout0_54) AT=965.025n

.meas tran vdout0_55ck1920 FIND v(dout0_55) AT=965.025n

.meas tran vdout0_56ck1920 FIND v(dout0_56) AT=965.025n

.meas tran vdout0_57ck1920 FIND v(dout0_57) AT=965.025n

.meas tran vdout0_58ck1920 FIND v(dout0_58) AT=965.025n

.meas tran vdout0_59ck1920 FIND v(dout0_59) AT=965.025n

.meas tran vdout0_60ck1920 FIND v(dout0_60) AT=965.025n

.meas tran vdout0_61ck1920 FIND v(dout0_61) AT=965.025n

.meas tran vdout0_62ck1920 FIND v(dout0_62) AT=965.025n

.meas tran vdout0_63ck1920 FIND v(dout0_63) AT=965.025n

.meas tran vdout0_64ck1920 FIND v(dout0_64) AT=965.025n

.meas tran vdout0_65ck1920 FIND v(dout0_65) AT=965.025n

.meas tran vdout0_66ck1920 FIND v(dout0_66) AT=965.025n

.meas tran vdout0_67ck1920 FIND v(dout0_67) AT=965.025n

.meas tran vdout0_68ck1920 FIND v(dout0_68) AT=965.025n

.meas tran vdout0_69ck1920 FIND v(dout0_69) AT=965.025n

.meas tran vdout0_70ck1920 FIND v(dout0_70) AT=965.025n

.meas tran vdout0_71ck1920 FIND v(dout0_71) AT=965.025n

.meas tran vdout0_72ck1920 FIND v(dout0_72) AT=965.025n

.meas tran vdout0_73ck1920 FIND v(dout0_73) AT=965.025n

.meas tran vdout0_74ck1920 FIND v(dout0_74) AT=965.025n

.meas tran vdout0_75ck1920 FIND v(dout0_75) AT=965.025n

.meas tran vdout0_76ck1920 FIND v(dout0_76) AT=965.025n

.meas tran vdout0_77ck1920 FIND v(dout0_77) AT=965.025n

.meas tran vdout0_78ck1920 FIND v(dout0_78) AT=965.025n

.meas tran vdout0_79ck1920 FIND v(dout0_79) AT=965.025n

.meas tran vdout0_80ck1920 FIND v(dout0_80) AT=965.025n

.meas tran vdout0_81ck1920 FIND v(dout0_81) AT=965.025n

.meas tran vdout0_82ck1920 FIND v(dout0_82) AT=965.025n

.meas tran vdout0_83ck1920 FIND v(dout0_83) AT=965.025n

.meas tran vdout0_84ck1920 FIND v(dout0_84) AT=965.025n

.meas tran vdout0_85ck1920 FIND v(dout0_85) AT=965.025n

.meas tran vdout0_86ck1920 FIND v(dout0_86) AT=965.025n

.meas tran vdout0_87ck1920 FIND v(dout0_87) AT=965.025n

.meas tran vdout0_88ck1920 FIND v(dout0_88) AT=965.025n

.meas tran vdout0_89ck1920 FIND v(dout0_89) AT=965.025n

.meas tran vdout0_90ck1920 FIND v(dout0_90) AT=965.025n

.meas tran vdout0_91ck1920 FIND v(dout0_91) AT=965.025n

.meas tran vdout0_92ck1920 FIND v(dout0_92) AT=965.025n

.meas tran vdout0_93ck1920 FIND v(dout0_93) AT=965.025n

.meas tran vdout0_94ck1920 FIND v(dout0_94) AT=965.025n

.meas tran vdout0_95ck1920 FIND v(dout0_95) AT=965.025n

.meas tran vdout0_96ck1920 FIND v(dout0_96) AT=965.025n

.meas tran vdout0_97ck1920 FIND v(dout0_97) AT=965.025n

.meas tran vdout0_98ck1920 FIND v(dout0_98) AT=965.025n

.meas tran vdout0_99ck1920 FIND v(dout0_99) AT=965.025n

.meas tran vdout0_100ck1920 FIND v(dout0_100) AT=965.025n

.meas tran vdout0_101ck1920 FIND v(dout0_101) AT=965.025n

.meas tran vdout0_102ck1920 FIND v(dout0_102) AT=965.025n

.meas tran vdout0_103ck1920 FIND v(dout0_103) AT=965.025n

.meas tran vdout0_104ck1920 FIND v(dout0_104) AT=965.025n

.meas tran vdout0_105ck1920 FIND v(dout0_105) AT=965.025n

.meas tran vdout0_106ck1920 FIND v(dout0_106) AT=965.025n

.meas tran vdout0_107ck1920 FIND v(dout0_107) AT=965.025n

.meas tran vdout0_108ck1920 FIND v(dout0_108) AT=965.025n

.meas tran vdout0_109ck1920 FIND v(dout0_109) AT=965.025n

.meas tran vdout0_110ck1920 FIND v(dout0_110) AT=965.025n

.meas tran vdout0_111ck1920 FIND v(dout0_111) AT=965.025n

.meas tran vdout0_112ck1920 FIND v(dout0_112) AT=965.025n

.meas tran vdout0_113ck1920 FIND v(dout0_113) AT=965.025n

.meas tran vdout0_114ck1920 FIND v(dout0_114) AT=965.025n

.meas tran vdout0_115ck1920 FIND v(dout0_115) AT=965.025n

.meas tran vdout0_116ck1920 FIND v(dout0_116) AT=965.025n

.meas tran vdout0_117ck1920 FIND v(dout0_117) AT=965.025n

.meas tran vdout0_118ck1920 FIND v(dout0_118) AT=965.025n

.meas tran vdout0_119ck1920 FIND v(dout0_119) AT=965.025n

.meas tran vdout0_120ck1920 FIND v(dout0_120) AT=965.025n

.meas tran vdout0_121ck1920 FIND v(dout0_121) AT=965.025n

.meas tran vdout0_122ck1920 FIND v(dout0_122) AT=965.025n

.meas tran vdout0_123ck1920 FIND v(dout0_123) AT=965.025n

.meas tran vdout0_124ck1920 FIND v(dout0_124) AT=965.025n

.meas tran vdout0_125ck1920 FIND v(dout0_125) AT=965.025n

.meas tran vdout0_126ck1920 FIND v(dout0_126) AT=965.025n

.meas tran vdout0_127ck1920 FIND v(dout0_127) AT=965.025n

.meas tran vdout0_128ck1920 FIND v(dout0_128) AT=965.025n

.meas tran vdout0_129ck1920 FIND v(dout0_129) AT=965.025n

.meas tran vdout0_130ck1920 FIND v(dout0_130) AT=965.025n

.meas tran vdout0_131ck1920 FIND v(dout0_131) AT=965.025n

.meas tran vdout0_132ck1920 FIND v(dout0_132) AT=965.025n

.meas tran vdout0_133ck1920 FIND v(dout0_133) AT=965.025n

.meas tran vdout0_134ck1920 FIND v(dout0_134) AT=965.025n

.meas tran vdout0_135ck1920 FIND v(dout0_135) AT=965.025n

.meas tran vdout0_136ck1920 FIND v(dout0_136) AT=965.025n

.meas tran vdout0_137ck1920 FIND v(dout0_137) AT=965.025n

.meas tran vdout0_138ck1920 FIND v(dout0_138) AT=965.025n

.meas tran vdout0_139ck1920 FIND v(dout0_139) AT=965.025n

.meas tran vdout0_140ck1920 FIND v(dout0_140) AT=965.025n

.meas tran vdout0_141ck1920 FIND v(dout0_141) AT=965.025n

.meas tran vdout0_142ck1920 FIND v(dout0_142) AT=965.025n

.meas tran vdout0_143ck1920 FIND v(dout0_143) AT=965.025n

.meas tran vdout0_144ck1920 FIND v(dout0_144) AT=965.025n

.meas tran vdout0_145ck1920 FIND v(dout0_145) AT=965.025n

.meas tran vdout0_146ck1920 FIND v(dout0_146) AT=965.025n

.meas tran vdout0_147ck1920 FIND v(dout0_147) AT=965.025n

.meas tran vdout0_148ck1920 FIND v(dout0_148) AT=965.025n

.meas tran vdout0_149ck1920 FIND v(dout0_149) AT=965.025n

.meas tran vdout0_150ck1920 FIND v(dout0_150) AT=965.025n

.meas tran vdout0_151ck1920 FIND v(dout0_151) AT=965.025n

.meas tran vdout0_152ck1920 FIND v(dout0_152) AT=965.025n

.meas tran vdout0_153ck1920 FIND v(dout0_153) AT=965.025n

.meas tran vdout0_154ck1920 FIND v(dout0_154) AT=965.025n

.meas tran vdout0_155ck1920 FIND v(dout0_155) AT=965.025n

.meas tran vdout0_156ck1920 FIND v(dout0_156) AT=965.025n

.meas tran vdout0_157ck1920 FIND v(dout0_157) AT=965.025n

.meas tran vdout0_158ck1920 FIND v(dout0_158) AT=965.025n

.meas tran vdout0_159ck1920 FIND v(dout0_159) AT=965.025n

.meas tran vdout0_160ck1920 FIND v(dout0_160) AT=965.025n

.meas tran vdout0_161ck1920 FIND v(dout0_161) AT=965.025n

.meas tran vdout0_162ck1920 FIND v(dout0_162) AT=965.025n

.meas tran vdout0_163ck1920 FIND v(dout0_163) AT=965.025n

.meas tran vdout0_164ck1920 FIND v(dout0_164) AT=965.025n

.meas tran vdout0_165ck1920 FIND v(dout0_165) AT=965.025n

.meas tran vdout0_166ck1920 FIND v(dout0_166) AT=965.025n

.meas tran vdout0_167ck1920 FIND v(dout0_167) AT=965.025n

.meas tran vdout0_168ck1920 FIND v(dout0_168) AT=965.025n

.meas tran vdout0_169ck1920 FIND v(dout0_169) AT=965.025n

.meas tran vdout0_170ck1920 FIND v(dout0_170) AT=965.025n

.meas tran vdout0_171ck1920 FIND v(dout0_171) AT=965.025n

.meas tran vdout0_172ck1920 FIND v(dout0_172) AT=965.025n

.meas tran vdout0_173ck1920 FIND v(dout0_173) AT=965.025n

.meas tran vdout0_174ck1920 FIND v(dout0_174) AT=965.025n

.meas tran vdout0_175ck1920 FIND v(dout0_175) AT=965.025n

.meas tran vdout0_176ck1920 FIND v(dout0_176) AT=965.025n

.meas tran vdout0_177ck1920 FIND v(dout0_177) AT=965.025n

.meas tran vdout0_178ck1920 FIND v(dout0_178) AT=965.025n

.meas tran vdout0_179ck1920 FIND v(dout0_179) AT=965.025n

.meas tran vdout0_180ck1920 FIND v(dout0_180) AT=965.025n

.meas tran vdout0_181ck1920 FIND v(dout0_181) AT=965.025n

.meas tran vdout0_182ck1920 FIND v(dout0_182) AT=965.025n

.meas tran vdout0_183ck1920 FIND v(dout0_183) AT=965.025n

.meas tran vdout0_184ck1920 FIND v(dout0_184) AT=965.025n

.meas tran vdout0_185ck1920 FIND v(dout0_185) AT=965.025n

.meas tran vdout0_186ck1920 FIND v(dout0_186) AT=965.025n

.meas tran vdout0_187ck1920 FIND v(dout0_187) AT=965.025n

.meas tran vdout0_188ck1920 FIND v(dout0_188) AT=965.025n

.meas tran vdout0_189ck1920 FIND v(dout0_189) AT=965.025n

.meas tran vdout0_190ck1920 FIND v(dout0_190) AT=965.025n

.meas tran vdout0_191ck1920 FIND v(dout0_191) AT=965.025n

.meas tran vdout0_192ck1920 FIND v(dout0_192) AT=965.025n

.meas tran vdout0_193ck1920 FIND v(dout0_193) AT=965.025n

.meas tran vdout0_194ck1920 FIND v(dout0_194) AT=965.025n

.meas tran vdout0_195ck1920 FIND v(dout0_195) AT=965.025n

.meas tran vdout0_196ck1920 FIND v(dout0_196) AT=965.025n

.meas tran vdout0_197ck1920 FIND v(dout0_197) AT=965.025n

.meas tran vdout0_198ck1920 FIND v(dout0_198) AT=965.025n

.meas tran vdout0_199ck1920 FIND v(dout0_199) AT=965.025n

.meas tran vdout0_200ck1920 FIND v(dout0_200) AT=965.025n

.meas tran vdout0_201ck1920 FIND v(dout0_201) AT=965.025n

.meas tran vdout0_202ck1920 FIND v(dout0_202) AT=965.025n

.meas tran vdout0_203ck1920 FIND v(dout0_203) AT=965.025n

.meas tran vdout0_204ck1920 FIND v(dout0_204) AT=965.025n

.meas tran vdout0_205ck1920 FIND v(dout0_205) AT=965.025n

.meas tran vdout0_206ck1920 FIND v(dout0_206) AT=965.025n

.meas tran vdout0_207ck1920 FIND v(dout0_207) AT=965.025n

.meas tran vdout0_208ck1920 FIND v(dout0_208) AT=965.025n

.meas tran vdout0_209ck1920 FIND v(dout0_209) AT=965.025n

.meas tran vdout0_210ck1920 FIND v(dout0_210) AT=965.025n

.meas tran vdout0_211ck1920 FIND v(dout0_211) AT=965.025n

.meas tran vdout0_212ck1920 FIND v(dout0_212) AT=965.025n

.meas tran vdout0_213ck1920 FIND v(dout0_213) AT=965.025n

.meas tran vdout0_214ck1920 FIND v(dout0_214) AT=965.025n

.meas tran vdout0_215ck1920 FIND v(dout0_215) AT=965.025n

.meas tran vdout0_216ck1920 FIND v(dout0_216) AT=965.025n

.meas tran vdout0_217ck1920 FIND v(dout0_217) AT=965.025n

.meas tran vdout0_218ck1920 FIND v(dout0_218) AT=965.025n

.meas tran vdout0_219ck1920 FIND v(dout0_219) AT=965.025n

.meas tran vdout0_220ck1920 FIND v(dout0_220) AT=965.025n

.meas tran vdout0_221ck1920 FIND v(dout0_221) AT=965.025n

.meas tran vdout0_222ck1920 FIND v(dout0_222) AT=965.025n

.meas tran vdout0_223ck1920 FIND v(dout0_223) AT=965.025n

.meas tran vdout0_224ck1920 FIND v(dout0_224) AT=965.025n

.meas tran vdout0_225ck1920 FIND v(dout0_225) AT=965.025n

.meas tran vdout0_226ck1920 FIND v(dout0_226) AT=965.025n

.meas tran vdout0_227ck1920 FIND v(dout0_227) AT=965.025n

.meas tran vdout0_228ck1920 FIND v(dout0_228) AT=965.025n

.meas tran vdout0_229ck1920 FIND v(dout0_229) AT=965.025n

.meas tran vdout0_230ck1920 FIND v(dout0_230) AT=965.025n

.meas tran vdout0_231ck1920 FIND v(dout0_231) AT=965.025n

.meas tran vdout0_232ck1920 FIND v(dout0_232) AT=965.025n

.meas tran vdout0_233ck1920 FIND v(dout0_233) AT=965.025n

.meas tran vdout0_234ck1920 FIND v(dout0_234) AT=965.025n

.meas tran vdout0_235ck1920 FIND v(dout0_235) AT=965.025n

.meas tran vdout0_236ck1920 FIND v(dout0_236) AT=965.025n

.meas tran vdout0_237ck1920 FIND v(dout0_237) AT=965.025n

.meas tran vdout0_238ck1920 FIND v(dout0_238) AT=965.025n

.meas tran vdout0_239ck1920 FIND v(dout0_239) AT=965.025n

.meas tran vdout0_240ck1920 FIND v(dout0_240) AT=965.025n

.meas tran vdout0_241ck1920 FIND v(dout0_241) AT=965.025n

.meas tran vdout0_242ck1920 FIND v(dout0_242) AT=965.025n

.meas tran vdout0_243ck1920 FIND v(dout0_243) AT=965.025n

.meas tran vdout0_244ck1920 FIND v(dout0_244) AT=965.025n

.meas tran vdout0_245ck1920 FIND v(dout0_245) AT=965.025n

.meas tran vdout0_246ck1920 FIND v(dout0_246) AT=965.025n

.meas tran vdout0_247ck1920 FIND v(dout0_247) AT=965.025n

.meas tran vdout0_248ck1920 FIND v(dout0_248) AT=965.025n

.meas tran vdout0_249ck1920 FIND v(dout0_249) AT=965.025n

.meas tran vdout0_250ck1920 FIND v(dout0_250) AT=965.025n

.meas tran vdout0_251ck1920 FIND v(dout0_251) AT=965.025n

.meas tran vdout0_252ck1920 FIND v(dout0_252) AT=965.025n

.meas tran vdout0_253ck1920 FIND v(dout0_253) AT=965.025n

.meas tran vdout0_254ck1920 FIND v(dout0_254) AT=965.025n

.meas tran vdout0_255ck1920 FIND v(dout0_255) AT=965.025n

.meas tran vdout0_0ck1930 FIND v(dout0_0) AT=970.025n

.meas tran vdout0_1ck1930 FIND v(dout0_1) AT=970.025n

.meas tran vdout0_2ck1930 FIND v(dout0_2) AT=970.025n

.meas tran vdout0_3ck1930 FIND v(dout0_3) AT=970.025n

.meas tran vdout0_4ck1930 FIND v(dout0_4) AT=970.025n

.meas tran vdout0_5ck1930 FIND v(dout0_5) AT=970.025n

.meas tran vdout0_6ck1930 FIND v(dout0_6) AT=970.025n

.meas tran vdout0_7ck1930 FIND v(dout0_7) AT=970.025n

.meas tran vdout0_8ck1930 FIND v(dout0_8) AT=970.025n

.meas tran vdout0_9ck1930 FIND v(dout0_9) AT=970.025n

.meas tran vdout0_10ck1930 FIND v(dout0_10) AT=970.025n

.meas tran vdout0_11ck1930 FIND v(dout0_11) AT=970.025n

.meas tran vdout0_12ck1930 FIND v(dout0_12) AT=970.025n

.meas tran vdout0_13ck1930 FIND v(dout0_13) AT=970.025n

.meas tran vdout0_14ck1930 FIND v(dout0_14) AT=970.025n

.meas tran vdout0_15ck1930 FIND v(dout0_15) AT=970.025n

.meas tran vdout0_16ck1930 FIND v(dout0_16) AT=970.025n

.meas tran vdout0_17ck1930 FIND v(dout0_17) AT=970.025n

.meas tran vdout0_18ck1930 FIND v(dout0_18) AT=970.025n

.meas tran vdout0_19ck1930 FIND v(dout0_19) AT=970.025n

.meas tran vdout0_20ck1930 FIND v(dout0_20) AT=970.025n

.meas tran vdout0_21ck1930 FIND v(dout0_21) AT=970.025n

.meas tran vdout0_22ck1930 FIND v(dout0_22) AT=970.025n

.meas tran vdout0_23ck1930 FIND v(dout0_23) AT=970.025n

.meas tran vdout0_24ck1930 FIND v(dout0_24) AT=970.025n

.meas tran vdout0_25ck1930 FIND v(dout0_25) AT=970.025n

.meas tran vdout0_26ck1930 FIND v(dout0_26) AT=970.025n

.meas tran vdout0_27ck1930 FIND v(dout0_27) AT=970.025n

.meas tran vdout0_28ck1930 FIND v(dout0_28) AT=970.025n

.meas tran vdout0_29ck1930 FIND v(dout0_29) AT=970.025n

.meas tran vdout0_30ck1930 FIND v(dout0_30) AT=970.025n

.meas tran vdout0_31ck1930 FIND v(dout0_31) AT=970.025n

.meas tran vdout0_32ck1930 FIND v(dout0_32) AT=970.025n

.meas tran vdout0_33ck1930 FIND v(dout0_33) AT=970.025n

.meas tran vdout0_34ck1930 FIND v(dout0_34) AT=970.025n

.meas tran vdout0_35ck1930 FIND v(dout0_35) AT=970.025n

.meas tran vdout0_36ck1930 FIND v(dout0_36) AT=970.025n

.meas tran vdout0_37ck1930 FIND v(dout0_37) AT=970.025n

.meas tran vdout0_38ck1930 FIND v(dout0_38) AT=970.025n

.meas tran vdout0_39ck1930 FIND v(dout0_39) AT=970.025n

.meas tran vdout0_40ck1930 FIND v(dout0_40) AT=970.025n

.meas tran vdout0_41ck1930 FIND v(dout0_41) AT=970.025n

.meas tran vdout0_42ck1930 FIND v(dout0_42) AT=970.025n

.meas tran vdout0_43ck1930 FIND v(dout0_43) AT=970.025n

.meas tran vdout0_44ck1930 FIND v(dout0_44) AT=970.025n

.meas tran vdout0_45ck1930 FIND v(dout0_45) AT=970.025n

.meas tran vdout0_46ck1930 FIND v(dout0_46) AT=970.025n

.meas tran vdout0_47ck1930 FIND v(dout0_47) AT=970.025n

.meas tran vdout0_48ck1930 FIND v(dout0_48) AT=970.025n

.meas tran vdout0_49ck1930 FIND v(dout0_49) AT=970.025n

.meas tran vdout0_50ck1930 FIND v(dout0_50) AT=970.025n

.meas tran vdout0_51ck1930 FIND v(dout0_51) AT=970.025n

.meas tran vdout0_52ck1930 FIND v(dout0_52) AT=970.025n

.meas tran vdout0_53ck1930 FIND v(dout0_53) AT=970.025n

.meas tran vdout0_54ck1930 FIND v(dout0_54) AT=970.025n

.meas tran vdout0_55ck1930 FIND v(dout0_55) AT=970.025n

.meas tran vdout0_56ck1930 FIND v(dout0_56) AT=970.025n

.meas tran vdout0_57ck1930 FIND v(dout0_57) AT=970.025n

.meas tran vdout0_58ck1930 FIND v(dout0_58) AT=970.025n

.meas tran vdout0_59ck1930 FIND v(dout0_59) AT=970.025n

.meas tran vdout0_60ck1930 FIND v(dout0_60) AT=970.025n

.meas tran vdout0_61ck1930 FIND v(dout0_61) AT=970.025n

.meas tran vdout0_62ck1930 FIND v(dout0_62) AT=970.025n

.meas tran vdout0_63ck1930 FIND v(dout0_63) AT=970.025n

.meas tran vdout0_64ck1930 FIND v(dout0_64) AT=970.025n

.meas tran vdout0_65ck1930 FIND v(dout0_65) AT=970.025n

.meas tran vdout0_66ck1930 FIND v(dout0_66) AT=970.025n

.meas tran vdout0_67ck1930 FIND v(dout0_67) AT=970.025n

.meas tran vdout0_68ck1930 FIND v(dout0_68) AT=970.025n

.meas tran vdout0_69ck1930 FIND v(dout0_69) AT=970.025n

.meas tran vdout0_70ck1930 FIND v(dout0_70) AT=970.025n

.meas tran vdout0_71ck1930 FIND v(dout0_71) AT=970.025n

.meas tran vdout0_72ck1930 FIND v(dout0_72) AT=970.025n

.meas tran vdout0_73ck1930 FIND v(dout0_73) AT=970.025n

.meas tran vdout0_74ck1930 FIND v(dout0_74) AT=970.025n

.meas tran vdout0_75ck1930 FIND v(dout0_75) AT=970.025n

.meas tran vdout0_76ck1930 FIND v(dout0_76) AT=970.025n

.meas tran vdout0_77ck1930 FIND v(dout0_77) AT=970.025n

.meas tran vdout0_78ck1930 FIND v(dout0_78) AT=970.025n

.meas tran vdout0_79ck1930 FIND v(dout0_79) AT=970.025n

.meas tran vdout0_80ck1930 FIND v(dout0_80) AT=970.025n

.meas tran vdout0_81ck1930 FIND v(dout0_81) AT=970.025n

.meas tran vdout0_82ck1930 FIND v(dout0_82) AT=970.025n

.meas tran vdout0_83ck1930 FIND v(dout0_83) AT=970.025n

.meas tran vdout0_84ck1930 FIND v(dout0_84) AT=970.025n

.meas tran vdout0_85ck1930 FIND v(dout0_85) AT=970.025n

.meas tran vdout0_86ck1930 FIND v(dout0_86) AT=970.025n

.meas tran vdout0_87ck1930 FIND v(dout0_87) AT=970.025n

.meas tran vdout0_88ck1930 FIND v(dout0_88) AT=970.025n

.meas tran vdout0_89ck1930 FIND v(dout0_89) AT=970.025n

.meas tran vdout0_90ck1930 FIND v(dout0_90) AT=970.025n

.meas tran vdout0_91ck1930 FIND v(dout0_91) AT=970.025n

.meas tran vdout0_92ck1930 FIND v(dout0_92) AT=970.025n

.meas tran vdout0_93ck1930 FIND v(dout0_93) AT=970.025n

.meas tran vdout0_94ck1930 FIND v(dout0_94) AT=970.025n

.meas tran vdout0_95ck1930 FIND v(dout0_95) AT=970.025n

.meas tran vdout0_96ck1930 FIND v(dout0_96) AT=970.025n

.meas tran vdout0_97ck1930 FIND v(dout0_97) AT=970.025n

.meas tran vdout0_98ck1930 FIND v(dout0_98) AT=970.025n

.meas tran vdout0_99ck1930 FIND v(dout0_99) AT=970.025n

.meas tran vdout0_100ck1930 FIND v(dout0_100) AT=970.025n

.meas tran vdout0_101ck1930 FIND v(dout0_101) AT=970.025n

.meas tran vdout0_102ck1930 FIND v(dout0_102) AT=970.025n

.meas tran vdout0_103ck1930 FIND v(dout0_103) AT=970.025n

.meas tran vdout0_104ck1930 FIND v(dout0_104) AT=970.025n

.meas tran vdout0_105ck1930 FIND v(dout0_105) AT=970.025n

.meas tran vdout0_106ck1930 FIND v(dout0_106) AT=970.025n

.meas tran vdout0_107ck1930 FIND v(dout0_107) AT=970.025n

.meas tran vdout0_108ck1930 FIND v(dout0_108) AT=970.025n

.meas tran vdout0_109ck1930 FIND v(dout0_109) AT=970.025n

.meas tran vdout0_110ck1930 FIND v(dout0_110) AT=970.025n

.meas tran vdout0_111ck1930 FIND v(dout0_111) AT=970.025n

.meas tran vdout0_112ck1930 FIND v(dout0_112) AT=970.025n

.meas tran vdout0_113ck1930 FIND v(dout0_113) AT=970.025n

.meas tran vdout0_114ck1930 FIND v(dout0_114) AT=970.025n

.meas tran vdout0_115ck1930 FIND v(dout0_115) AT=970.025n

.meas tran vdout0_116ck1930 FIND v(dout0_116) AT=970.025n

.meas tran vdout0_117ck1930 FIND v(dout0_117) AT=970.025n

.meas tran vdout0_118ck1930 FIND v(dout0_118) AT=970.025n

.meas tran vdout0_119ck1930 FIND v(dout0_119) AT=970.025n

.meas tran vdout0_120ck1930 FIND v(dout0_120) AT=970.025n

.meas tran vdout0_121ck1930 FIND v(dout0_121) AT=970.025n

.meas tran vdout0_122ck1930 FIND v(dout0_122) AT=970.025n

.meas tran vdout0_123ck1930 FIND v(dout0_123) AT=970.025n

.meas tran vdout0_124ck1930 FIND v(dout0_124) AT=970.025n

.meas tran vdout0_125ck1930 FIND v(dout0_125) AT=970.025n

.meas tran vdout0_126ck1930 FIND v(dout0_126) AT=970.025n

.meas tran vdout0_127ck1930 FIND v(dout0_127) AT=970.025n

.meas tran vdout0_128ck1930 FIND v(dout0_128) AT=970.025n

.meas tran vdout0_129ck1930 FIND v(dout0_129) AT=970.025n

.meas tran vdout0_130ck1930 FIND v(dout0_130) AT=970.025n

.meas tran vdout0_131ck1930 FIND v(dout0_131) AT=970.025n

.meas tran vdout0_132ck1930 FIND v(dout0_132) AT=970.025n

.meas tran vdout0_133ck1930 FIND v(dout0_133) AT=970.025n

.meas tran vdout0_134ck1930 FIND v(dout0_134) AT=970.025n

.meas tran vdout0_135ck1930 FIND v(dout0_135) AT=970.025n

.meas tran vdout0_136ck1930 FIND v(dout0_136) AT=970.025n

.meas tran vdout0_137ck1930 FIND v(dout0_137) AT=970.025n

.meas tran vdout0_138ck1930 FIND v(dout0_138) AT=970.025n

.meas tran vdout0_139ck1930 FIND v(dout0_139) AT=970.025n

.meas tran vdout0_140ck1930 FIND v(dout0_140) AT=970.025n

.meas tran vdout0_141ck1930 FIND v(dout0_141) AT=970.025n

.meas tran vdout0_142ck1930 FIND v(dout0_142) AT=970.025n

.meas tran vdout0_143ck1930 FIND v(dout0_143) AT=970.025n

.meas tran vdout0_144ck1930 FIND v(dout0_144) AT=970.025n

.meas tran vdout0_145ck1930 FIND v(dout0_145) AT=970.025n

.meas tran vdout0_146ck1930 FIND v(dout0_146) AT=970.025n

.meas tran vdout0_147ck1930 FIND v(dout0_147) AT=970.025n

.meas tran vdout0_148ck1930 FIND v(dout0_148) AT=970.025n

.meas tran vdout0_149ck1930 FIND v(dout0_149) AT=970.025n

.meas tran vdout0_150ck1930 FIND v(dout0_150) AT=970.025n

.meas tran vdout0_151ck1930 FIND v(dout0_151) AT=970.025n

.meas tran vdout0_152ck1930 FIND v(dout0_152) AT=970.025n

.meas tran vdout0_153ck1930 FIND v(dout0_153) AT=970.025n

.meas tran vdout0_154ck1930 FIND v(dout0_154) AT=970.025n

.meas tran vdout0_155ck1930 FIND v(dout0_155) AT=970.025n

.meas tran vdout0_156ck1930 FIND v(dout0_156) AT=970.025n

.meas tran vdout0_157ck1930 FIND v(dout0_157) AT=970.025n

.meas tran vdout0_158ck1930 FIND v(dout0_158) AT=970.025n

.meas tran vdout0_159ck1930 FIND v(dout0_159) AT=970.025n

.meas tran vdout0_160ck1930 FIND v(dout0_160) AT=970.025n

.meas tran vdout0_161ck1930 FIND v(dout0_161) AT=970.025n

.meas tran vdout0_162ck1930 FIND v(dout0_162) AT=970.025n

.meas tran vdout0_163ck1930 FIND v(dout0_163) AT=970.025n

.meas tran vdout0_164ck1930 FIND v(dout0_164) AT=970.025n

.meas tran vdout0_165ck1930 FIND v(dout0_165) AT=970.025n

.meas tran vdout0_166ck1930 FIND v(dout0_166) AT=970.025n

.meas tran vdout0_167ck1930 FIND v(dout0_167) AT=970.025n

.meas tran vdout0_168ck1930 FIND v(dout0_168) AT=970.025n

.meas tran vdout0_169ck1930 FIND v(dout0_169) AT=970.025n

.meas tran vdout0_170ck1930 FIND v(dout0_170) AT=970.025n

.meas tran vdout0_171ck1930 FIND v(dout0_171) AT=970.025n

.meas tran vdout0_172ck1930 FIND v(dout0_172) AT=970.025n

.meas tran vdout0_173ck1930 FIND v(dout0_173) AT=970.025n

.meas tran vdout0_174ck1930 FIND v(dout0_174) AT=970.025n

.meas tran vdout0_175ck1930 FIND v(dout0_175) AT=970.025n

.meas tran vdout0_176ck1930 FIND v(dout0_176) AT=970.025n

.meas tran vdout0_177ck1930 FIND v(dout0_177) AT=970.025n

.meas tran vdout0_178ck1930 FIND v(dout0_178) AT=970.025n

.meas tran vdout0_179ck1930 FIND v(dout0_179) AT=970.025n

.meas tran vdout0_180ck1930 FIND v(dout0_180) AT=970.025n

.meas tran vdout0_181ck1930 FIND v(dout0_181) AT=970.025n

.meas tran vdout0_182ck1930 FIND v(dout0_182) AT=970.025n

.meas tran vdout0_183ck1930 FIND v(dout0_183) AT=970.025n

.meas tran vdout0_184ck1930 FIND v(dout0_184) AT=970.025n

.meas tran vdout0_185ck1930 FIND v(dout0_185) AT=970.025n

.meas tran vdout0_186ck1930 FIND v(dout0_186) AT=970.025n

.meas tran vdout0_187ck1930 FIND v(dout0_187) AT=970.025n

.meas tran vdout0_188ck1930 FIND v(dout0_188) AT=970.025n

.meas tran vdout0_189ck1930 FIND v(dout0_189) AT=970.025n

.meas tran vdout0_190ck1930 FIND v(dout0_190) AT=970.025n

.meas tran vdout0_191ck1930 FIND v(dout0_191) AT=970.025n

.meas tran vdout0_192ck1930 FIND v(dout0_192) AT=970.025n

.meas tran vdout0_193ck1930 FIND v(dout0_193) AT=970.025n

.meas tran vdout0_194ck1930 FIND v(dout0_194) AT=970.025n

.meas tran vdout0_195ck1930 FIND v(dout0_195) AT=970.025n

.meas tran vdout0_196ck1930 FIND v(dout0_196) AT=970.025n

.meas tran vdout0_197ck1930 FIND v(dout0_197) AT=970.025n

.meas tran vdout0_198ck1930 FIND v(dout0_198) AT=970.025n

.meas tran vdout0_199ck1930 FIND v(dout0_199) AT=970.025n

.meas tran vdout0_200ck1930 FIND v(dout0_200) AT=970.025n

.meas tran vdout0_201ck1930 FIND v(dout0_201) AT=970.025n

.meas tran vdout0_202ck1930 FIND v(dout0_202) AT=970.025n

.meas tran vdout0_203ck1930 FIND v(dout0_203) AT=970.025n

.meas tran vdout0_204ck1930 FIND v(dout0_204) AT=970.025n

.meas tran vdout0_205ck1930 FIND v(dout0_205) AT=970.025n

.meas tran vdout0_206ck1930 FIND v(dout0_206) AT=970.025n

.meas tran vdout0_207ck1930 FIND v(dout0_207) AT=970.025n

.meas tran vdout0_208ck1930 FIND v(dout0_208) AT=970.025n

.meas tran vdout0_209ck1930 FIND v(dout0_209) AT=970.025n

.meas tran vdout0_210ck1930 FIND v(dout0_210) AT=970.025n

.meas tran vdout0_211ck1930 FIND v(dout0_211) AT=970.025n

.meas tran vdout0_212ck1930 FIND v(dout0_212) AT=970.025n

.meas tran vdout0_213ck1930 FIND v(dout0_213) AT=970.025n

.meas tran vdout0_214ck1930 FIND v(dout0_214) AT=970.025n

.meas tran vdout0_215ck1930 FIND v(dout0_215) AT=970.025n

.meas tran vdout0_216ck1930 FIND v(dout0_216) AT=970.025n

.meas tran vdout0_217ck1930 FIND v(dout0_217) AT=970.025n

.meas tran vdout0_218ck1930 FIND v(dout0_218) AT=970.025n

.meas tran vdout0_219ck1930 FIND v(dout0_219) AT=970.025n

.meas tran vdout0_220ck1930 FIND v(dout0_220) AT=970.025n

.meas tran vdout0_221ck1930 FIND v(dout0_221) AT=970.025n

.meas tran vdout0_222ck1930 FIND v(dout0_222) AT=970.025n

.meas tran vdout0_223ck1930 FIND v(dout0_223) AT=970.025n

.meas tran vdout0_224ck1930 FIND v(dout0_224) AT=970.025n

.meas tran vdout0_225ck1930 FIND v(dout0_225) AT=970.025n

.meas tran vdout0_226ck1930 FIND v(dout0_226) AT=970.025n

.meas tran vdout0_227ck1930 FIND v(dout0_227) AT=970.025n

.meas tran vdout0_228ck1930 FIND v(dout0_228) AT=970.025n

.meas tran vdout0_229ck1930 FIND v(dout0_229) AT=970.025n

.meas tran vdout0_230ck1930 FIND v(dout0_230) AT=970.025n

.meas tran vdout0_231ck1930 FIND v(dout0_231) AT=970.025n

.meas tran vdout0_232ck1930 FIND v(dout0_232) AT=970.025n

.meas tran vdout0_233ck1930 FIND v(dout0_233) AT=970.025n

.meas tran vdout0_234ck1930 FIND v(dout0_234) AT=970.025n

.meas tran vdout0_235ck1930 FIND v(dout0_235) AT=970.025n

.meas tran vdout0_236ck1930 FIND v(dout0_236) AT=970.025n

.meas tran vdout0_237ck1930 FIND v(dout0_237) AT=970.025n

.meas tran vdout0_238ck1930 FIND v(dout0_238) AT=970.025n

.meas tran vdout0_239ck1930 FIND v(dout0_239) AT=970.025n

.meas tran vdout0_240ck1930 FIND v(dout0_240) AT=970.025n

.meas tran vdout0_241ck1930 FIND v(dout0_241) AT=970.025n

.meas tran vdout0_242ck1930 FIND v(dout0_242) AT=970.025n

.meas tran vdout0_243ck1930 FIND v(dout0_243) AT=970.025n

.meas tran vdout0_244ck1930 FIND v(dout0_244) AT=970.025n

.meas tran vdout0_245ck1930 FIND v(dout0_245) AT=970.025n

.meas tran vdout0_246ck1930 FIND v(dout0_246) AT=970.025n

.meas tran vdout0_247ck1930 FIND v(dout0_247) AT=970.025n

.meas tran vdout0_248ck1930 FIND v(dout0_248) AT=970.025n

.meas tran vdout0_249ck1930 FIND v(dout0_249) AT=970.025n

.meas tran vdout0_250ck1930 FIND v(dout0_250) AT=970.025n

.meas tran vdout0_251ck1930 FIND v(dout0_251) AT=970.025n

.meas tran vdout0_252ck1930 FIND v(dout0_252) AT=970.025n

.meas tran vdout0_253ck1930 FIND v(dout0_253) AT=970.025n

.meas tran vdout0_254ck1930 FIND v(dout0_254) AT=970.025n

.meas tran vdout0_255ck1930 FIND v(dout0_255) AT=970.025n

.meas tran vdout0_0ck1960 FIND v(dout0_0) AT=985.025n

.meas tran vdout0_1ck1960 FIND v(dout0_1) AT=985.025n

.meas tran vdout0_2ck1960 FIND v(dout0_2) AT=985.025n

.meas tran vdout0_3ck1960 FIND v(dout0_3) AT=985.025n

.meas tran vdout0_4ck1960 FIND v(dout0_4) AT=985.025n

.meas tran vdout0_5ck1960 FIND v(dout0_5) AT=985.025n

.meas tran vdout0_6ck1960 FIND v(dout0_6) AT=985.025n

.meas tran vdout0_7ck1960 FIND v(dout0_7) AT=985.025n

.meas tran vdout0_8ck1960 FIND v(dout0_8) AT=985.025n

.meas tran vdout0_9ck1960 FIND v(dout0_9) AT=985.025n

.meas tran vdout0_10ck1960 FIND v(dout0_10) AT=985.025n

.meas tran vdout0_11ck1960 FIND v(dout0_11) AT=985.025n

.meas tran vdout0_12ck1960 FIND v(dout0_12) AT=985.025n

.meas tran vdout0_13ck1960 FIND v(dout0_13) AT=985.025n

.meas tran vdout0_14ck1960 FIND v(dout0_14) AT=985.025n

.meas tran vdout0_15ck1960 FIND v(dout0_15) AT=985.025n

.meas tran vdout0_16ck1960 FIND v(dout0_16) AT=985.025n

.meas tran vdout0_17ck1960 FIND v(dout0_17) AT=985.025n

.meas tran vdout0_18ck1960 FIND v(dout0_18) AT=985.025n

.meas tran vdout0_19ck1960 FIND v(dout0_19) AT=985.025n

.meas tran vdout0_20ck1960 FIND v(dout0_20) AT=985.025n

.meas tran vdout0_21ck1960 FIND v(dout0_21) AT=985.025n

.meas tran vdout0_22ck1960 FIND v(dout0_22) AT=985.025n

.meas tran vdout0_23ck1960 FIND v(dout0_23) AT=985.025n

.meas tran vdout0_24ck1960 FIND v(dout0_24) AT=985.025n

.meas tran vdout0_25ck1960 FIND v(dout0_25) AT=985.025n

.meas tran vdout0_26ck1960 FIND v(dout0_26) AT=985.025n

.meas tran vdout0_27ck1960 FIND v(dout0_27) AT=985.025n

.meas tran vdout0_28ck1960 FIND v(dout0_28) AT=985.025n

.meas tran vdout0_29ck1960 FIND v(dout0_29) AT=985.025n

.meas tran vdout0_30ck1960 FIND v(dout0_30) AT=985.025n

.meas tran vdout0_31ck1960 FIND v(dout0_31) AT=985.025n

.meas tran vdout0_32ck1960 FIND v(dout0_32) AT=985.025n

.meas tran vdout0_33ck1960 FIND v(dout0_33) AT=985.025n

.meas tran vdout0_34ck1960 FIND v(dout0_34) AT=985.025n

.meas tran vdout0_35ck1960 FIND v(dout0_35) AT=985.025n

.meas tran vdout0_36ck1960 FIND v(dout0_36) AT=985.025n

.meas tran vdout0_37ck1960 FIND v(dout0_37) AT=985.025n

.meas tran vdout0_38ck1960 FIND v(dout0_38) AT=985.025n

.meas tran vdout0_39ck1960 FIND v(dout0_39) AT=985.025n

.meas tran vdout0_40ck1960 FIND v(dout0_40) AT=985.025n

.meas tran vdout0_41ck1960 FIND v(dout0_41) AT=985.025n

.meas tran vdout0_42ck1960 FIND v(dout0_42) AT=985.025n

.meas tran vdout0_43ck1960 FIND v(dout0_43) AT=985.025n

.meas tran vdout0_44ck1960 FIND v(dout0_44) AT=985.025n

.meas tran vdout0_45ck1960 FIND v(dout0_45) AT=985.025n

.meas tran vdout0_46ck1960 FIND v(dout0_46) AT=985.025n

.meas tran vdout0_47ck1960 FIND v(dout0_47) AT=985.025n

.meas tran vdout0_48ck1960 FIND v(dout0_48) AT=985.025n

.meas tran vdout0_49ck1960 FIND v(dout0_49) AT=985.025n

.meas tran vdout0_50ck1960 FIND v(dout0_50) AT=985.025n

.meas tran vdout0_51ck1960 FIND v(dout0_51) AT=985.025n

.meas tran vdout0_52ck1960 FIND v(dout0_52) AT=985.025n

.meas tran vdout0_53ck1960 FIND v(dout0_53) AT=985.025n

.meas tran vdout0_54ck1960 FIND v(dout0_54) AT=985.025n

.meas tran vdout0_55ck1960 FIND v(dout0_55) AT=985.025n

.meas tran vdout0_56ck1960 FIND v(dout0_56) AT=985.025n

.meas tran vdout0_57ck1960 FIND v(dout0_57) AT=985.025n

.meas tran vdout0_58ck1960 FIND v(dout0_58) AT=985.025n

.meas tran vdout0_59ck1960 FIND v(dout0_59) AT=985.025n

.meas tran vdout0_60ck1960 FIND v(dout0_60) AT=985.025n

.meas tran vdout0_61ck1960 FIND v(dout0_61) AT=985.025n

.meas tran vdout0_62ck1960 FIND v(dout0_62) AT=985.025n

.meas tran vdout0_63ck1960 FIND v(dout0_63) AT=985.025n

.meas tran vdout0_64ck1960 FIND v(dout0_64) AT=985.025n

.meas tran vdout0_65ck1960 FIND v(dout0_65) AT=985.025n

.meas tran vdout0_66ck1960 FIND v(dout0_66) AT=985.025n

.meas tran vdout0_67ck1960 FIND v(dout0_67) AT=985.025n

.meas tran vdout0_68ck1960 FIND v(dout0_68) AT=985.025n

.meas tran vdout0_69ck1960 FIND v(dout0_69) AT=985.025n

.meas tran vdout0_70ck1960 FIND v(dout0_70) AT=985.025n

.meas tran vdout0_71ck1960 FIND v(dout0_71) AT=985.025n

.meas tran vdout0_72ck1960 FIND v(dout0_72) AT=985.025n

.meas tran vdout0_73ck1960 FIND v(dout0_73) AT=985.025n

.meas tran vdout0_74ck1960 FIND v(dout0_74) AT=985.025n

.meas tran vdout0_75ck1960 FIND v(dout0_75) AT=985.025n

.meas tran vdout0_76ck1960 FIND v(dout0_76) AT=985.025n

.meas tran vdout0_77ck1960 FIND v(dout0_77) AT=985.025n

.meas tran vdout0_78ck1960 FIND v(dout0_78) AT=985.025n

.meas tran vdout0_79ck1960 FIND v(dout0_79) AT=985.025n

.meas tran vdout0_80ck1960 FIND v(dout0_80) AT=985.025n

.meas tran vdout0_81ck1960 FIND v(dout0_81) AT=985.025n

.meas tran vdout0_82ck1960 FIND v(dout0_82) AT=985.025n

.meas tran vdout0_83ck1960 FIND v(dout0_83) AT=985.025n

.meas tran vdout0_84ck1960 FIND v(dout0_84) AT=985.025n

.meas tran vdout0_85ck1960 FIND v(dout0_85) AT=985.025n

.meas tran vdout0_86ck1960 FIND v(dout0_86) AT=985.025n

.meas tran vdout0_87ck1960 FIND v(dout0_87) AT=985.025n

.meas tran vdout0_88ck1960 FIND v(dout0_88) AT=985.025n

.meas tran vdout0_89ck1960 FIND v(dout0_89) AT=985.025n

.meas tran vdout0_90ck1960 FIND v(dout0_90) AT=985.025n

.meas tran vdout0_91ck1960 FIND v(dout0_91) AT=985.025n

.meas tran vdout0_92ck1960 FIND v(dout0_92) AT=985.025n

.meas tran vdout0_93ck1960 FIND v(dout0_93) AT=985.025n

.meas tran vdout0_94ck1960 FIND v(dout0_94) AT=985.025n

.meas tran vdout0_95ck1960 FIND v(dout0_95) AT=985.025n

.meas tran vdout0_96ck1960 FIND v(dout0_96) AT=985.025n

.meas tran vdout0_97ck1960 FIND v(dout0_97) AT=985.025n

.meas tran vdout0_98ck1960 FIND v(dout0_98) AT=985.025n

.meas tran vdout0_99ck1960 FIND v(dout0_99) AT=985.025n

.meas tran vdout0_100ck1960 FIND v(dout0_100) AT=985.025n

.meas tran vdout0_101ck1960 FIND v(dout0_101) AT=985.025n

.meas tran vdout0_102ck1960 FIND v(dout0_102) AT=985.025n

.meas tran vdout0_103ck1960 FIND v(dout0_103) AT=985.025n

.meas tran vdout0_104ck1960 FIND v(dout0_104) AT=985.025n

.meas tran vdout0_105ck1960 FIND v(dout0_105) AT=985.025n

.meas tran vdout0_106ck1960 FIND v(dout0_106) AT=985.025n

.meas tran vdout0_107ck1960 FIND v(dout0_107) AT=985.025n

.meas tran vdout0_108ck1960 FIND v(dout0_108) AT=985.025n

.meas tran vdout0_109ck1960 FIND v(dout0_109) AT=985.025n

.meas tran vdout0_110ck1960 FIND v(dout0_110) AT=985.025n

.meas tran vdout0_111ck1960 FIND v(dout0_111) AT=985.025n

.meas tran vdout0_112ck1960 FIND v(dout0_112) AT=985.025n

.meas tran vdout0_113ck1960 FIND v(dout0_113) AT=985.025n

.meas tran vdout0_114ck1960 FIND v(dout0_114) AT=985.025n

.meas tran vdout0_115ck1960 FIND v(dout0_115) AT=985.025n

.meas tran vdout0_116ck1960 FIND v(dout0_116) AT=985.025n

.meas tran vdout0_117ck1960 FIND v(dout0_117) AT=985.025n

.meas tran vdout0_118ck1960 FIND v(dout0_118) AT=985.025n

.meas tran vdout0_119ck1960 FIND v(dout0_119) AT=985.025n

.meas tran vdout0_120ck1960 FIND v(dout0_120) AT=985.025n

.meas tran vdout0_121ck1960 FIND v(dout0_121) AT=985.025n

.meas tran vdout0_122ck1960 FIND v(dout0_122) AT=985.025n

.meas tran vdout0_123ck1960 FIND v(dout0_123) AT=985.025n

.meas tran vdout0_124ck1960 FIND v(dout0_124) AT=985.025n

.meas tran vdout0_125ck1960 FIND v(dout0_125) AT=985.025n

.meas tran vdout0_126ck1960 FIND v(dout0_126) AT=985.025n

.meas tran vdout0_127ck1960 FIND v(dout0_127) AT=985.025n

.meas tran vdout0_128ck1960 FIND v(dout0_128) AT=985.025n

.meas tran vdout0_129ck1960 FIND v(dout0_129) AT=985.025n

.meas tran vdout0_130ck1960 FIND v(dout0_130) AT=985.025n

.meas tran vdout0_131ck1960 FIND v(dout0_131) AT=985.025n

.meas tran vdout0_132ck1960 FIND v(dout0_132) AT=985.025n

.meas tran vdout0_133ck1960 FIND v(dout0_133) AT=985.025n

.meas tran vdout0_134ck1960 FIND v(dout0_134) AT=985.025n

.meas tran vdout0_135ck1960 FIND v(dout0_135) AT=985.025n

.meas tran vdout0_136ck1960 FIND v(dout0_136) AT=985.025n

.meas tran vdout0_137ck1960 FIND v(dout0_137) AT=985.025n

.meas tran vdout0_138ck1960 FIND v(dout0_138) AT=985.025n

.meas tran vdout0_139ck1960 FIND v(dout0_139) AT=985.025n

.meas tran vdout0_140ck1960 FIND v(dout0_140) AT=985.025n

.meas tran vdout0_141ck1960 FIND v(dout0_141) AT=985.025n

.meas tran vdout0_142ck1960 FIND v(dout0_142) AT=985.025n

.meas tran vdout0_143ck1960 FIND v(dout0_143) AT=985.025n

.meas tran vdout0_144ck1960 FIND v(dout0_144) AT=985.025n

.meas tran vdout0_145ck1960 FIND v(dout0_145) AT=985.025n

.meas tran vdout0_146ck1960 FIND v(dout0_146) AT=985.025n

.meas tran vdout0_147ck1960 FIND v(dout0_147) AT=985.025n

.meas tran vdout0_148ck1960 FIND v(dout0_148) AT=985.025n

.meas tran vdout0_149ck1960 FIND v(dout0_149) AT=985.025n

.meas tran vdout0_150ck1960 FIND v(dout0_150) AT=985.025n

.meas tran vdout0_151ck1960 FIND v(dout0_151) AT=985.025n

.meas tran vdout0_152ck1960 FIND v(dout0_152) AT=985.025n

.meas tran vdout0_153ck1960 FIND v(dout0_153) AT=985.025n

.meas tran vdout0_154ck1960 FIND v(dout0_154) AT=985.025n

.meas tran vdout0_155ck1960 FIND v(dout0_155) AT=985.025n

.meas tran vdout0_156ck1960 FIND v(dout0_156) AT=985.025n

.meas tran vdout0_157ck1960 FIND v(dout0_157) AT=985.025n

.meas tran vdout0_158ck1960 FIND v(dout0_158) AT=985.025n

.meas tran vdout0_159ck1960 FIND v(dout0_159) AT=985.025n

.meas tran vdout0_160ck1960 FIND v(dout0_160) AT=985.025n

.meas tran vdout0_161ck1960 FIND v(dout0_161) AT=985.025n

.meas tran vdout0_162ck1960 FIND v(dout0_162) AT=985.025n

.meas tran vdout0_163ck1960 FIND v(dout0_163) AT=985.025n

.meas tran vdout0_164ck1960 FIND v(dout0_164) AT=985.025n

.meas tran vdout0_165ck1960 FIND v(dout0_165) AT=985.025n

.meas tran vdout0_166ck1960 FIND v(dout0_166) AT=985.025n

.meas tran vdout0_167ck1960 FIND v(dout0_167) AT=985.025n

.meas tran vdout0_168ck1960 FIND v(dout0_168) AT=985.025n

.meas tran vdout0_169ck1960 FIND v(dout0_169) AT=985.025n

.meas tran vdout0_170ck1960 FIND v(dout0_170) AT=985.025n

.meas tran vdout0_171ck1960 FIND v(dout0_171) AT=985.025n

.meas tran vdout0_172ck1960 FIND v(dout0_172) AT=985.025n

.meas tran vdout0_173ck1960 FIND v(dout0_173) AT=985.025n

.meas tran vdout0_174ck1960 FIND v(dout0_174) AT=985.025n

.meas tran vdout0_175ck1960 FIND v(dout0_175) AT=985.025n

.meas tran vdout0_176ck1960 FIND v(dout0_176) AT=985.025n

.meas tran vdout0_177ck1960 FIND v(dout0_177) AT=985.025n

.meas tran vdout0_178ck1960 FIND v(dout0_178) AT=985.025n

.meas tran vdout0_179ck1960 FIND v(dout0_179) AT=985.025n

.meas tran vdout0_180ck1960 FIND v(dout0_180) AT=985.025n

.meas tran vdout0_181ck1960 FIND v(dout0_181) AT=985.025n

.meas tran vdout0_182ck1960 FIND v(dout0_182) AT=985.025n

.meas tran vdout0_183ck1960 FIND v(dout0_183) AT=985.025n

.meas tran vdout0_184ck1960 FIND v(dout0_184) AT=985.025n

.meas tran vdout0_185ck1960 FIND v(dout0_185) AT=985.025n

.meas tran vdout0_186ck1960 FIND v(dout0_186) AT=985.025n

.meas tran vdout0_187ck1960 FIND v(dout0_187) AT=985.025n

.meas tran vdout0_188ck1960 FIND v(dout0_188) AT=985.025n

.meas tran vdout0_189ck1960 FIND v(dout0_189) AT=985.025n

.meas tran vdout0_190ck1960 FIND v(dout0_190) AT=985.025n

.meas tran vdout0_191ck1960 FIND v(dout0_191) AT=985.025n

.meas tran vdout0_192ck1960 FIND v(dout0_192) AT=985.025n

.meas tran vdout0_193ck1960 FIND v(dout0_193) AT=985.025n

.meas tran vdout0_194ck1960 FIND v(dout0_194) AT=985.025n

.meas tran vdout0_195ck1960 FIND v(dout0_195) AT=985.025n

.meas tran vdout0_196ck1960 FIND v(dout0_196) AT=985.025n

.meas tran vdout0_197ck1960 FIND v(dout0_197) AT=985.025n

.meas tran vdout0_198ck1960 FIND v(dout0_198) AT=985.025n

.meas tran vdout0_199ck1960 FIND v(dout0_199) AT=985.025n

.meas tran vdout0_200ck1960 FIND v(dout0_200) AT=985.025n

.meas tran vdout0_201ck1960 FIND v(dout0_201) AT=985.025n

.meas tran vdout0_202ck1960 FIND v(dout0_202) AT=985.025n

.meas tran vdout0_203ck1960 FIND v(dout0_203) AT=985.025n

.meas tran vdout0_204ck1960 FIND v(dout0_204) AT=985.025n

.meas tran vdout0_205ck1960 FIND v(dout0_205) AT=985.025n

.meas tran vdout0_206ck1960 FIND v(dout0_206) AT=985.025n

.meas tran vdout0_207ck1960 FIND v(dout0_207) AT=985.025n

.meas tran vdout0_208ck1960 FIND v(dout0_208) AT=985.025n

.meas tran vdout0_209ck1960 FIND v(dout0_209) AT=985.025n

.meas tran vdout0_210ck1960 FIND v(dout0_210) AT=985.025n

.meas tran vdout0_211ck1960 FIND v(dout0_211) AT=985.025n

.meas tran vdout0_212ck1960 FIND v(dout0_212) AT=985.025n

.meas tran vdout0_213ck1960 FIND v(dout0_213) AT=985.025n

.meas tran vdout0_214ck1960 FIND v(dout0_214) AT=985.025n

.meas tran vdout0_215ck1960 FIND v(dout0_215) AT=985.025n

.meas tran vdout0_216ck1960 FIND v(dout0_216) AT=985.025n

.meas tran vdout0_217ck1960 FIND v(dout0_217) AT=985.025n

.meas tran vdout0_218ck1960 FIND v(dout0_218) AT=985.025n

.meas tran vdout0_219ck1960 FIND v(dout0_219) AT=985.025n

.meas tran vdout0_220ck1960 FIND v(dout0_220) AT=985.025n

.meas tran vdout0_221ck1960 FIND v(dout0_221) AT=985.025n

.meas tran vdout0_222ck1960 FIND v(dout0_222) AT=985.025n

.meas tran vdout0_223ck1960 FIND v(dout0_223) AT=985.025n

.meas tran vdout0_224ck1960 FIND v(dout0_224) AT=985.025n

.meas tran vdout0_225ck1960 FIND v(dout0_225) AT=985.025n

.meas tran vdout0_226ck1960 FIND v(dout0_226) AT=985.025n

.meas tran vdout0_227ck1960 FIND v(dout0_227) AT=985.025n

.meas tran vdout0_228ck1960 FIND v(dout0_228) AT=985.025n

.meas tran vdout0_229ck1960 FIND v(dout0_229) AT=985.025n

.meas tran vdout0_230ck1960 FIND v(dout0_230) AT=985.025n

.meas tran vdout0_231ck1960 FIND v(dout0_231) AT=985.025n

.meas tran vdout0_232ck1960 FIND v(dout0_232) AT=985.025n

.meas tran vdout0_233ck1960 FIND v(dout0_233) AT=985.025n

.meas tran vdout0_234ck1960 FIND v(dout0_234) AT=985.025n

.meas tran vdout0_235ck1960 FIND v(dout0_235) AT=985.025n

.meas tran vdout0_236ck1960 FIND v(dout0_236) AT=985.025n

.meas tran vdout0_237ck1960 FIND v(dout0_237) AT=985.025n

.meas tran vdout0_238ck1960 FIND v(dout0_238) AT=985.025n

.meas tran vdout0_239ck1960 FIND v(dout0_239) AT=985.025n

.meas tran vdout0_240ck1960 FIND v(dout0_240) AT=985.025n

.meas tran vdout0_241ck1960 FIND v(dout0_241) AT=985.025n

.meas tran vdout0_242ck1960 FIND v(dout0_242) AT=985.025n

.meas tran vdout0_243ck1960 FIND v(dout0_243) AT=985.025n

.meas tran vdout0_244ck1960 FIND v(dout0_244) AT=985.025n

.meas tran vdout0_245ck1960 FIND v(dout0_245) AT=985.025n

.meas tran vdout0_246ck1960 FIND v(dout0_246) AT=985.025n

.meas tran vdout0_247ck1960 FIND v(dout0_247) AT=985.025n

.meas tran vdout0_248ck1960 FIND v(dout0_248) AT=985.025n

.meas tran vdout0_249ck1960 FIND v(dout0_249) AT=985.025n

.meas tran vdout0_250ck1960 FIND v(dout0_250) AT=985.025n

.meas tran vdout0_251ck1960 FIND v(dout0_251) AT=985.025n

.meas tran vdout0_252ck1960 FIND v(dout0_252) AT=985.025n

.meas tran vdout0_253ck1960 FIND v(dout0_253) AT=985.025n

.meas tran vdout0_254ck1960 FIND v(dout0_254) AT=985.025n

.meas tran vdout0_255ck1960 FIND v(dout0_255) AT=985.025n

.meas tran vdout0_0ck1980 FIND v(dout0_0) AT=995.025n

.meas tran vdout0_1ck1980 FIND v(dout0_1) AT=995.025n

.meas tran vdout0_2ck1980 FIND v(dout0_2) AT=995.025n

.meas tran vdout0_3ck1980 FIND v(dout0_3) AT=995.025n

.meas tran vdout0_4ck1980 FIND v(dout0_4) AT=995.025n

.meas tran vdout0_5ck1980 FIND v(dout0_5) AT=995.025n

.meas tran vdout0_6ck1980 FIND v(dout0_6) AT=995.025n

.meas tran vdout0_7ck1980 FIND v(dout0_7) AT=995.025n

.meas tran vdout0_8ck1980 FIND v(dout0_8) AT=995.025n

.meas tran vdout0_9ck1980 FIND v(dout0_9) AT=995.025n

.meas tran vdout0_10ck1980 FIND v(dout0_10) AT=995.025n

.meas tran vdout0_11ck1980 FIND v(dout0_11) AT=995.025n

.meas tran vdout0_12ck1980 FIND v(dout0_12) AT=995.025n

.meas tran vdout0_13ck1980 FIND v(dout0_13) AT=995.025n

.meas tran vdout0_14ck1980 FIND v(dout0_14) AT=995.025n

.meas tran vdout0_15ck1980 FIND v(dout0_15) AT=995.025n

.meas tran vdout0_16ck1980 FIND v(dout0_16) AT=995.025n

.meas tran vdout0_17ck1980 FIND v(dout0_17) AT=995.025n

.meas tran vdout0_18ck1980 FIND v(dout0_18) AT=995.025n

.meas tran vdout0_19ck1980 FIND v(dout0_19) AT=995.025n

.meas tran vdout0_20ck1980 FIND v(dout0_20) AT=995.025n

.meas tran vdout0_21ck1980 FIND v(dout0_21) AT=995.025n

.meas tran vdout0_22ck1980 FIND v(dout0_22) AT=995.025n

.meas tran vdout0_23ck1980 FIND v(dout0_23) AT=995.025n

.meas tran vdout0_24ck1980 FIND v(dout0_24) AT=995.025n

.meas tran vdout0_25ck1980 FIND v(dout0_25) AT=995.025n

.meas tran vdout0_26ck1980 FIND v(dout0_26) AT=995.025n

.meas tran vdout0_27ck1980 FIND v(dout0_27) AT=995.025n

.meas tran vdout0_28ck1980 FIND v(dout0_28) AT=995.025n

.meas tran vdout0_29ck1980 FIND v(dout0_29) AT=995.025n

.meas tran vdout0_30ck1980 FIND v(dout0_30) AT=995.025n

.meas tran vdout0_31ck1980 FIND v(dout0_31) AT=995.025n

.meas tran vdout0_32ck1980 FIND v(dout0_32) AT=995.025n

.meas tran vdout0_33ck1980 FIND v(dout0_33) AT=995.025n

.meas tran vdout0_34ck1980 FIND v(dout0_34) AT=995.025n

.meas tran vdout0_35ck1980 FIND v(dout0_35) AT=995.025n

.meas tran vdout0_36ck1980 FIND v(dout0_36) AT=995.025n

.meas tran vdout0_37ck1980 FIND v(dout0_37) AT=995.025n

.meas tran vdout0_38ck1980 FIND v(dout0_38) AT=995.025n

.meas tran vdout0_39ck1980 FIND v(dout0_39) AT=995.025n

.meas tran vdout0_40ck1980 FIND v(dout0_40) AT=995.025n

.meas tran vdout0_41ck1980 FIND v(dout0_41) AT=995.025n

.meas tran vdout0_42ck1980 FIND v(dout0_42) AT=995.025n

.meas tran vdout0_43ck1980 FIND v(dout0_43) AT=995.025n

.meas tran vdout0_44ck1980 FIND v(dout0_44) AT=995.025n

.meas tran vdout0_45ck1980 FIND v(dout0_45) AT=995.025n

.meas tran vdout0_46ck1980 FIND v(dout0_46) AT=995.025n

.meas tran vdout0_47ck1980 FIND v(dout0_47) AT=995.025n

.meas tran vdout0_48ck1980 FIND v(dout0_48) AT=995.025n

.meas tran vdout0_49ck1980 FIND v(dout0_49) AT=995.025n

.meas tran vdout0_50ck1980 FIND v(dout0_50) AT=995.025n

.meas tran vdout0_51ck1980 FIND v(dout0_51) AT=995.025n

.meas tran vdout0_52ck1980 FIND v(dout0_52) AT=995.025n

.meas tran vdout0_53ck1980 FIND v(dout0_53) AT=995.025n

.meas tran vdout0_54ck1980 FIND v(dout0_54) AT=995.025n

.meas tran vdout0_55ck1980 FIND v(dout0_55) AT=995.025n

.meas tran vdout0_56ck1980 FIND v(dout0_56) AT=995.025n

.meas tran vdout0_57ck1980 FIND v(dout0_57) AT=995.025n

.meas tran vdout0_58ck1980 FIND v(dout0_58) AT=995.025n

.meas tran vdout0_59ck1980 FIND v(dout0_59) AT=995.025n

.meas tran vdout0_60ck1980 FIND v(dout0_60) AT=995.025n

.meas tran vdout0_61ck1980 FIND v(dout0_61) AT=995.025n

.meas tran vdout0_62ck1980 FIND v(dout0_62) AT=995.025n

.meas tran vdout0_63ck1980 FIND v(dout0_63) AT=995.025n

.meas tran vdout0_64ck1980 FIND v(dout0_64) AT=995.025n

.meas tran vdout0_65ck1980 FIND v(dout0_65) AT=995.025n

.meas tran vdout0_66ck1980 FIND v(dout0_66) AT=995.025n

.meas tran vdout0_67ck1980 FIND v(dout0_67) AT=995.025n

.meas tran vdout0_68ck1980 FIND v(dout0_68) AT=995.025n

.meas tran vdout0_69ck1980 FIND v(dout0_69) AT=995.025n

.meas tran vdout0_70ck1980 FIND v(dout0_70) AT=995.025n

.meas tran vdout0_71ck1980 FIND v(dout0_71) AT=995.025n

.meas tran vdout0_72ck1980 FIND v(dout0_72) AT=995.025n

.meas tran vdout0_73ck1980 FIND v(dout0_73) AT=995.025n

.meas tran vdout0_74ck1980 FIND v(dout0_74) AT=995.025n

.meas tran vdout0_75ck1980 FIND v(dout0_75) AT=995.025n

.meas tran vdout0_76ck1980 FIND v(dout0_76) AT=995.025n

.meas tran vdout0_77ck1980 FIND v(dout0_77) AT=995.025n

.meas tran vdout0_78ck1980 FIND v(dout0_78) AT=995.025n

.meas tran vdout0_79ck1980 FIND v(dout0_79) AT=995.025n

.meas tran vdout0_80ck1980 FIND v(dout0_80) AT=995.025n

.meas tran vdout0_81ck1980 FIND v(dout0_81) AT=995.025n

.meas tran vdout0_82ck1980 FIND v(dout0_82) AT=995.025n

.meas tran vdout0_83ck1980 FIND v(dout0_83) AT=995.025n

.meas tran vdout0_84ck1980 FIND v(dout0_84) AT=995.025n

.meas tran vdout0_85ck1980 FIND v(dout0_85) AT=995.025n

.meas tran vdout0_86ck1980 FIND v(dout0_86) AT=995.025n

.meas tran vdout0_87ck1980 FIND v(dout0_87) AT=995.025n

.meas tran vdout0_88ck1980 FIND v(dout0_88) AT=995.025n

.meas tran vdout0_89ck1980 FIND v(dout0_89) AT=995.025n

.meas tran vdout0_90ck1980 FIND v(dout0_90) AT=995.025n

.meas tran vdout0_91ck1980 FIND v(dout0_91) AT=995.025n

.meas tran vdout0_92ck1980 FIND v(dout0_92) AT=995.025n

.meas tran vdout0_93ck1980 FIND v(dout0_93) AT=995.025n

.meas tran vdout0_94ck1980 FIND v(dout0_94) AT=995.025n

.meas tran vdout0_95ck1980 FIND v(dout0_95) AT=995.025n

.meas tran vdout0_96ck1980 FIND v(dout0_96) AT=995.025n

.meas tran vdout0_97ck1980 FIND v(dout0_97) AT=995.025n

.meas tran vdout0_98ck1980 FIND v(dout0_98) AT=995.025n

.meas tran vdout0_99ck1980 FIND v(dout0_99) AT=995.025n

.meas tran vdout0_100ck1980 FIND v(dout0_100) AT=995.025n

.meas tran vdout0_101ck1980 FIND v(dout0_101) AT=995.025n

.meas tran vdout0_102ck1980 FIND v(dout0_102) AT=995.025n

.meas tran vdout0_103ck1980 FIND v(dout0_103) AT=995.025n

.meas tran vdout0_104ck1980 FIND v(dout0_104) AT=995.025n

.meas tran vdout0_105ck1980 FIND v(dout0_105) AT=995.025n

.meas tran vdout0_106ck1980 FIND v(dout0_106) AT=995.025n

.meas tran vdout0_107ck1980 FIND v(dout0_107) AT=995.025n

.meas tran vdout0_108ck1980 FIND v(dout0_108) AT=995.025n

.meas tran vdout0_109ck1980 FIND v(dout0_109) AT=995.025n

.meas tran vdout0_110ck1980 FIND v(dout0_110) AT=995.025n

.meas tran vdout0_111ck1980 FIND v(dout0_111) AT=995.025n

.meas tran vdout0_112ck1980 FIND v(dout0_112) AT=995.025n

.meas tran vdout0_113ck1980 FIND v(dout0_113) AT=995.025n

.meas tran vdout0_114ck1980 FIND v(dout0_114) AT=995.025n

.meas tran vdout0_115ck1980 FIND v(dout0_115) AT=995.025n

.meas tran vdout0_116ck1980 FIND v(dout0_116) AT=995.025n

.meas tran vdout0_117ck1980 FIND v(dout0_117) AT=995.025n

.meas tran vdout0_118ck1980 FIND v(dout0_118) AT=995.025n

.meas tran vdout0_119ck1980 FIND v(dout0_119) AT=995.025n

.meas tran vdout0_120ck1980 FIND v(dout0_120) AT=995.025n

.meas tran vdout0_121ck1980 FIND v(dout0_121) AT=995.025n

.meas tran vdout0_122ck1980 FIND v(dout0_122) AT=995.025n

.meas tran vdout0_123ck1980 FIND v(dout0_123) AT=995.025n

.meas tran vdout0_124ck1980 FIND v(dout0_124) AT=995.025n

.meas tran vdout0_125ck1980 FIND v(dout0_125) AT=995.025n

.meas tran vdout0_126ck1980 FIND v(dout0_126) AT=995.025n

.meas tran vdout0_127ck1980 FIND v(dout0_127) AT=995.025n

.meas tran vdout0_128ck1980 FIND v(dout0_128) AT=995.025n

.meas tran vdout0_129ck1980 FIND v(dout0_129) AT=995.025n

.meas tran vdout0_130ck1980 FIND v(dout0_130) AT=995.025n

.meas tran vdout0_131ck1980 FIND v(dout0_131) AT=995.025n

.meas tran vdout0_132ck1980 FIND v(dout0_132) AT=995.025n

.meas tran vdout0_133ck1980 FIND v(dout0_133) AT=995.025n

.meas tran vdout0_134ck1980 FIND v(dout0_134) AT=995.025n

.meas tran vdout0_135ck1980 FIND v(dout0_135) AT=995.025n

.meas tran vdout0_136ck1980 FIND v(dout0_136) AT=995.025n

.meas tran vdout0_137ck1980 FIND v(dout0_137) AT=995.025n

.meas tran vdout0_138ck1980 FIND v(dout0_138) AT=995.025n

.meas tran vdout0_139ck1980 FIND v(dout0_139) AT=995.025n

.meas tran vdout0_140ck1980 FIND v(dout0_140) AT=995.025n

.meas tran vdout0_141ck1980 FIND v(dout0_141) AT=995.025n

.meas tran vdout0_142ck1980 FIND v(dout0_142) AT=995.025n

.meas tran vdout0_143ck1980 FIND v(dout0_143) AT=995.025n

.meas tran vdout0_144ck1980 FIND v(dout0_144) AT=995.025n

.meas tran vdout0_145ck1980 FIND v(dout0_145) AT=995.025n

.meas tran vdout0_146ck1980 FIND v(dout0_146) AT=995.025n

.meas tran vdout0_147ck1980 FIND v(dout0_147) AT=995.025n

.meas tran vdout0_148ck1980 FIND v(dout0_148) AT=995.025n

.meas tran vdout0_149ck1980 FIND v(dout0_149) AT=995.025n

.meas tran vdout0_150ck1980 FIND v(dout0_150) AT=995.025n

.meas tran vdout0_151ck1980 FIND v(dout0_151) AT=995.025n

.meas tran vdout0_152ck1980 FIND v(dout0_152) AT=995.025n

.meas tran vdout0_153ck1980 FIND v(dout0_153) AT=995.025n

.meas tran vdout0_154ck1980 FIND v(dout0_154) AT=995.025n

.meas tran vdout0_155ck1980 FIND v(dout0_155) AT=995.025n

.meas tran vdout0_156ck1980 FIND v(dout0_156) AT=995.025n

.meas tran vdout0_157ck1980 FIND v(dout0_157) AT=995.025n

.meas tran vdout0_158ck1980 FIND v(dout0_158) AT=995.025n

.meas tran vdout0_159ck1980 FIND v(dout0_159) AT=995.025n

.meas tran vdout0_160ck1980 FIND v(dout0_160) AT=995.025n

.meas tran vdout0_161ck1980 FIND v(dout0_161) AT=995.025n

.meas tran vdout0_162ck1980 FIND v(dout0_162) AT=995.025n

.meas tran vdout0_163ck1980 FIND v(dout0_163) AT=995.025n

.meas tran vdout0_164ck1980 FIND v(dout0_164) AT=995.025n

.meas tran vdout0_165ck1980 FIND v(dout0_165) AT=995.025n

.meas tran vdout0_166ck1980 FIND v(dout0_166) AT=995.025n

.meas tran vdout0_167ck1980 FIND v(dout0_167) AT=995.025n

.meas tran vdout0_168ck1980 FIND v(dout0_168) AT=995.025n

.meas tran vdout0_169ck1980 FIND v(dout0_169) AT=995.025n

.meas tran vdout0_170ck1980 FIND v(dout0_170) AT=995.025n

.meas tran vdout0_171ck1980 FIND v(dout0_171) AT=995.025n

.meas tran vdout0_172ck1980 FIND v(dout0_172) AT=995.025n

.meas tran vdout0_173ck1980 FIND v(dout0_173) AT=995.025n

.meas tran vdout0_174ck1980 FIND v(dout0_174) AT=995.025n

.meas tran vdout0_175ck1980 FIND v(dout0_175) AT=995.025n

.meas tran vdout0_176ck1980 FIND v(dout0_176) AT=995.025n

.meas tran vdout0_177ck1980 FIND v(dout0_177) AT=995.025n

.meas tran vdout0_178ck1980 FIND v(dout0_178) AT=995.025n

.meas tran vdout0_179ck1980 FIND v(dout0_179) AT=995.025n

.meas tran vdout0_180ck1980 FIND v(dout0_180) AT=995.025n

.meas tran vdout0_181ck1980 FIND v(dout0_181) AT=995.025n

.meas tran vdout0_182ck1980 FIND v(dout0_182) AT=995.025n

.meas tran vdout0_183ck1980 FIND v(dout0_183) AT=995.025n

.meas tran vdout0_184ck1980 FIND v(dout0_184) AT=995.025n

.meas tran vdout0_185ck1980 FIND v(dout0_185) AT=995.025n

.meas tran vdout0_186ck1980 FIND v(dout0_186) AT=995.025n

.meas tran vdout0_187ck1980 FIND v(dout0_187) AT=995.025n

.meas tran vdout0_188ck1980 FIND v(dout0_188) AT=995.025n

.meas tran vdout0_189ck1980 FIND v(dout0_189) AT=995.025n

.meas tran vdout0_190ck1980 FIND v(dout0_190) AT=995.025n

.meas tran vdout0_191ck1980 FIND v(dout0_191) AT=995.025n

.meas tran vdout0_192ck1980 FIND v(dout0_192) AT=995.025n

.meas tran vdout0_193ck1980 FIND v(dout0_193) AT=995.025n

.meas tran vdout0_194ck1980 FIND v(dout0_194) AT=995.025n

.meas tran vdout0_195ck1980 FIND v(dout0_195) AT=995.025n

.meas tran vdout0_196ck1980 FIND v(dout0_196) AT=995.025n

.meas tran vdout0_197ck1980 FIND v(dout0_197) AT=995.025n

.meas tran vdout0_198ck1980 FIND v(dout0_198) AT=995.025n

.meas tran vdout0_199ck1980 FIND v(dout0_199) AT=995.025n

.meas tran vdout0_200ck1980 FIND v(dout0_200) AT=995.025n

.meas tran vdout0_201ck1980 FIND v(dout0_201) AT=995.025n

.meas tran vdout0_202ck1980 FIND v(dout0_202) AT=995.025n

.meas tran vdout0_203ck1980 FIND v(dout0_203) AT=995.025n

.meas tran vdout0_204ck1980 FIND v(dout0_204) AT=995.025n

.meas tran vdout0_205ck1980 FIND v(dout0_205) AT=995.025n

.meas tran vdout0_206ck1980 FIND v(dout0_206) AT=995.025n

.meas tran vdout0_207ck1980 FIND v(dout0_207) AT=995.025n

.meas tran vdout0_208ck1980 FIND v(dout0_208) AT=995.025n

.meas tran vdout0_209ck1980 FIND v(dout0_209) AT=995.025n

.meas tran vdout0_210ck1980 FIND v(dout0_210) AT=995.025n

.meas tran vdout0_211ck1980 FIND v(dout0_211) AT=995.025n

.meas tran vdout0_212ck1980 FIND v(dout0_212) AT=995.025n

.meas tran vdout0_213ck1980 FIND v(dout0_213) AT=995.025n

.meas tran vdout0_214ck1980 FIND v(dout0_214) AT=995.025n

.meas tran vdout0_215ck1980 FIND v(dout0_215) AT=995.025n

.meas tran vdout0_216ck1980 FIND v(dout0_216) AT=995.025n

.meas tran vdout0_217ck1980 FIND v(dout0_217) AT=995.025n

.meas tran vdout0_218ck1980 FIND v(dout0_218) AT=995.025n

.meas tran vdout0_219ck1980 FIND v(dout0_219) AT=995.025n

.meas tran vdout0_220ck1980 FIND v(dout0_220) AT=995.025n

.meas tran vdout0_221ck1980 FIND v(dout0_221) AT=995.025n

.meas tran vdout0_222ck1980 FIND v(dout0_222) AT=995.025n

.meas tran vdout0_223ck1980 FIND v(dout0_223) AT=995.025n

.meas tran vdout0_224ck1980 FIND v(dout0_224) AT=995.025n

.meas tran vdout0_225ck1980 FIND v(dout0_225) AT=995.025n

.meas tran vdout0_226ck1980 FIND v(dout0_226) AT=995.025n

.meas tran vdout0_227ck1980 FIND v(dout0_227) AT=995.025n

.meas tran vdout0_228ck1980 FIND v(dout0_228) AT=995.025n

.meas tran vdout0_229ck1980 FIND v(dout0_229) AT=995.025n

.meas tran vdout0_230ck1980 FIND v(dout0_230) AT=995.025n

.meas tran vdout0_231ck1980 FIND v(dout0_231) AT=995.025n

.meas tran vdout0_232ck1980 FIND v(dout0_232) AT=995.025n

.meas tran vdout0_233ck1980 FIND v(dout0_233) AT=995.025n

.meas tran vdout0_234ck1980 FIND v(dout0_234) AT=995.025n

.meas tran vdout0_235ck1980 FIND v(dout0_235) AT=995.025n

.meas tran vdout0_236ck1980 FIND v(dout0_236) AT=995.025n

.meas tran vdout0_237ck1980 FIND v(dout0_237) AT=995.025n

.meas tran vdout0_238ck1980 FIND v(dout0_238) AT=995.025n

.meas tran vdout0_239ck1980 FIND v(dout0_239) AT=995.025n

.meas tran vdout0_240ck1980 FIND v(dout0_240) AT=995.025n

.meas tran vdout0_241ck1980 FIND v(dout0_241) AT=995.025n

.meas tran vdout0_242ck1980 FIND v(dout0_242) AT=995.025n

.meas tran vdout0_243ck1980 FIND v(dout0_243) AT=995.025n

.meas tran vdout0_244ck1980 FIND v(dout0_244) AT=995.025n

.meas tran vdout0_245ck1980 FIND v(dout0_245) AT=995.025n

.meas tran vdout0_246ck1980 FIND v(dout0_246) AT=995.025n

.meas tran vdout0_247ck1980 FIND v(dout0_247) AT=995.025n

.meas tran vdout0_248ck1980 FIND v(dout0_248) AT=995.025n

.meas tran vdout0_249ck1980 FIND v(dout0_249) AT=995.025n

.meas tran vdout0_250ck1980 FIND v(dout0_250) AT=995.025n

.meas tran vdout0_251ck1980 FIND v(dout0_251) AT=995.025n

.meas tran vdout0_252ck1980 FIND v(dout0_252) AT=995.025n

.meas tran vdout0_253ck1980 FIND v(dout0_253) AT=995.025n

.meas tran vdout0_254ck1980 FIND v(dout0_254) AT=995.025n

.meas tran vdout0_255ck1980 FIND v(dout0_255) AT=995.025n

.meas tran vdout0_0ck2010 FIND v(dout0_0) AT=1010.025n

.meas tran vdout0_1ck2010 FIND v(dout0_1) AT=1010.025n

.meas tran vdout0_2ck2010 FIND v(dout0_2) AT=1010.025n

.meas tran vdout0_3ck2010 FIND v(dout0_3) AT=1010.025n

.meas tran vdout0_4ck2010 FIND v(dout0_4) AT=1010.025n

.meas tran vdout0_5ck2010 FIND v(dout0_5) AT=1010.025n

.meas tran vdout0_6ck2010 FIND v(dout0_6) AT=1010.025n

.meas tran vdout0_7ck2010 FIND v(dout0_7) AT=1010.025n

.meas tran vdout0_8ck2010 FIND v(dout0_8) AT=1010.025n

.meas tran vdout0_9ck2010 FIND v(dout0_9) AT=1010.025n

.meas tran vdout0_10ck2010 FIND v(dout0_10) AT=1010.025n

.meas tran vdout0_11ck2010 FIND v(dout0_11) AT=1010.025n

.meas tran vdout0_12ck2010 FIND v(dout0_12) AT=1010.025n

.meas tran vdout0_13ck2010 FIND v(dout0_13) AT=1010.025n

.meas tran vdout0_14ck2010 FIND v(dout0_14) AT=1010.025n

.meas tran vdout0_15ck2010 FIND v(dout0_15) AT=1010.025n

.meas tran vdout0_16ck2010 FIND v(dout0_16) AT=1010.025n

.meas tran vdout0_17ck2010 FIND v(dout0_17) AT=1010.025n

.meas tran vdout0_18ck2010 FIND v(dout0_18) AT=1010.025n

.meas tran vdout0_19ck2010 FIND v(dout0_19) AT=1010.025n

.meas tran vdout0_20ck2010 FIND v(dout0_20) AT=1010.025n

.meas tran vdout0_21ck2010 FIND v(dout0_21) AT=1010.025n

.meas tran vdout0_22ck2010 FIND v(dout0_22) AT=1010.025n

.meas tran vdout0_23ck2010 FIND v(dout0_23) AT=1010.025n

.meas tran vdout0_24ck2010 FIND v(dout0_24) AT=1010.025n

.meas tran vdout0_25ck2010 FIND v(dout0_25) AT=1010.025n

.meas tran vdout0_26ck2010 FIND v(dout0_26) AT=1010.025n

.meas tran vdout0_27ck2010 FIND v(dout0_27) AT=1010.025n

.meas tran vdout0_28ck2010 FIND v(dout0_28) AT=1010.025n

.meas tran vdout0_29ck2010 FIND v(dout0_29) AT=1010.025n

.meas tran vdout0_30ck2010 FIND v(dout0_30) AT=1010.025n

.meas tran vdout0_31ck2010 FIND v(dout0_31) AT=1010.025n

.meas tran vdout0_32ck2010 FIND v(dout0_32) AT=1010.025n

.meas tran vdout0_33ck2010 FIND v(dout0_33) AT=1010.025n

.meas tran vdout0_34ck2010 FIND v(dout0_34) AT=1010.025n

.meas tran vdout0_35ck2010 FIND v(dout0_35) AT=1010.025n

.meas tran vdout0_36ck2010 FIND v(dout0_36) AT=1010.025n

.meas tran vdout0_37ck2010 FIND v(dout0_37) AT=1010.025n

.meas tran vdout0_38ck2010 FIND v(dout0_38) AT=1010.025n

.meas tran vdout0_39ck2010 FIND v(dout0_39) AT=1010.025n

.meas tran vdout0_40ck2010 FIND v(dout0_40) AT=1010.025n

.meas tran vdout0_41ck2010 FIND v(dout0_41) AT=1010.025n

.meas tran vdout0_42ck2010 FIND v(dout0_42) AT=1010.025n

.meas tran vdout0_43ck2010 FIND v(dout0_43) AT=1010.025n

.meas tran vdout0_44ck2010 FIND v(dout0_44) AT=1010.025n

.meas tran vdout0_45ck2010 FIND v(dout0_45) AT=1010.025n

.meas tran vdout0_46ck2010 FIND v(dout0_46) AT=1010.025n

.meas tran vdout0_47ck2010 FIND v(dout0_47) AT=1010.025n

.meas tran vdout0_48ck2010 FIND v(dout0_48) AT=1010.025n

.meas tran vdout0_49ck2010 FIND v(dout0_49) AT=1010.025n

.meas tran vdout0_50ck2010 FIND v(dout0_50) AT=1010.025n

.meas tran vdout0_51ck2010 FIND v(dout0_51) AT=1010.025n

.meas tran vdout0_52ck2010 FIND v(dout0_52) AT=1010.025n

.meas tran vdout0_53ck2010 FIND v(dout0_53) AT=1010.025n

.meas tran vdout0_54ck2010 FIND v(dout0_54) AT=1010.025n

.meas tran vdout0_55ck2010 FIND v(dout0_55) AT=1010.025n

.meas tran vdout0_56ck2010 FIND v(dout0_56) AT=1010.025n

.meas tran vdout0_57ck2010 FIND v(dout0_57) AT=1010.025n

.meas tran vdout0_58ck2010 FIND v(dout0_58) AT=1010.025n

.meas tran vdout0_59ck2010 FIND v(dout0_59) AT=1010.025n

.meas tran vdout0_60ck2010 FIND v(dout0_60) AT=1010.025n

.meas tran vdout0_61ck2010 FIND v(dout0_61) AT=1010.025n

.meas tran vdout0_62ck2010 FIND v(dout0_62) AT=1010.025n

.meas tran vdout0_63ck2010 FIND v(dout0_63) AT=1010.025n

.meas tran vdout0_64ck2010 FIND v(dout0_64) AT=1010.025n

.meas tran vdout0_65ck2010 FIND v(dout0_65) AT=1010.025n

.meas tran vdout0_66ck2010 FIND v(dout0_66) AT=1010.025n

.meas tran vdout0_67ck2010 FIND v(dout0_67) AT=1010.025n

.meas tran vdout0_68ck2010 FIND v(dout0_68) AT=1010.025n

.meas tran vdout0_69ck2010 FIND v(dout0_69) AT=1010.025n

.meas tran vdout0_70ck2010 FIND v(dout0_70) AT=1010.025n

.meas tran vdout0_71ck2010 FIND v(dout0_71) AT=1010.025n

.meas tran vdout0_72ck2010 FIND v(dout0_72) AT=1010.025n

.meas tran vdout0_73ck2010 FIND v(dout0_73) AT=1010.025n

.meas tran vdout0_74ck2010 FIND v(dout0_74) AT=1010.025n

.meas tran vdout0_75ck2010 FIND v(dout0_75) AT=1010.025n

.meas tran vdout0_76ck2010 FIND v(dout0_76) AT=1010.025n

.meas tran vdout0_77ck2010 FIND v(dout0_77) AT=1010.025n

.meas tran vdout0_78ck2010 FIND v(dout0_78) AT=1010.025n

.meas tran vdout0_79ck2010 FIND v(dout0_79) AT=1010.025n

.meas tran vdout0_80ck2010 FIND v(dout0_80) AT=1010.025n

.meas tran vdout0_81ck2010 FIND v(dout0_81) AT=1010.025n

.meas tran vdout0_82ck2010 FIND v(dout0_82) AT=1010.025n

.meas tran vdout0_83ck2010 FIND v(dout0_83) AT=1010.025n

.meas tran vdout0_84ck2010 FIND v(dout0_84) AT=1010.025n

.meas tran vdout0_85ck2010 FIND v(dout0_85) AT=1010.025n

.meas tran vdout0_86ck2010 FIND v(dout0_86) AT=1010.025n

.meas tran vdout0_87ck2010 FIND v(dout0_87) AT=1010.025n

.meas tran vdout0_88ck2010 FIND v(dout0_88) AT=1010.025n

.meas tran vdout0_89ck2010 FIND v(dout0_89) AT=1010.025n

.meas tran vdout0_90ck2010 FIND v(dout0_90) AT=1010.025n

.meas tran vdout0_91ck2010 FIND v(dout0_91) AT=1010.025n

.meas tran vdout0_92ck2010 FIND v(dout0_92) AT=1010.025n

.meas tran vdout0_93ck2010 FIND v(dout0_93) AT=1010.025n

.meas tran vdout0_94ck2010 FIND v(dout0_94) AT=1010.025n

.meas tran vdout0_95ck2010 FIND v(dout0_95) AT=1010.025n

.meas tran vdout0_96ck2010 FIND v(dout0_96) AT=1010.025n

.meas tran vdout0_97ck2010 FIND v(dout0_97) AT=1010.025n

.meas tran vdout0_98ck2010 FIND v(dout0_98) AT=1010.025n

.meas tran vdout0_99ck2010 FIND v(dout0_99) AT=1010.025n

.meas tran vdout0_100ck2010 FIND v(dout0_100) AT=1010.025n

.meas tran vdout0_101ck2010 FIND v(dout0_101) AT=1010.025n

.meas tran vdout0_102ck2010 FIND v(dout0_102) AT=1010.025n

.meas tran vdout0_103ck2010 FIND v(dout0_103) AT=1010.025n

.meas tran vdout0_104ck2010 FIND v(dout0_104) AT=1010.025n

.meas tran vdout0_105ck2010 FIND v(dout0_105) AT=1010.025n

.meas tran vdout0_106ck2010 FIND v(dout0_106) AT=1010.025n

.meas tran vdout0_107ck2010 FIND v(dout0_107) AT=1010.025n

.meas tran vdout0_108ck2010 FIND v(dout0_108) AT=1010.025n

.meas tran vdout0_109ck2010 FIND v(dout0_109) AT=1010.025n

.meas tran vdout0_110ck2010 FIND v(dout0_110) AT=1010.025n

.meas tran vdout0_111ck2010 FIND v(dout0_111) AT=1010.025n

.meas tran vdout0_112ck2010 FIND v(dout0_112) AT=1010.025n

.meas tran vdout0_113ck2010 FIND v(dout0_113) AT=1010.025n

.meas tran vdout0_114ck2010 FIND v(dout0_114) AT=1010.025n

.meas tran vdout0_115ck2010 FIND v(dout0_115) AT=1010.025n

.meas tran vdout0_116ck2010 FIND v(dout0_116) AT=1010.025n

.meas tran vdout0_117ck2010 FIND v(dout0_117) AT=1010.025n

.meas tran vdout0_118ck2010 FIND v(dout0_118) AT=1010.025n

.meas tran vdout0_119ck2010 FIND v(dout0_119) AT=1010.025n

.meas tran vdout0_120ck2010 FIND v(dout0_120) AT=1010.025n

.meas tran vdout0_121ck2010 FIND v(dout0_121) AT=1010.025n

.meas tran vdout0_122ck2010 FIND v(dout0_122) AT=1010.025n

.meas tran vdout0_123ck2010 FIND v(dout0_123) AT=1010.025n

.meas tran vdout0_124ck2010 FIND v(dout0_124) AT=1010.025n

.meas tran vdout0_125ck2010 FIND v(dout0_125) AT=1010.025n

.meas tran vdout0_126ck2010 FIND v(dout0_126) AT=1010.025n

.meas tran vdout0_127ck2010 FIND v(dout0_127) AT=1010.025n

.meas tran vdout0_128ck2010 FIND v(dout0_128) AT=1010.025n

.meas tran vdout0_129ck2010 FIND v(dout0_129) AT=1010.025n

.meas tran vdout0_130ck2010 FIND v(dout0_130) AT=1010.025n

.meas tran vdout0_131ck2010 FIND v(dout0_131) AT=1010.025n

.meas tran vdout0_132ck2010 FIND v(dout0_132) AT=1010.025n

.meas tran vdout0_133ck2010 FIND v(dout0_133) AT=1010.025n

.meas tran vdout0_134ck2010 FIND v(dout0_134) AT=1010.025n

.meas tran vdout0_135ck2010 FIND v(dout0_135) AT=1010.025n

.meas tran vdout0_136ck2010 FIND v(dout0_136) AT=1010.025n

.meas tran vdout0_137ck2010 FIND v(dout0_137) AT=1010.025n

.meas tran vdout0_138ck2010 FIND v(dout0_138) AT=1010.025n

.meas tran vdout0_139ck2010 FIND v(dout0_139) AT=1010.025n

.meas tran vdout0_140ck2010 FIND v(dout0_140) AT=1010.025n

.meas tran vdout0_141ck2010 FIND v(dout0_141) AT=1010.025n

.meas tran vdout0_142ck2010 FIND v(dout0_142) AT=1010.025n

.meas tran vdout0_143ck2010 FIND v(dout0_143) AT=1010.025n

.meas tran vdout0_144ck2010 FIND v(dout0_144) AT=1010.025n

.meas tran vdout0_145ck2010 FIND v(dout0_145) AT=1010.025n

.meas tran vdout0_146ck2010 FIND v(dout0_146) AT=1010.025n

.meas tran vdout0_147ck2010 FIND v(dout0_147) AT=1010.025n

.meas tran vdout0_148ck2010 FIND v(dout0_148) AT=1010.025n

.meas tran vdout0_149ck2010 FIND v(dout0_149) AT=1010.025n

.meas tran vdout0_150ck2010 FIND v(dout0_150) AT=1010.025n

.meas tran vdout0_151ck2010 FIND v(dout0_151) AT=1010.025n

.meas tran vdout0_152ck2010 FIND v(dout0_152) AT=1010.025n

.meas tran vdout0_153ck2010 FIND v(dout0_153) AT=1010.025n

.meas tran vdout0_154ck2010 FIND v(dout0_154) AT=1010.025n

.meas tran vdout0_155ck2010 FIND v(dout0_155) AT=1010.025n

.meas tran vdout0_156ck2010 FIND v(dout0_156) AT=1010.025n

.meas tran vdout0_157ck2010 FIND v(dout0_157) AT=1010.025n

.meas tran vdout0_158ck2010 FIND v(dout0_158) AT=1010.025n

.meas tran vdout0_159ck2010 FIND v(dout0_159) AT=1010.025n

.meas tran vdout0_160ck2010 FIND v(dout0_160) AT=1010.025n

.meas tran vdout0_161ck2010 FIND v(dout0_161) AT=1010.025n

.meas tran vdout0_162ck2010 FIND v(dout0_162) AT=1010.025n

.meas tran vdout0_163ck2010 FIND v(dout0_163) AT=1010.025n

.meas tran vdout0_164ck2010 FIND v(dout0_164) AT=1010.025n

.meas tran vdout0_165ck2010 FIND v(dout0_165) AT=1010.025n

.meas tran vdout0_166ck2010 FIND v(dout0_166) AT=1010.025n

.meas tran vdout0_167ck2010 FIND v(dout0_167) AT=1010.025n

.meas tran vdout0_168ck2010 FIND v(dout0_168) AT=1010.025n

.meas tran vdout0_169ck2010 FIND v(dout0_169) AT=1010.025n

.meas tran vdout0_170ck2010 FIND v(dout0_170) AT=1010.025n

.meas tran vdout0_171ck2010 FIND v(dout0_171) AT=1010.025n

.meas tran vdout0_172ck2010 FIND v(dout0_172) AT=1010.025n

.meas tran vdout0_173ck2010 FIND v(dout0_173) AT=1010.025n

.meas tran vdout0_174ck2010 FIND v(dout0_174) AT=1010.025n

.meas tran vdout0_175ck2010 FIND v(dout0_175) AT=1010.025n

.meas tran vdout0_176ck2010 FIND v(dout0_176) AT=1010.025n

.meas tran vdout0_177ck2010 FIND v(dout0_177) AT=1010.025n

.meas tran vdout0_178ck2010 FIND v(dout0_178) AT=1010.025n

.meas tran vdout0_179ck2010 FIND v(dout0_179) AT=1010.025n

.meas tran vdout0_180ck2010 FIND v(dout0_180) AT=1010.025n

.meas tran vdout0_181ck2010 FIND v(dout0_181) AT=1010.025n

.meas tran vdout0_182ck2010 FIND v(dout0_182) AT=1010.025n

.meas tran vdout0_183ck2010 FIND v(dout0_183) AT=1010.025n

.meas tran vdout0_184ck2010 FIND v(dout0_184) AT=1010.025n

.meas tran vdout0_185ck2010 FIND v(dout0_185) AT=1010.025n

.meas tran vdout0_186ck2010 FIND v(dout0_186) AT=1010.025n

.meas tran vdout0_187ck2010 FIND v(dout0_187) AT=1010.025n

.meas tran vdout0_188ck2010 FIND v(dout0_188) AT=1010.025n

.meas tran vdout0_189ck2010 FIND v(dout0_189) AT=1010.025n

.meas tran vdout0_190ck2010 FIND v(dout0_190) AT=1010.025n

.meas tran vdout0_191ck2010 FIND v(dout0_191) AT=1010.025n

.meas tran vdout0_192ck2010 FIND v(dout0_192) AT=1010.025n

.meas tran vdout0_193ck2010 FIND v(dout0_193) AT=1010.025n

.meas tran vdout0_194ck2010 FIND v(dout0_194) AT=1010.025n

.meas tran vdout0_195ck2010 FIND v(dout0_195) AT=1010.025n

.meas tran vdout0_196ck2010 FIND v(dout0_196) AT=1010.025n

.meas tran vdout0_197ck2010 FIND v(dout0_197) AT=1010.025n

.meas tran vdout0_198ck2010 FIND v(dout0_198) AT=1010.025n

.meas tran vdout0_199ck2010 FIND v(dout0_199) AT=1010.025n

.meas tran vdout0_200ck2010 FIND v(dout0_200) AT=1010.025n

.meas tran vdout0_201ck2010 FIND v(dout0_201) AT=1010.025n

.meas tran vdout0_202ck2010 FIND v(dout0_202) AT=1010.025n

.meas tran vdout0_203ck2010 FIND v(dout0_203) AT=1010.025n

.meas tran vdout0_204ck2010 FIND v(dout0_204) AT=1010.025n

.meas tran vdout0_205ck2010 FIND v(dout0_205) AT=1010.025n

.meas tran vdout0_206ck2010 FIND v(dout0_206) AT=1010.025n

.meas tran vdout0_207ck2010 FIND v(dout0_207) AT=1010.025n

.meas tran vdout0_208ck2010 FIND v(dout0_208) AT=1010.025n

.meas tran vdout0_209ck2010 FIND v(dout0_209) AT=1010.025n

.meas tran vdout0_210ck2010 FIND v(dout0_210) AT=1010.025n

.meas tran vdout0_211ck2010 FIND v(dout0_211) AT=1010.025n

.meas tran vdout0_212ck2010 FIND v(dout0_212) AT=1010.025n

.meas tran vdout0_213ck2010 FIND v(dout0_213) AT=1010.025n

.meas tran vdout0_214ck2010 FIND v(dout0_214) AT=1010.025n

.meas tran vdout0_215ck2010 FIND v(dout0_215) AT=1010.025n

.meas tran vdout0_216ck2010 FIND v(dout0_216) AT=1010.025n

.meas tran vdout0_217ck2010 FIND v(dout0_217) AT=1010.025n

.meas tran vdout0_218ck2010 FIND v(dout0_218) AT=1010.025n

.meas tran vdout0_219ck2010 FIND v(dout0_219) AT=1010.025n

.meas tran vdout0_220ck2010 FIND v(dout0_220) AT=1010.025n

.meas tran vdout0_221ck2010 FIND v(dout0_221) AT=1010.025n

.meas tran vdout0_222ck2010 FIND v(dout0_222) AT=1010.025n

.meas tran vdout0_223ck2010 FIND v(dout0_223) AT=1010.025n

.meas tran vdout0_224ck2010 FIND v(dout0_224) AT=1010.025n

.meas tran vdout0_225ck2010 FIND v(dout0_225) AT=1010.025n

.meas tran vdout0_226ck2010 FIND v(dout0_226) AT=1010.025n

.meas tran vdout0_227ck2010 FIND v(dout0_227) AT=1010.025n

.meas tran vdout0_228ck2010 FIND v(dout0_228) AT=1010.025n

.meas tran vdout0_229ck2010 FIND v(dout0_229) AT=1010.025n

.meas tran vdout0_230ck2010 FIND v(dout0_230) AT=1010.025n

.meas tran vdout0_231ck2010 FIND v(dout0_231) AT=1010.025n

.meas tran vdout0_232ck2010 FIND v(dout0_232) AT=1010.025n

.meas tran vdout0_233ck2010 FIND v(dout0_233) AT=1010.025n

.meas tran vdout0_234ck2010 FIND v(dout0_234) AT=1010.025n

.meas tran vdout0_235ck2010 FIND v(dout0_235) AT=1010.025n

.meas tran vdout0_236ck2010 FIND v(dout0_236) AT=1010.025n

.meas tran vdout0_237ck2010 FIND v(dout0_237) AT=1010.025n

.meas tran vdout0_238ck2010 FIND v(dout0_238) AT=1010.025n

.meas tran vdout0_239ck2010 FIND v(dout0_239) AT=1010.025n

.meas tran vdout0_240ck2010 FIND v(dout0_240) AT=1010.025n

.meas tran vdout0_241ck2010 FIND v(dout0_241) AT=1010.025n

.meas tran vdout0_242ck2010 FIND v(dout0_242) AT=1010.025n

.meas tran vdout0_243ck2010 FIND v(dout0_243) AT=1010.025n

.meas tran vdout0_244ck2010 FIND v(dout0_244) AT=1010.025n

.meas tran vdout0_245ck2010 FIND v(dout0_245) AT=1010.025n

.meas tran vdout0_246ck2010 FIND v(dout0_246) AT=1010.025n

.meas tran vdout0_247ck2010 FIND v(dout0_247) AT=1010.025n

.meas tran vdout0_248ck2010 FIND v(dout0_248) AT=1010.025n

.meas tran vdout0_249ck2010 FIND v(dout0_249) AT=1010.025n

.meas tran vdout0_250ck2010 FIND v(dout0_250) AT=1010.025n

.meas tran vdout0_251ck2010 FIND v(dout0_251) AT=1010.025n

.meas tran vdout0_252ck2010 FIND v(dout0_252) AT=1010.025n

.meas tran vdout0_253ck2010 FIND v(dout0_253) AT=1010.025n

.meas tran vdout0_254ck2010 FIND v(dout0_254) AT=1010.025n

.meas tran vdout0_255ck2010 FIND v(dout0_255) AT=1010.025n
